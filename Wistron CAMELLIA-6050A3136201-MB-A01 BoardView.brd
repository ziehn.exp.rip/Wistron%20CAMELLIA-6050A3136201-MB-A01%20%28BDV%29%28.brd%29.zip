# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Library data of the parts (continued)
C2762-C2764 = CSC0603: part number: CSC0603-47UF_4V_3,6010B0245002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAP-CHIP-47UF-4V-K-X5R-0603-TAP; signal model: C2_6010B0245002_47UF_4V_3; room: Sheet51
C2772 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet51
C2815 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet55
C2900 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet53
C3000 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet58
C3001 C3006 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet58
C3003 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet58
C3009-C3014 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet58; signal model: C2_6010A0036403_0_1uF_16V_2
C3015-C3018 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet58
C3150 C3152 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet49
C3151 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet49
C3302 C3304-C3313 C3315 C3316 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet48
C3369 C3375 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet48
C3503 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet65
C3504 C3506 C3540 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet65
C3800 C3803 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet73
C3801 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet73
C3802 C3804 = CSC0201: part number: CSC0201-0.1UF_25V_1,6010B0293301,CSC_060X030X033_2,0.48MM,CSC0201,CAP,0.1UF,25V,0201,X5R; signal model: C2_6010B0293301_6_8PF_50V_1; room: Sheet73
C4100-C4103 C4108 C4112 C4114 C4116 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet46
C4104 C4110 C4119 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet46; signal model: C2_6010A0036403_0_1uF_16V_2
C4105 C4111 C4115 C4121 C4123 C4131 C4137 C4146 C4151 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet46
C4107 C4109 C4113 C4117 C4118 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet46
C4122 C4124 = CSC0201: part number: CSC0201-0.022UF_6.3V_1,6010B0058112,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.022UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0058112_0_022uF_6_3V_1; room: Sheet38
C4125-C4128 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet47
C4129 C4135 C4136 C4139 C4142 C4144 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet47; signal model: C2_6010A0036403_0_1uF_16V_2
C4130 C4134 C4138 C4145 C4147-C4150 C4152 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet47
C4132 C4133 C4140 C4141 C4143 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet47
C4350 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet68
C4351 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet68
C4411 C4413 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet29
C4412 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet29
C4500 C4501 C4505 C4516 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet44
C4502 C4503 C4507 C4508 C4649 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet44
C4504 C4517-C4519 C4531 C4534 C4536 C4538 C4539 C4541 C4545 C4547-C4549 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet42
C4506 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet44
C4509-C4511 C4522 C4528 C4553 C4566-C4568 C4577 C4585-C4587 C4597-C4601 C4607-C4611 C4620-C4623 C4645-C4648 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet44
C4512 C4515 C4521 C4525-C4527 C4602-C4606 C4624 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet44
C4513 C4523 C4533 C4540 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet42
C4514 = CSC0201: part number: CSC0201-47PF_50V_1,6010B0058118,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,47PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058118_47pF_50V_1; room: Sheet33
C4520 C4524 C4530 C4535 C4542 C4546 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet42
C4529 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet44
C4532 C4543 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet42
C4544 = CSC0603: part number: CSC0603-4.7UF_10V_3,6010B0067401,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,10V,K,X5R,0603,TR; signal model: C2_6010B0067401_4_7uF_10V_3; room: Sheet42
C4550-C4552 C4554 C4555 C4558-C4565 C4588-C4590 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet43
C4556 C4591 C4592 C4626 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet44
C4557 C4569 C4572-C4576 C4578-C4584 C4593-C4596 C4628-C4631 C4636-C4644 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet43
C4570 C4571 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet43
C4612-C4619 C4632-C4635 C4820 C4821 = CSC0201: part number: CSC0201-0.22UF_6.3V_1,6010B0058114,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.22UF,6.3V,M,X5R,0201,TR; signal model: C2_6010B0058114_0_22uF_6_3V_1; room: Sheet39
C4625 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet44
C4627 C4650-C4652 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet39
C4764 C4766 C4768 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet41
C4767 C4788 C4828 = CSC0201: part number: CSC0201-12PF_50V_1,6010B0058102,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,12PF_50V,J,C0G,0201,TR; signal model: C2_6010B0058102_12pF_50V_1; room: Sheet41
C4818 C4819 = CSC0201: part number: CSC0201-0.22UF_6.3V_1,6010B0058114,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.22UF,6.3V,M,X5R,0201,TR; signal model: C2_6010B0058114_0_22uF_6_3V_1; room: Sheet39; signal model: C2_6010A0036403_0_1uF_16V_2
C4826 = CSC0201: part number: CSC0201-15PF_25V_1,6010B0233701,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,15PF,25V,J,C0G,0201,TR; signal model: C2_6010B0233701_15pF_25V_1; room: Sheet41
C4920 C4921 = CSC0402: part number: CSC0402-1UF_6.3V_2_NP,6010B0392101_NP,CSC_100X050X055_2_NP,0.0003MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_NP_1uF_6_3V_2_NP; room: Sheet31
C4937 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet31
C6035 C6037 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet25
C6038 = CSC0201: part number: CSC0201-0.01UF_25V_1,6010B0334301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,0.01UF,25V,K,X5R,0201,TR; signal model: C2_6010B0334301_0_01UF_25V_1; room: Sheet25
C7000 C7002 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet26
C7001 = CSC0201: part number: CSC0201-0.22UF_6.3V_1,6010B0058114,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.22UF,6.3V,M,X5R,0201,TR; signal model: C2_6010B0058114_0_22uF_6_3V_1; room: Sheet27
C7003 C7005 C7008 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet26
C7004 C7006 C7007 C7010 C7012 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet26
C7009 C7027 = CSC0201: part number: CSC0201-0.01UF_25V_1,6010B0334301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,0.01UF,25V,K,X5R,0201,TR; signal model: C2_6010B0334301_0_01UF_25V_1; room: Sheet27
C7013 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet26
C7023 = CSC0201: part number: CSC0201-0.1UF_25V_1,6010B0293301,CSC_060X030X033_2,0.48MM,CSC0201,CAP,0.1UF,25V,0201,X5R; signal model: C2_6010B0293301_6_8PF_50V_1; room: Sheet27
C7024 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet27
C7025 = CSC0402: part number: CSC0402-3300PF_50V_2,6010A0025701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-332-K,50V-X7R-0402-TAP; signal model: C2_6010A0025701_3300pF_50V_2; room: Sheet27
C7029 = CSC0402: part number: CSC0402-0.01UF_25V_2,6010B0063701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,25V,J,X7R,0402,TR; signal model: C2_6010B0063701_0_01uF_25V_2; room: Sheet27
C7040 C7041 = CSC0201: part number: CSC0201-220PF_50V_1,6010B0348201,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,220PF,50V,K,X5R,0201,TR; signal model: C2_6010B0348201_220pF_50V_1; room: Sheet26
C7400 = CSC0201: part number: CSC0201-0.01UF_25V_1,6010B0334301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,0.01UF,25V,K,X5R,0201,TR; signal model: C2_6010B0334301_0_01UF_25V_1; room: Sheet28
C7401 = CSC0402: part number: CSC0402-3300PF_50V_2,6010A0025701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-332-K,50V-X7R-0402-TAP; signal model: C2_6010A0025701_3300pF_50V_2; room: Sheet28
C7402 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet28
C7403 = CSC0201: part number: CSC0201-0.22UF_6.3V_1,6010B0058114,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.22UF,6.3V,M,X5R,0201,TR; signal model: C2_6010B0058114_0_22uF_6_3V_1; room: Sheet28
C7500 C7501 C7503 = CSC0201: part number: CSC0201-100PF_50V_1,6010B0058101,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,100PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058101_100pF_50V_1; room: Sheet25
C7502 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet25
C7504 = CSC0201: part number: CSC0201-470PF_50V_1,6010B0535901,CSC_060X030X033_2,0.43MM,CSC0201,CAPACITOR-CHIP,470PF,50V,K,X7R,0201,TR; signal model: C2_6010B0535901_470PF_50V_1; room: Sheet77
C7505-C7507 = CSC0201: part number: CSC0201-18PF_50V_1,6010B0058106,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,18PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058106_18pF_50V_1; room: Sheet77
C7508 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet77
C7511-C7519 C7521 C7524 C7527 C7531 C7534 C7556 C7559 C7562 C7568 = CSC0201: part number: CSC0201-68PF_50V_1,6010B0544001,CSC_060X030X033_2,0.43MM,CSC0201,CAPACITOR-CHIP,68PF,50V,J,C0G,0201,TR; signal model: C2_6010B0544001_68pF_50V_1; room: Sheet77
C7520 C7523 C7526 C7529 C7533 C7555 C7558 C7561 C7567 = CSC0201: part number: CSC0201-10PF_50V_1,6010B0058120,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,10PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058120_10pF_50V_1; room: Sheet77
C7522 C7525 C7528 C7532 C7535 C7560 C7563-C7566 = CSC0201: part number: CSC0201-100PF_50V_1,6010B0058101,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,100PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058101_100pF_50V_1; room: Sheet77
C7530 = CSC0201: part number: CSC0201-CSC0201,CSC0201,CSC_060X030X030_2,0.45MM,CSC0201,CSC0201; signal model: C2_CSC0201_CSC0201; room: Sheet63; signal model: C2_CSC0402_DY_CSC0402_DY
C7536-C7554 = CSC0201: part number: CSC0201-6.8PF_50V_1,6010B0153301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP_6_8PF_50V_D_C0G_0201_TR; signal model: C2_6010B0153301_6_8PF_50V_1; room: Sheet77
C7557 = CSC0201: part number: CSC0201-0.1UF_25V_1,6010B0293301,CSC_060X030X033_2,0.48MM,CSC0201,CAP,0.1UF,25V,0201,X5R; signal model: C2_6010B0293301_6_8PF_50V_1; room: Sheet77
C7600 C7601 C7604 C7605 C7608-C7610 C7628 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet76
C7602 C7603 C7606 C7607 = CSC0201: part number: CSC0201-0.22UF_25V_1,6010B0536801,CSC_060X030X033_2,0.43MM,CSC0201,CAPACITOR-CHIP,0.22UF,25V,K,X5R,0201,TR; signal model: C2_6010B0536801_0_22uF_25V_1; room: Sheet76
C7611-C7622 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet76
C7623 = CSC0201: part number: CSC0201-0.01UF_25V_1,6010B0334301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,0.01UF,25V,K,X5R,0201,TR; signal model: C2_6010B0334301_0_01UF_25V_1; room: Sheet76
C7624 C7625 = CSC0201: part number: CSC0201-10PF_50V_1,6010B0058120,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,10PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058120_10pF_50V_1; room: Sheet76
C7626 C7627 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet76
C9200-C9202 C9204 C9209-C9212 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet80
C9203 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet80
C9205 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet80
C9206 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet80
C9207 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet81
C9208 = CAP_TA_SP: part number: CAP_TA_SP-100UF_6.3V,6010B0154501,CST_320X160X180_2_245,1.95MM,CAP_TA_SP,,,CAPACITOR-TA-SP,100UF,6.3V,M,85C,AX1.6,SMD,TR,45MOHM; signal model: C2_6010B0154501_100uF_6_3V; room: Sheet80
C9213-C9215 C9217 C9222-C9225 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet81
C9216 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet81
C9218 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet81
C9226-C9228 = CSC0201: part number: CSC0201-100PF_50V_1,6010B0058101,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,100PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058101_100pF_50V_1; room: Sheet82
C9229 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet82
C9300 C9301 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet85
C9302 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet84
C9353 C9357 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet83
C9354 C9360 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet83
C60000 = CAP_AL: part number: CAP_AL-68UF_16V,6010B0226501,CS_730X430X200_2_610,2.15MM,CAP_AL,,,CAPACITOR-AL-SP,68UF,16V,M,105C,DX1.9,SMD,TR,50MOHM; signal model: C2_6010B0226501_68uF_16V; room: Sheet7
C60001 C60002 C60011 = CSC0805: part number: CSC0805-4.7UF_25V_5,6010B0048902,CSC_200X125X135_2,1.45MM,CSC0805,0805,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0805,TR; signal model: C2_6010B0048902_4_7uF_25V_5; room: Sheet7
C60003 C60004 = CSC0603: part number: CSC0603-2.2UF_25V_3,6010B1113401,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,2.2UF,25V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B1113401_2_2uF_25V_3; room: Sheet7
C60006 C60020 = CSC0402: part number: CSC0402-0.022UF_16V_2,6010A0000101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-223-K,16V-X7R-0402-TAP; signal model: C2_6010A0000101_0_022uF_16V_2; room: Sheet7
C60007 C60016 C60018 C60019 C60021 C60024 C60026 C60029-C60031 C60033 C60050 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet7
C60008 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet7
C60009 = CSC0603: part number: CSC0603-4.7UF_25V_3,6010B0322201,CSC_160X080X095_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0322201_4_7uF_25V_3; room: Sheet7
C60010 C60017 C60032 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet7
C60012 = CSC0805: part number: CSC0805-CSC0805,CSC0805,CSC_200X125X130_2,1.45MM,CSC0805,0805,,CSC0805; signal model: C2_CSC0805_CSC0805; room: Sheet7
C60013 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet7
C60014 C60048 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet7
C60015 C60025 = CSC0603: part number: CSC0603-0.22UF_25V_3,6010B0027101,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,0.22UF,25V,K,X5R,0603,TR; signal model: C2_6010B0027101_0_22uF_25V_3; room: Sheet7
C60022 C60035 = CSC0603: part number: CSC0603-2.2UF_6.3V_3,6010B0392401,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,2.2UF,6.3V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0392401_2_2UF_6_3V_3; room: Sheet7
C60023 C60028 C60034 = CSC0402: part number: CSC0402-1UF_25V_2,6010B0455901,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,25V,K,X5R,0402,TR,0.5MM; signal model: C2_6010B0455901_1UF_25V_2; room: Sheet7
C60027 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet7
C60049 = CSC0402: part number: CSC0402-10PF_50V_2,6010A0025401,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_10pF_50V_2; room: Sheet7
C60099 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet7
C60101-C60104 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet12
C60109 C60191 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet12
C60110 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet12
C60111 = CSC0603: part number: CSC0603-4.7UF_25V_3,6010B0322201,CSC_160X080X095_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0322201_4_7uF_25V_3; room: Sheet12
C60112 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet12
C60115 C60190 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet12
C60116 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet12
C60200 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet10
C60201-C60204 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040703,CSC_200X125X140_2,1.5MM,CSC0805,0805,X5R,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0805,TR,1.25MM; signal model: C2_6010A0040703_22UF_6_3V_5; room: Sheet10
C60205 = CAP_TA_SP: part number: CAP_TA_SP-100UF_6.3V,6010B0154501,CST_320X160X180_2_245,1.95MM,CAP_TA_SP,,,CAPACITOR-TA-SP,100UF,6.3V,M,85C,AX1.6,SMD,TR,45MOHM; signal model: C2_6010B0154501_100uF_6_3V; room: Sheet10
C60209 C60217 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet10
C60210 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet10
C60211 = CSC0603: part number: CSC0603-10UF_25V_3,6010B0366801,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,25V,M,X5R,0603,TR; signal model: C2_6010B0366801_10uF_25V_3; room: Sheet10
C60212 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet10
C60215 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet10
C60216 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet10
C60250-C60253 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040703,CSC_200X125X140_2,1.5MM,CSC0805,0805,X5R,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0805,TR,1.25MM; signal model: C2_6010A0040703_22UF_6_3V_5; room: Sheet11
C60254 = CAP_TA_SP: part number: CAP_TA_SP-100UF_6.3V,6010B0154501,CST_320X160X180_2_245,1.95MM,CAP_TA_SP,,,CAPACITOR-TA-SP,100UF,6.3V,M,85C,AX1.6,SMD,TR,45MOHM; signal model: C2_6010B0154501_100uF_6_3V; room: Sheet11
C60259 C60280 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet11
C60260 C60261 = CSC0805: part number: CSC0805-4.7UF_25V_5,6010B0048902,CSC_200X125X135_2,1.45MM,CSC0805,0805,,CAPACITOR-CHIP,4.7UF,25V,K,X5R,0805,TR; signal model: C2_6010B0048902_4_7uF_25V_5; room: Sheet11
C60262 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet11
C60263 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet11
C60265 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet11
C60266 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet11
C60281 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet11
C60300-C60302 C60350 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet13
C60303 C60304 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet13
C60309 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet13
C60310 C60313 = CSC0603: part number: CSC0603-10UF_25V_3,6010B0366801,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,25V,M,X5R,0603,TR; signal model: C2_6010B0366801_10uF_25V_3; room: Sheet13
C60311 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet13
C60312 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet13
C60315 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet13
C60316 C60348 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet13
C60351 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet13
C60400 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet14
C60401 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet14
C60405 = CSC0402: part number: CSC0402-22PF_50V_2,6010072202AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAPACITOR-CHIP,22PF,50V,J,C0G,0402,TR; signal model: C2_6010072202AT_22pF_50V_2; room: Sheet14
C60410 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet14
C60500-C60502 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet18
C60509 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet18
C60510 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet18
C60511 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet18
C60515 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet18
C60516 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet18
C60600-C60602 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet15
C60603 C60604 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet15
C60609 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet15
C60610 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet15
C60611 = CSC0805: part number: CSC0805-CSC0805,CSC0805,CSC_200X125X130_2,1.45MM,CSC0805,0805,,CSC0805; signal model: C2_CSC0805_CSC0805; room: Sheet15
C60612 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet15
C60615 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet15
C60616 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet15
C60620 = CSC0402: part number: CSC0402-220PF_50V_2,6010B0076701,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2; room: Sheet15
C60630 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet15
C60900-C60902 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet17
C60903 C60904 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet17
C60909 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet17
C60910 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet17
C60911 = CSC0805: part number: CSC0805-CSC0805,CSC0805,CSC_200X125X130_2,1.45MM,CSC0805,0805,,CSC0805; signal model: C2_CSC0805_CSC0805; room: Sheet17
C60912 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet17
C60915 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet17
C60916 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet17
C60920 = CSC0402: part number: CSC0402-330PF_50V_2,6010A0010301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-331-J,50V-X7R-0402-TAP; signal model: C2_6010A0010301_330pF_50V_2; room: Sheet17
C60930 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet17
C61400-C61402 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet19
C61409 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet19
C61410 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet19
C61411 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet19
C61415 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet19
C61416 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet19
C61700 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet16
C61705 = CSC0402: part number: CSC0402-330PF_50V_2,6010A0010301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-331-J,50V-X7R-0402-TAP; signal model: C2_6010A0010301_330pF_50V_2; room: Sheet16
C61710 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet16
C66000 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet21
C66001-C66005 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet21
C66010 C66020 C66030 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet21
C66011 C66012 C66021 C66031 = CSC0603: part number: CSC0603-10UF_25V_3,6010B0366801,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,25V,M,X5R,0603,TR; signal model: C2_6010B0366801_10uF_25V_3; room: Sheet21
C66014 C66024 C66034 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet21
C66015 C66025 C66035 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet21
C66016 C66026 C66036 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet21
C66017 C66027 C66037 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet21
C66022 C66032 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet21
C66100 C66101 C66172 C66472 C66672 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet20
C66107 = CSC0402: part number: CSC0402-150PF_50V_2,6010A003620K,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-150PF-50V-K-X7R-0402-TAP; signal model: C2_6010A003620K_150pF_50V_2; room: Sheet20
C66110 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet20
C66111 C66160 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet20
C66115 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet20
C66197 = CSC0402: part number: CSC0402-330PF_50V_2,6010A0010301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-331-J,50V-X7R-0402-TAP; signal model: C2_6010A0010301_330pF_50V_2; room: Sheet20
C66199 C66299 = CAP_TANT: part number: CAP_TANT-33UF_16V,6010B0334401,CS_350X280X200_2,2.1MM,CAP_TANT,,,CAPACITOR-TANT,33UF,16V,20%,-55~+105C,3.5X2.8,TR; signal model: C2_6010B0334401_33uF_16V; room: Sheet21
C66300 = CAP_AL_SP: part number: CAP_AL_SP-330UF_2V_9MR_PANA_-35%,6010B0136301,CS_730X430X210_2,2.25MM,CAP_AL_SP,7.3X4.3,,CAPACITOR-AL-SP,330UF,2V,-35%/+10%,105C,DX1.9,SMD,TR,9MOHM; signal model: C2_6010B0136301_330uF_2V_9mR_Pana_-35%; room: Sheet22
C66301-C66305 C66312 = CSC0603: part number: CSC0603-CSC0603,CSC0603,CSC_160X080X080_2,0.95MM,CSC0603,0603,,CSC0603; signal model: C2_CSC0603_CSC0603; room: Sheet22
C66310 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet22
C66311 = CSC0603: part number: CSC0603-10UF_25V_3,6010B0366801,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,25V,M,X5R,0603,TR; signal model: C2_6010B0366801_10uF_25V_3; room: Sheet22
C66314 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet22
C66315 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet22
C66316 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet22
C66317 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet22
C66399 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet21
C66407 = CSC0402: part number: CSC0402-470PF_50V_2,6010A0025101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-471-K,50V-X7R-0402-TAP; signal model: C2_6010A0025101_470pF_50V_2; room: Sheet20
C66599 = CAP_TANT: part number: CAP_TANT-33UF_16V,6010B0334401,CS_350X280X200_2,2.1MM,CAP_TANT,,,CAPACITOR-TANT,33UF,16V,20%,-55~+105C,3.5X2.8,TR; signal model: C2_6010B0334401_33uF_16V; room: Sheet22
C66600 C66601 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002,CSC_160X080X100_2,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002_22uF_6_3V_3; room: Sheet23
C66607 = CSC0402: part number: CSC0402-39PF_50V_2,6010A003610A,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP,39PF,50V,J,NPO,0402,TAP; signal model: C2_6010A003610A_39pF_50V_2; room: Sheet20
C66610 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet23
C66614 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067602,CSC_160X080X080_2,0.90MM,CSC0603,0603,,CAPACITOR-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067602_1uF_25V_3; room: Sheet23
C66615 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet23
C66616 = CSC0402: part number: CSC0402-CSC0402,CSC0402,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402; signal model: C2_CSC0402_CSC0402; room: Sheet23
C66617 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet23
C66806 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet20
C68052 = CSC0402: part number: CSC0402-3900PF_16V_2,6010A003630L,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-3900PF-16V-K-X7R-0402-TAP; signal model: C2_6010A003630L_3900pF_16V_2; room: Sheet9
C68098 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet9
C68099 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet9
C76020 = CSC0201: part number: CSC0201-100PF_50V_1,6010B0058101,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,100PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058101_100pF_50V_1; room: Sheet10
CN200 = CN_10_2G: part number: CN_10_2G-ACES_50506_01001_001_10P,6012B0240012-003,CRESCENT-6012B0240012-003,1.85MM,,CONNECTOR,FPC,1.5MM,FL,10P,0.5MM,90D,SMD,TR,G/F; room: Sheet68
CN300 = CN_42_2G: part number: CN_42_2G-P_TWO_196652_42041_3_42P,6012B1164401,FPC_PTWO_42_050_R_160,1.85MM,,CONNECTOR,FPC,BACK FLIP,3.2MM,FL,CREAM,1X42,0.5MM,90D,SMD,TR,LCP,GOLD,3U; room: Sheet64
CN301 = CN_08_2G: part number: CN_08_2G-ENTERY_6718K_Y08N_01L_8P,6012B0488902,FPC_ENTRY_8_050_R_100,1.25MM,,CONNECTOR,FPC,1.0MM,FL,8P,0.5MM,90D,SMD,TR,G/F; room: Sheet64
CN303 = CN_08_2G: part number: CN_08_2G-ACES_51536_00801_Q01_8P,6012B0456501,FPC_ACES_8_050_R_120_1,1.6MM,,CONNECTOR,FPC,FL,8P,0.5MM,90D,SMD,TR; room: Sheet64
CN366 = 50961_0084B_001: part number: 50961_0084B_001-ACES_50951_0084N_001_8P,6026B0270301-004,OLYMPIA-6026B0270301-004,3.20MM,,SOCKET,SPI FLASH,8P,1.27MM,5U,2.95MM,STR,SMD,TR; room: Sheet62
CN367 = 50950_0084N_001: part number: 50950_0084N_001-ACES_50950_0084N_001_8P,6026B0415001,SKT-BIOS_ACES_1015X1000X295,3.2MM,,SOCKET,SPI FLASH,8P,1.27MM,5U,2.95MM,STR,SMD,TR; room: Sheet62
CN375 = CN_30_4G: part number: CN_30_4G-I_PEX_20455_030E_14_30P,6012B0834301,WTB_IPEX_30_050_SMD_R_F_100_1,1.25MM,,CONNECTOR,W TO B,1.0MM,FL,BLK,1X30,0.5MM,90D,SMD,TR,LCP,GOLD,15U; room: Sheet32
CN550 = CN_04_2G: part number: CN_04_2G-ACES_50224_00401_001_4P,6012B0069910,WTB_ACES_4_100_SMD_R_M_295,3.2MM,,CONNECTOR,W TO B,ML,1X4,90D,SMD,TR; room: Sheet71
CN1300 = AS0BC26_S30BE_7H: part number: AS0BC26_S30BE_7H-LOTES_APCI0019_P003H_75P,6026B0301801,NGFF_LOTES_67_050_E_308,3.4MM,,SOCKET, PCIEX KEY E NGFF, 75P, 0.5MM, GOLD, 10U, 3.0MM, 30D, SMD, TR; room: Sheet66
CN1400 = APCI0018_P005A: part number: APCI0018_P005A-LOTES_APCI0018_P005H_75P,6026B0243101,NGFF_LOTES_67_050_B_305,3.4MM,,SOCKET,PCIEX KEY B NGFF,75P,0.5MM,GOLD,10U,3.0MM,30D,DIP,STANDARD,TR; room: Sheet67
CN1451 = A0635_0001: part number: A0635_0001-FULLINHOPE_A0635_0001_7P,6026B0477601,SIM-N_FULHP_7_ST_138,1.78MM,,SOCKET,NANO SIM,7P,0.9MM,GOLD FLASH,1.38MM,LCP,BLACK,90D,SMD,STANDARD,TR; room: Sheet67
CN1951 = APCI0020_P001A01: part number: APCI0020_P001A01-LOTES_APCI0020_P003H_75P,6026B0240301-004,STALLONE-6026B0240301-004,3.35MM,,SOCKET,PCIEX,75P,0.5MM,GOLD,30U,3.0MM,30D,DIP,SMD,TR; room: Sheet60
CN2200 = CN_08_2G: part number: CN_08_2G-ACES_51536_00801_Q01_8P,6012B0456501,FPC_ACES_8_050_R_120_1,1.6MM,,CONNECTOR,FPC,FL,8P,0.5MM,90D,SMD,TR; room: Sheet61
