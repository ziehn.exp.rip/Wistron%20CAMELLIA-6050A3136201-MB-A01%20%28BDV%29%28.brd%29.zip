# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Nets (continued)
OCP_PWM_OUT: Q68054.G U300.G6(GPIO60/PWM7)
ON_OFF#: CN300.7 Q1003.S R1012.2(B) SW1000.T2
ON_OFF#1: Q1000.D Q1003.D R327.1(A) R1010.2(B)
ON_OFF#1_Q: CN4941.11 PAD300.2 Q1000.S R100.1(A) R4888.1(A)
ON_OFF#1_Q_XDP: CN4920.41(HOOK1) R4888.2(B)
PA_USB2_MXCTL: R2735.2(B) U2700.R2(PA_USB2_MXCTL)
PA_USB2_RBIAS: R2721.2(B) U2700.H19(PA_USB2_RBIAS)
PB_USB2_MXCTL: R2736.2(B) U2700.R1(PB_USB2_MXCTL)
PB_USB2_RBIAS: R2723.2(B) U2700.F19(PB_USB2_RBIAS)
PCBEEP: C527.1(A) U500.34(PCBEEP)
PCH_3A_SMCLK: Q4752.6 R4830.2(B) U4555.CK14(GPP_C0/SMBCLK)
PCH_3A_SMDATA: Q4752.3 R4792.2(B) U4555.CH15(GPP_C1/SMBDATA)
PCH_3S_SMCLK: CN4100.253(SCL) CN4125.253(SCL) CN4920.53(SCL) Q4752.1 R4913.2(B)
PCH_3S_SMDATA: CN4100.254(SDA) CN4125.254(SDA) CN4920.51(SDA) Q4752.4 R4828.2(B)
PCH_CIO_PLUG_EVENT: R2722.1(A) R4748.2(B) U4555.CP10(GPP_E2/SATAXPCIE2/SATAGP2)
PCH_CLICKPAD_INT#: R4625.2(B) R4831.2(B) U4555.CR22(GPP_D10/ISH_SPI_CLK/GSPI2_CLK)
PCH_I2C3_3S_SCL: Q4750.3 R4802.2(B)
PCH_I2C3_3S_SDA: Q4750.6 R4825.2(B)
PCH_I2C3_SCL: Q4750.4 R4561.2(B) U4555.CH28(GPP_H7/I2C3_SCL)
PCH_I2C3_SDA: Q4750.1 R4560.2(B) U4555.CH27(GPP_H6/I2C3_SDA)
PCH_KBC_SMCLK: Q4411.6 R310.1(A) U300.K8(GPIO90/I2C1_SCL0) U4412.1(SCL)
PCH_KBC_SMDATA: Q4411.3 R311.1(A) U300.K7(GPIO87/I2C1_SDA0) U4412.5(SDA)
PCH_LAN_RST#: R4768.2(B) U4555.CG12(GPP_C12/UART1_RXD/ISH_UART1_RXD)
PCH_LAN_SMCLK: R2764.1(A) R4797.2(B) U4555.CH14(GPP_C3/SML0CLK)
PCH_LAN_SMDATA: R2761.1(A) R4884.2(B) U4555.CF15(GPP_C4/SML0DATA)
PCH_OPI_RCOMP: R4588.2(B) U4555.BW25(PCH_OPIRCOMP)
PCH_PWROK: R4511.2(B) R4552.2(B) U4555.BP31(PCH_PWROK)
PCH_SLP_S0IX#: R353.1(A) R4772.2(B) U4555.CF12(GPP_C14/UART1_RTS#/ISH_UART1_RTS#)
PCH_SLP_SUS#: R4859.1(A) U300.J6(GPIO75/32KHZ_OUT) U4555.BU29(SLP_SUS#)
PCH_SML1CLK: R4827.2(B) U4555.CN15(GPP_C6/SML1CLK)
PCH_SML1DATA: R4856.2(B) U4555.CM15(GPP_C7/SML1DATA)
PCH_SPKR: Q500.G R517.1(A) R519.2(B) U4555.CF35(GPP_B14/SPKR)
PCH_SPKR_R: C514.1(A) R508.1(A) R517.2(B)
PCH_SPKR_R_R: C515.1(A) C527.2(B) R507.1(A) R508.2(B)
PCH_TBT_PERST#: R4678.2(B) R4727.2(B) U2701.2 U4555.CR12(GPP_C20/UART2_RXD)
PCH_TCK: CN4920.55(TCK1) R4589.1(A) U4555.W6(PCH_TCK)
PCH_TDI: CN4920.56(TDI) R4615.1(A) R4891.2(B) U4555.U5(PCH_TDI)
PCH_TDO: CN4920.52(TDO) R4612.1(A) R4807.2(B) U4555.W5(PCH_TDO)
PCH_TMS: CN4920.58(TMS) R4614.2(B) R4886.2(B) U4555.P5(PCH_TMS)
PCH_WAKE#: Q1301.D Q2701.3 R1303.2(B) R1413.2(B) R2759.2(B) R4946.1(A)
PCH_WAKE#_R: R4946.2(B) R4947.2(B) U4555.BU30(WAKE#)
PCH_WAKE#_WWAN: CN1400.23(RESERVED_23) R1413.1(A)
PCH_WLAN_RST#: R4771.2(B) U1300.2 U4555.CH12(GPP_C13/UART1_TXD/ISH_UART1_TXD)
PCIE_RBIAS: R2708.2(B) U2700.N16(PCIE_RBIAS)
PCIE_RCOMPN: R4608.2(B) U4555.CE6(PCIE_RCOMP*)
PCIE_RCOMPP: R4608.1(A) U4555.CE5(PCIE_RCOMP_P)
PCIE_RX5_C_DN: C2701.1(A) U2700.V22(PCIE_TX0*)
PCIE_RX5_C_DP: C2700.1(A) U2700.V23(PCIE_TX0_P)
PCIE_RX5_DN: C2701.2(B) U4555.BW9(PCIE5_RXN/USB31_5_RXN)
PCIE_RX5_DP: C2700.2(B) U4555.BW8(PCIE5_RXP/USB31_5_RXP)
PCIE_RX6_C_DN: C2703.1(A) U2700.P22(PCIE_TX1*)
PCIE_RX6_C_DP: C2702.1(A) U2700.P23(PCIE_TX1_P)
PCIE_RX6_DN: C2703.2(B) U4555.BU6(PCIE6_RXN/USB31_6_RXN)
PCIE_RX6_DP: C2702.2(B) U4555.BU5(PCIE6_RXP/USB31_6_RXP)
PCIE_RX7_C_DN: C2705.1(A) U2700.K22(PCIE_TX2*)
PCIE_RX7_C_DP: C2704.1(A) U2700.K23(PCIE_TX2_P)
PCIE_RX7_DN: C2705.2(B) U4555.BT7(PCIE7_RXN)
PCIE_RX7_DP: C2704.2(B) U4555.BT6(PCIE7_RXP)
PCIE_RX8_C_DN: C2707.1(A) U2700.F22(PCIE_TX3*)
PCIE_RX8_C_DP: C2706.1(A) U2700.F23(PCIE_TX3_P)
PCIE_RX8_DN: C2707.2(B) U4555.BU9(PCIE8_RXN)
PCIE_RX8_DP: C2706.2(B) U4555.BU8(PCIE8_RXP)
PCIE_RX9_DN: CN1951.5(PERN3) U4555.BP5(PCIE9_RXN)
PCIE_RX9_DP: CN1951.7(PERP3) U4555.BP6(PCIE9_RXP)
PCIE_RX10_DN: CN1951.17(PERN2) U4555.BN6(PCIE10_RXN)
PCIE_RX10_DP: CN1951.19(PERP2) U4555.BN5(PCIE10_RXP)
PCIE_RX11_DN: CN1951.29(PERN1) U4555.BN10(PCIE11_RXN/SATA0_RXN)
PCIE_RX11_DP: CN1951.31(PERP1) U4555.BN8(PCIE11_RXP/SATA0_RXP)
PCIE_RX12_DN: CN1951.43(PERP0/SATA-B-) U4555.BL6(PCIE12_RXN/SATA1A_RXN)
PCIE_RX12_DP: CN1951.41(PERN0/SATA-B+) U4555.BL5(PCIE12_RXP/SATA1A_RXP)
PCIE_RX14_DN: CN1300.43 U4555.BJ6(PCIE14_RXN)
PCIE_RX14_DP: CN1300.41 U4555.BJ5(PCIE14_RXP)
PCIE_RX16_DN: CN1400.41(PETN0/SATA-B+) U4555.BE5(PCIE16_RXN/SATA2_RXN)
PCIE_RX16_DP: CN1400.43(PETN0/SATA-B-) U4555.BE6(PCIE16_RXP/SATA2_RXP)
PCIE_TX5_C_DN: C4616.1(A) U2700.Y22(PCIE_RX0*)
PCIE_TX5_C_DP: C4617.1(A) U2700.Y23(PCIE_RX0_P)
PCIE_TX5_DN: C4616.2(B) U4555.BW4(PCIE5_TXN/USB31_5_TXN)
PCIE_TX5_DP: C4617.2(B) U4555.BW3(PCIE5_TXP/USB31_5_TXP)
PCIE_TX6_C_DN: C4618.1(A) U2700.T22(PCIE_RX1*)
PCIE_TX6_C_DP: C4619.1(A) U2700.T23(PCIE_RX1_P)
PCIE_TX6_DN: C4618.2(B) U4555.BU4(PCIE6_TXN/USB31_6_TXN)
PCIE_TX6_DP: C4619.2(B) U4555.BU3(PCIE6_TXP/USB31_6_TXP)
PCIE_TX7_C_DN: C4632.1(A) U2700.M22(PCIE_RX2*)
PCIE_TX7_C_DP: C4633.1(A) U2700.M23(PCIE_RX2_P)
PCIE_TX7_DN: C4632.2(B) U4555.BU2(PCIE7_TXN)
PCIE_TX7_DP: C4633.2(B) U4555.BU1(PCIE7_TXP)
PCIE_TX8_C_DN: C4634.1(A) U2700.H22(PCIE_RX3*)
PCIE_TX8_C_DP: C4635.1(A) U2700.H23(PCIE_RX3_P)
PCIE_TX8_DN: C4634.2(B) U4555.BT4(PCIE8_TXN)
PCIE_TX8_DP: C4635.2(B) U4555.BT3(PCIE8_TXP)
PCIE_TX9_C_DN: C4614.1(A) CN1951.11
PCIE_TX9_C_DP: C4615.1(A) CN1951.13
PCIE_TX9_DN: C4614.2(B) U4555.BR2(PCIE9_TXN)
PCIE_TX9_DP: C4615.2(B) U4555.BR1(PCIE9_TXP)
PCIE_TX10_C_DN: C4612.1(A) CN1951.23
PCIE_TX10_C_DP: C4613.1(A) CN1951.25
PCIE_TX10_DN: C4612.2(B) U4555.BR4(PCIE10_TXN)
PCIE_TX10_DP: C4613.2(B) U4555.BR3(PCIE10_TXP)
PCIE_TX11_C_DN: C4820.1(A) CN1951.35(PETN1)
PCIE_TX11_C_DP: C4821.1(A) CN1951.37(PETP1)
PCIE_TX11_DN: C4820.2(B) U4555.BN4(PCIE11_TXN/SATA0_TXN)
PCIE_TX11_DP: C4821.2(B) U4555.BN3(PCIE11_TXP/SATA0_TXP)
PCIE_TX12_C_DN: C4818.1(A) CN1951.47(PETN0/SATA-A-)
PCIE_TX12_C_DP: C4819.1(A) CN1951.49(PETP0/SATA-A+)
PCIE_TX12_DN: C4818.2(B) U4555.BN2(PCIE12_TXN/SATA1A_TXN)
PCIE_TX12_DP: C4819.2(B) U4555.BN1(PCIE12_TXP/SATA1A_TXP)
PCIE_TX14_C_DN: C4651.1(A) CN1300.37
PCIE_TX14_C_DP: C4652.1(A) CN1300.35
PCIE_TX14_DN: C4651.2(B) U4555.BL2(PCIE14_TXN)
PCIE_TX14_DP: C4652.2(B) U4555.BL1(PCIE14_TXP)
PCIE_TX16_C_DN: C4627.1(A) CN1400.47(PETN0/SATA-A-)
PCIE_TX16_C_DP: C4650.1(A) CN1400.49(PETN0/SATA-A+)
PCIE_TX16_DN: C4627.2(B) U4555.BJ4(PCIE16_TXN/SATA2_TXN)
PCIE_TX16_DP: C4650.2(B) U4555.BJ3(PCIE16_TXP/SATA2_TXP)
PD_ADP_DIS1: Q2607.5 R2627.2(B) U300.H7(GPIOC5/KBRST#)
PD_ADP_DIS2: Q2605.5 R2615.2(B) U300.D10(GPIOC6/SMI#)
PLAY_MUTE_LED: Q303.2 R402.2(B) R408.2(B) R409.2(B)
PLAY_MUTE_LED_AUDIO: R409.1(A) U500.1
PLAY_MUTE_LED_CNTR: Q303.6 R365.1(A) R376.1(A)
PLAY_MUTE_LED_CNTR_R: CN300.9 R365.2(B)
PLAY_MUTE_LED_PCH: R408.1(A) U4555.CF27(GPP_H4/I2C2_SDA)
PLT_DET: R309.1(A) R906.1(A) U300.D2(GPIOF0/ADC9)
PLT_ID1: R4460.1(A) R4803.1(A) U4555.CJ17(GPP_F8/CNV_MFUART2_RXD)
PLT_ID2: R4580.1(A) R4761.1(A) R4804.1(A)
PLT_ID2_PCH: R4580.2(B) U4555.CH17(GPP_F9/CNV_MFUART2_TXD)
PLT_ID3: CN2500.22 R4762.1(A) R4805.1(A) U4555.CK17(GPP_F10)
PLT_ID4: R3027.2(B) R3028.2(B) U4555.BY31(GPP_A16/SD_1P8_SEL)
PLT_RST#: Q4754.1(G) R420.1(A) R4564.1(A) R4941.2(B) U4700.2(IN)
PLT_RST#_KBC: R420.2(B) U300.J5(GPIO76/EC_SCI#)
PLT_RST#_PCH: R4941.1(A) U4555.BJ35(GPP_B13/PLTRST#)
PM_EXTTS#0_R: CN4100.134(EVENT#) R4201.2(B)
PM_EXTTS#1_R: CN4125.134(EVENT#) R4200.2(B)
PM_PWROK: R321.1(A) U300.K4(GPIO61/RESET_OUT#) U4555.CR10(SYS_PWROK)
PM_SLP_A#: CN4941.6 R4860.1(A) R7415.1(A) U4555.BU37(GPD6/SLP_A#)
PM_SLP_A#_COMPARE: D7400.2(A2) R7415.2(B)
PP_DETECT: CN3000.25 Q3003.G R3015.2(B) R3020.2(B)
PP_DETECT#: Q3003.D R433.2(B)
PP_DETECT#_R: R433.1(A) U300.G10(GPIO50)
PP_HVA: CN3000.22 R387.1(A) R434.2(B) R3022.2(B)
PP_HVA_R: R434.1(A) U300.H6(GPIOD7)
PP_SELECT: R3020.1(A) R3022.1(A) U3001.6
PRIVACY_LED#: R388.1(A) U300.D4(GPIO36/I2C5_SDA0/RTS#)
PRIVACY_LED#_R: CN300.5 R388.2(B)
PSR_EN_R: CN3000.16
PV_VBUS_CNTR_1: C2609.2(B) C2610.2(B) C2620.2(B) C2900.1(A) C7600.1(A) C7601.1(A) C7602.1(A) C7603.1(A) C7627.1(A) CN2900.A4 CN2900.A9 CN2900.B4 CN2900.B9 D2611.1(A1) Q2601.2(S) Q2609.1(S0) Q2609.2(S1) Q2609.3(S2) R2601.2(B) R2602.2(B) R2619.2(B) TP2600.1 U2403.D1 U2602.C2(VBUS3) U2602.D1(VBUS1) U2602.D2(VBUS2)
PV_VBUS_CNTR_2: C2600.2(B) C2602.2(B) C2608.2(B) C2815.1(A) C7604.1(A) C7605.1(A) C7606.1(A) C7607.1(A) C7626.1(A) CN2800.A4 CN2800.A9 CN2800.B4 CN2800.B9 D2612.1(A1) Q2600.1(S0) Q2600.2(S1) Q2600.3(S2) Q2603.2(S) R2611.2(B) R2613.2(B) R2635.2(B) TP2601.1 U2403.L3 U2600.C2(VBUS3) U2600.D1(VBUS1) U2600.D2(VBUS2)
PVADP: C6037.1(A) C6038.1(A) C60034.1(A) D60099.1(A1) L6035.1(INA) L6036.1(INA) Q60010.1(S0) Q60010.2(S1) Q60010.3(S2) Q60033.2(S) R60045.1(A) R60048.1(A) R60050.1(A) R68123.1(A)
PVADP_DC: C6035.1(A) C7623.1(A) CN6000.1 CN6000.2 CN6000.3 D6035.1 L6035.2(INB) L6036.2(INB)
PVCORE: C4550.1(A) C4551.1(A) C4552.1(A) C4554.1(A) C4555.1(A) C4556.1(A) C4557.1(A) C4558.1(A) C4559.1(A) C4560.1(A) C4561.1(A) C4562.1(A) C4563.1(A) C4564.1(A) C4565.1(A) C4569.1(A) C4570.1(A) C4571.1(A) C4572.1(A) C4573.1(A) C4574.1(A) C4575.1(A) C4576.1(A) C4578.1(A) C4579.1(A) C4580.1(A) C4581.1(A) C4582.1(A) C4583.1(A) C4584.1(A) C4588.1(A) C4589.1(A) C4590.1(A) C4591.1(A) C4592.1(A) C4593.1(A) C4594.1(A) C4595.1(A) C4596.1(A) C4628.1(A) C4629.1(A) C4630.1(A) C4631.1(A) C4636.1(A) C4637.1(A) C4638.1(A) C4639.1(A) C4640.1(A) C4641.1(A) C4642.1(A) C4643.1(A) C4644.1(A) C7523.1(A) C7524.1(A) C7525.1(A) C7526.1(A) C7527.1(A) C7528.1(A) C7529.1(A) C7531.1(A) C7532.1(A) C66000.1(A) C66001.1(A) C66002.1(A) C66003.1(A) C66004.1(A) C66005.1(A) L66010.2 L66010.4 L66020.2 L66020.4 L66030.2 L66030.4 R4593.2(B) TP66000.1 U4555.AA9(VCCCORE_1) U4555.AB2(VCCCORE_2) U4555.AB8(VCCCORE_3) U4555.AB9(VCCCORE_4) U4555.AB10(VCCCORE_5) U4555.AC8(VCCCORE_6) U4555.AD9(VCCCORE_7) U4555.AE8(VCCCORE_8) U4555.AE9(VCCCORE_9) U4555.AE10(VCCCORE_10) U4555.AF2(VCCCORE_11) U4555.AF8(VCCCORE_12) U4555.AF10(VCCCORE_13) U4555.AG8(VCCCORE_14) U4555.AG9(VCCCORE_15) U4555.AH9(VCCCORE_16) U4555.AJ8(VCCCORE_17) U4555.AJ10(VCCCORE_18) U4555.AK2(VCCCORE_19) U4555.AK9(VCCCORE_20) U4555.AL8(VCCCORE_21) U4555.AL9(VCCCORE_22) U4555.AL10(VCCCORE_23) U4555.AM8(VCCCORE_24) U4555.AN9(VCCCORE_28) U4555.AN10(VCCCORE_29) U4555.AN24(VCCCORE_30) U4555.AN26(VCCCORE_31) U4555.AN27(VCCCORE_32) U4555.AP2(VCCCORE_33) U4555.AP9(VCCCORE_34) U4555.AP24(VCCCORE_35) U4555.AP26(VCCCORE_36) U4555.AR5(VCCCORE_37) U4555.AR6(VCCCORE_38) U4555.AR7(VCCCORE_39) U4555.AR8(VCCCORE_40) U4555.AR10(VCCCORE_41) U4555.AR25(VCCCORE_42) U4555.AR27(VCCCORE_43) U4555.AT9(VCCCORE_44) U4555.AT24(VCCCORE_45) U4555.AT26(VCCCORE_46) U4555.AU5(VCCCORE_47) U4555.AU6(VCCCORE_48) U4555.AU7(VCCCORE_49) U4555.AU8(VCCCORE_50) U4555.AU9(VCCCORE_51) U4555.AU24(VCCCORE_52) U4555.AU25(VCCCORE_53) U4555.AU26(VCCCORE_54) U4555.AU27(VCCCORE_55) U4555.AV2(VCCCORE_56) U4555.AV5(VCCCORE_57) U4555.AV7(VCCCORE_58) U4555.AV10(VCCCORE_59) U4555.AV27(VCCCORE_60) U4555.AW5(VCCCORE_61) U4555.AW6(VCCCORE_62) U4555.AW7(VCCCORE_63) U4555.AW8(VCCCORE_64) U4555.AW9(VCCCORE_65) U4555.AW10(VCCCORE_66) U4555.AW24(VCCCORE_67) U4555.AW25(VCCCORE_68) U4555.AW26(VCCCORE_69) U4555.AW27(VCCCORE_70) U4555.AY24(VCCCORE_71) U4555.AY26(VCCCORE_72) U4555.BA5(VCCCORE_73) U4555.BA7(VCCCORE_74) U4555.BA8(VCCCORE_75) U4555.BA25(VCCCORE_76) U4555.BA27(VCCCORE_77) U4555.BB2(VCCCORE_78) U4555.BB26(VCCCORE_79) U4555.BC5(VCCCORE_80) U4555.BC6(VCCCORE_81) U4555.BC7(VCCCORE_82) U4555.BC9(VCCCORE_83) U4555.BC10(VCCCORE_84) U4555.BC26(VCCCORE_85) U4555.BC27(VCCCORE_86) U4555.BD5(VCCCORE_87) U4555.BD8(VCCCORE_88) U4555.BD10(VCCCORE_89) U4555.BD25(VCCCORE_90) U4555.BD27(VCCCORE_91) U4555.BE9(VCCCORE_92) U4555.BE24(VCCCORE_93) U4555.BE25(VCCCORE_94) U4555.BE26(VCCCORE_95) U4555.BE27(VCCCORE_96) U4555.BF2(VCCCORE_97) U4555.BF9(VCCCORE_98) U4555.BF24(VCCCORE_99) U4555.BF26(VCCCORE_100) U4555.BG27(VCCCORE_101) U4555.V2(VCCCORE_25) U4555.Y8(VCCCORE_26) U4555.Y10(VCCCORE_27)
PVCORE_PG: R4511.1(A) R66002.2(B) U66000.30(VRRDY)
PVCORE_VID0: R4889.1(A) U4555.CB36(GPP_B0/CORE_VID0)
PVCORE_VID1: R4890.1(A) U4555.CB35(GPP_B1/CORE_VID1)
PVPACK: C7502.1(A) C60050.1(A) CN6050.1 CN6050.2 CN6050.3 Q60012.1(S0) Q60012.2(S1) Q60012.3(S2) R60019.1(A) TP6053.1
PVSYS: C7628.1(A) D60031.2(A2) D68200.1(OUT) Q68100.1(S0) Q68100.2(S1) Q68100.3(S2) Q68101.1(S0) Q68101.2(S1) Q68101.3(S2) Q68102.4 Q68105.1 Q68106.1(S0) Q68106.2(S1) Q68106.3(S2) Q68107.1 R60000.1 R68096.1(A)
PVSYS_BUCK: C7555.1(A) C7556.1(A) C7557.1(A) C60010.1(A) C60011.1(A) C60012.1(A) C60013.1(A) C60014.1(A) C60099.1(A) Q60000.5(D3) Q60000.6(D2) Q60000.7(D1) Q60000.8(D0) R60000.2
PVT_CS#: CN366.1 R355.2(B) U300.L10(PVT_CS0#/GPIO97) U366.1
PVT_MISO: CN366.2 R390.2(B) U366.2
PVT_MISO2: CN366.3 R344.1(A) R345.1(A) R419.2(B) U366.3
PVT_MISO2_EC: R419.1(A) U300.M11(GPIO94/PVT_DIO2)
PVT_MISO3: CN366.7 R346.1(A) R421.1(A) U366.7
PVT_MISO3_EC: R421.2(B) U300.L11(GPIOB0/PVT_DIO3)
PVT_MISO_EC: R390.1(A) U300.M12(PVT_MISO_DIO1/SPIP_MISO/GPIO95)
PVT_MOSI: CN366.5 R305.1(A) U366.5
PVT_MOSI_EC: R305.2(B) U300.K12(PVT_MOSI_DIO0/SPIP_MOSI/GPIOA3)
PVT_SCLK: CN366.6 R304.1(A) U366.6
PVT_SCLK_EC: R304.2(B) U300.L12(PVT_SCLK/SPIP_SCLK/GPIOA1)
PWM#_LED: Q301.G U300.H10(GPIOC2/PWM1/I2C6_SCL0)
PWM_EC_IN: C305.2(B) R431.1(A) R432.1(A) U300.F3(GPIOE1/ADC7)
PWM_EC_OUT: R428.1(A) R3024.1(A) U300.K5(GPIO80/PWM3_LED3)
PWM_EC_OUT_R: R3024.2(B) U3001.1
PWR_BTN_OUT#: R103.2(B) R350.2(B) U300.D9(KSO16/GPIO03) U4555.BU28(GPD3/PWRBTN#)
PWR_GOOD_3: Q4751.5 R4821.1(A) R4855.1(A) R7404.2(B) R7407.2(B) U300.M4(PWRGD/GPIO72) U7400.1(OUT)
PWR_GOOD_3_Q4751_G: Q4751.2 Q4751.3 R4742.2(B)
PWRBTN#: C100.1(A) R100.2(B) R101.2(B) R350.1(A) U300.G5(GPIO73/PS2_CLK3/TA2)
PWRSW_P3V3A: C7007.1(A) C7008.1(A) R7012.1(A) U7001.8 U7001.9
PWRSW_P3V3S: C7004.2(B) C7005.2(B) R7011.1(A) U7001.13 U7001.14
Q1304_G: Q1304.G R1307.2(B)
RBIAS: R2750.1(A) U2700.J6(RBIAS)
RECORD_MUTE_LED: Q303.5 R399.2(B) R410.2(B) R411.2(B)
RECORD_MUTE_LED_AUDIO: R410.1(A) U500.4(GPIO0/DMIC-DATA-12)
RECORD_MUTE_LED_CNTRL: Q303.3 R364.1(A) R372.1(A)
RECORD_MUTE_LED_CNTRL_R: CN300.8 R364.2(B)
RECORD_MUTE_LED_PCH: R411.1(A) U4555.CF29(GPP_H5/I2C2_SCL)
RF_RESET#_C: CN1300.10 R1319.2(B)
RFID_BEEP_EN#: R4700.2(B) U4555.CM23(GPP_D15/ISH_UART0_RTS#/GSPI2_CS1#)
RFID_PRESENT: R4839.2(B) U4555.CN23(GPP_D14/ISH_UART0_TXD)
RSENSE: R2750.2(B) U2700.J5(RSENSE)
RSMRST#: R330.2(B) R4926.1(A) U4555.BR36(RSMRST#)
RSMRST#_EC: R329.1(A) R330.1(A) U300.M10(GPIO84)
RSMRST_PG: C7406.1(A) R377.1(A) R7406.2(B) R7427.2(B) U7400.7(OUT)
RST1#: R1005.1(A) U1000.12
RST2: D1000.2(A2) R1004.1(A) U1000.9
RST2_D: D1000.3(C) Q1001.2 Q1001.5 R1007.1(A)
RTC_DET#: R4520.2(B) U4555.BV29(GPP_A0/RCIN#/TIME_SYNC1)
RTC_X1: C4767.2(B) R4862.1(A) U4555.BN31(RTCX1) X4750.4
RTC_X2: C4788.2(B) R4862.2(B) U4555.BN32(RTCX2) X4750.1
RTCRST#: C4768.1(A) CN4941.9 Q1001.3 R4845.2(B) U4555.BR34(RTCRST#)
RTD3_CIO_PWR_EN: R2709.1(A) U2702.2 U4555.CF20(GPP_D1/SPI1_CLK/BK1/SBK1)
RTD3_CIO_PWR_EN_BUF: R2701.2(B) R2709.2(B) R2712.2(B) U2700.T5(RTD3_PWR_EN) U2702.4
RTD3_USB_PWR_EN: R2727.1(A) U4555.CG22(GPP_D2/SPI1_MISO_IO1/BK2/SBK2)
RTD3_WAKE#: R4512.2(B) U4555.CN8(GPP_E0/SATAXPCIE0/SATAGP0)
SA0_DIM0: CN4100.256(SA0) R4101.1(A) R4103.2(B)
SA0_DIM1: CN4125.256(SA0) R4125.1(A)
SA1_DIM0: CN4100.260(SA1) R4100.1(A)
SA1_DIM1: CN4125.260(SA1) R4126.2(B)
SC_PWRSV#: CN200.5 R4749.2(B) TP853.1 U4555.CH30(GPP_H3/I2S2_RXD/CNV_BT_I2S_SDO)
SCAN_3S_IN<0>: D302.6 RS300.1 U300.A2(KSI0/GPIO31/TRACEDATA3)
SCAN_3S_IN<1>: D302.3 RS300.2 U300.A3(KSI1/GPIO30/TRACEDATA2)
SCAN_3S_IN<2>: D304.6 RS300.3 U300.A4(KSI2/GPIO27/TRACEDATA1)
SCAN_3S_IN<3>: D304.3 RS300.4 U300.B3(KSI3/GPIO26/TRACEDATA0)
SCAN_3S_IN<4>: D303.6 RS300.6 U300.B4(KSI4/GPIO25/TRACECLK)
SCAN_3S_IN<5>: D303.3 RS300.7 U300.C3(KSI5/GPIO24)
SCAN_3S_IN<6>: D301.3(C) RS300.8 U300.C4(KSI6/GPIO23/S_SBUB)
SCAN_3S_IN<7>: CN300.20 RS300.9 U300.C5(KSI7/GPIO22/S_SBUA)
SCAN_3S_OUT<0>: CN300.41 R339.1(A) U300.B5(KSO00/GPIO21/JTAG_TCK0_SWCLK0)
SCAN_3S_OUT<1>: CN300.23 R338.1(A) U300.B6(KSO01/GPIO20/JTAG_TMS0_SWIO0)
SCAN_3S_OUT<2>: CN300.40 R336.1(A) U300.B7(KSO02/GPIO17/JTAG_TDI0)
SCAN_3S_OUT<3>: CN300.29 R337.1(A) U300.B8(KSO03/GPIO16/JTAG_TDO0_SWO0)
SCAN_3S_OUT<4>: CN300.27 U300.C7(KSO04/GPIO15/XNOR)
SCAN_3S_OUT<5>: CN300.39 U300.C6(KSO05/GPIO14)
SCAN_3S_OUT<6>: CN300.25 U300.C8(KSO06/GPIO13)
SCAN_3S_OUT<7>: CN300.26 R335.1(A) R380.1(A) U300.B9(KSO07/GPO12/JEN0#)
SCAN_3S_OUT<8>: CN300.28 U300.C9(KSO08/GPIO11/CR_SOUT)
SCAN_3S_OUT<9>: CN300.16 U300.C10(KSO09/GPIO10/CR_SIN)
SCAN_3S_OUT<10>: CN300.24 U300.B11
SCAN_3S_OUT<11>: CN300.42 U300.B10
SCAN_3S_OUT<12>: U300.C11(KSO12/GPIO05)
SCAN_3S_OUT<13>: U300.D11(KSO13/GPIO04)
SCAN_3S_OUT_R_<0>: CN375.17 R339.2(B)
SCAN_3S_OUT_R_<1>: CN375.18 R338.2(B)
SCAN_3S_OUT_R_<2>: CN375.20 R336.2(B)
SCAN_3S_OUT_R_<3>: CN375.19 R337.2(B)
SCAN_3S_OUT_R_<7>: CN375.21 R335.2(B)
SCL_BAT_CHG: R307.1(A) R6050.1(A) U300.C12(GPIOB5/I2C0_SCL0) U60000.22
SCL_BAT_R_CHG: C7501.2(B) CN6050.5 D7505.2 R6050.2(B) TP6051.1
SCL_P: R66004.1(A) U300.L6(GPIOE4/I2C6_SCL1)
SCR_RST#: CN200.6 TP851.1
SDA_BAT_CHG: R306.1(A) R6051.1(A) U300.B12(GPIOB4/I2C0_SDA0) U60000.21
SDA_BAT_R_CHG: C7500.2(B) CN6050.4 D7504.2 R6051.2(B) TP6050.1
SDA_P: R66003.1(A) U300.L7(GPIOE3/I2C6_SDA1)
SET: R4415.1(A) U4413.1(SET)
SG_IN: TP4522.1 U4555.CN20(GPP_F3)
SLP_LAN#_PCH: R4858.1(A) U4555.BT31(SLP_LAN#)
SLP_S0#: R7156.2(B) R66105.2(B) U66000.35(SLP_S0#)
SLP_S3#_3R: CN4941.2 D4702.2(A2) D7002.3(A1) Q7002.2 R398.1(A) R2702.1(A) R4516.2(B) R4864.1(A) R4921.1(A) R7016.1(A) R7023.1(A) R7028.1(A) R7124.1(A) R7414.1(A) U2501.6 U3150.4 U4920.1
SLP_S3#_3R_COMPARE: D7400.1(A1) R7414.2(B)
SLP_S3#_3R_KBC: R398.2(B) U300.D6(KSO14/GPIO82)
SLP_S3#_3R_N: R2702.2(B) R2710.2(B) U2700.U1(SLP_S3#)
SLP_S3#_3R_PCH: R4516.1(A) U4555.BU36(GPD4/SLP_S3#)
SLP_S3#_3R_RC: C7009.1(A) D7002.1(A2) Q7306.5 R7028.2(B)
SLP_S3#_XDP_PRSNT: Q7307.5 R4921.2(B) U4920.4
SLP_S3_5R: Q2701.5 Q7002.6 Q7011.G R7005.2(B)
SLP_S4#_3R: CN4941.5 R301.1(A) R4521.2(B) R4863.1(A) R7020.1(A) U1000.6 U2500.4 U2501.7
SLP_S4#_3R_KBC: R301.2(B) U300.F11(GPIOA6/PS2_CLK3/TA2/SHD_CS1#)
SLP_S4#_3R_PCH: R4521.1(A) U4555.BU27(GPD5/SLP_S4#)
SLP_S4#_3R_R: Q7002.5 R7018.2(B) R7020.2(B)
SLP_S4_3R: Q7002.3 R7019.2(B)
SLP_S5#_3R: CN4941.4 TP4507.1 U4555.BT29(GPD10/SLP_S5#)
SLP_WLAN_PCH#: R4851.1(A) U4555.BT30(GPD9/SPL_WLAN#)
SPI_CLK_EC: R316.2(B) U300.F12(SHD_SCLK/GPIOA2)
SPI_CLK_EC_R: R312.2(B) R316.1(A)
SPI_CLK_FLH: CN367.6 R312.1(A) R4794.1(A) U367.6 U3500.19(SCLK)
SPI_CLK_PCH: R4567.1(A) R4842.1(A) U4555.CH37(SPI0_CLK)
SPI_CLK_PCH_R: R4567.2(B) R4794.2(B)
SPI_CS0#_EC: R441.2(B) U300.G11(SHD_CS0#/GPIOA0)
SPI_CS0#_EC_R: R441.1(A) R442.2(B)
SPI_CS0#_FLH: CN367.1 R331.1(A) R442.1(A) R4790.1(A) U367.1
SPI_CS0#_PCH: R4570.1(A) U4555.CG36(SPI0_CS0#)
SPI_CS0#_PCH_R: R4570.2(B) R4790.2(B)
SPI_SI_EC: R439.2(B) U300.H11(SHD_MOSI_DIO0/GPIOA4/TB1_TACH2PWM_IN)
SPI_SI_EC_R: R313.2(B) R439.1(A)
SPI_SI_FLH: CN367.5 R313.1(A) R418.1(A) R4796.1(A) U367.5 U3500.21(MOSI)
SPI_SI_FLH_R: C4937.1(A) CN4920.47(HOOK3) R4931.2(B)
SPI_SI_PCH: R4568.1(A) U4555.CF36(SPI0_MOSI)
SPI_SI_PCH_R: R4568.2(B) R4796.2(B)
SPI_SO2_EC_R: R314.2(B)
SPI_SO2_FLH: CN367.3 R314.1(A) R369.1(A) R370.1(A) R4793.1(A) U367.3
SPI_SO2_PCH: R4611.1(A) U4555.CF34(SPI0_IO2)
SPI_SO2_PCH_R: R4611.2(B) R4793.2(B) R4929.2(B)
SPI_SO3_EC_R: R422.2(B)
SPI_SO3_FLH: CN367.7 R368.1(A) R422.1(A) R4795.1(A) U367.7
SPI_SO3_PCH: R4592.1(A) U4555.CG34(SPI0_IO3)
SPI_SO3_PCH_R: R4592.2(B) R4795.2(B)
SPI_SO_EC: R440.2(B) U300.G12(SHD_MISO_DIO1/GPIO96)
SPI_SO_EC_R: R425.2(B) R440.1(A)
SPI_SO_FLH: CN367.2 R367.2(B) R425.1(A) U367.2 U3500.24(MISO)
SPI_SO_PCH: R4569.1(A) U4555.CF37(SPI0_MISO)
SPI_SO_PCH_R: R367.1(A) R4569.2(B)
SPI_TPM_CS#: R4808.1(A) U4555.CH34(SPI0_CS2#)
SPI_TPM_CS#_R: R3516.2(B) R4808.2(B) U3500.20(CS#)
SPI_TPM_VCC: C321.1(A) C366.1(A) C3503.1(A) C3504.1(A) C3506.1(A) C4524.2(B) C4549.2(B) CN367.8 R331.2(B) R368.2(B) R369.2(B) R373.2(B) R418.2(B) R3501.1(A) R3503.1(A) R3504.2(B) R3516.1(A) R3517.1(A) R3541.1(A) R4931.1(A) U367.8 U3500.1 U3500.8 U3500.22 U4555.BV23(VCCSPI)
SPK_OUT_L_DN: R567.1(A) U500.43(SPK-L-)
SPK_OUT_L_DP: R550.1(A) U500.42(SPK-L+)
SPK_OUT_L_R_DN: C642.1(A) CN550.3 R567.2(B)
SPK_OUT_L_R_DP: C643.1(A) CN550.4 R550.2(B)
SPK_OUT_R_DN: R566.1(A) U500.44(SPK-R-)
SPK_OUT_R_DP: R551.1(A) U500.45(SPK-R+)
SPK_OUT_R_R_DN: C640.1(A) CN550.2 R566.2(B)
SPK_OUT_R_R_DP: C641.1(A) CN550.1 R551.2(B)
SPKR_EN_AB: R500.2(B) R502.2(B) R505.2(B) R515.1(A)
SPKR_EN_AB_AUDIO: C511.1(A) R505.1(A) R516.2(B) U500.13(DC_DET/EAPD)
SR1#: R1010.1(A) U1000.2
SRTCRST#: C4764.1(A) Q1001.6 R4834.2(B) U4555.BR37(SRTCRST#)
SSD_SUSCLK: CN1951.68(SUSCLK) TP1951.1
SUSCLK32_KBC: R332.2(B) U300.L5(GPIOE7/32KCLIN)
SUSCLK32_PCH: R332.1(A) R1310.1(A) U4555.BT32(GPD8/SUSCLK)
SUSCLK32_PCH_WLAN: CN1300.50 R1310.2(B)
TACH_FAN1_IN: CN4300.3 D4300.1 R4301.1(A) TP4302.1 U300.E10(GPIOD3/TB1_TACH2PWM_IN)
TBT_CIO_PLUG_EVENT: R2722.2(B) U2700.AA1(CIO_PLUG_EVENT#)
TBT_EE_CLK: CN2700.6 U2700.Y16(EE_CLK) U2703.6
TBT_EE_CS_N: CN2700.1 R2752.1(A) U2700.W18(EE_CS#) U2703.1
TBT_EE_DI: CN2700.5 U2700.Y18(EE_DI) U2703.5
TBT_EE_DO: CN2700.2 R2753.1(A) U2700.W16(EE_DO) U2703.2
TBT_EE_WP_N: CN2700.3 R2754.1(A) U2700.W4(EE_WP#) U2703.3
TBT_FORCE_PWR: R2711.2(B) R2739.2(B) U2700.V4(FORCE_PWR) U4555.CF22(GPP_D3/SPI1_MOSI_IO0/BK3/SBK3)
TBT_HOLD_N: CN2700.7 R2751.1(A) U2703.7
TBT_I2C_SCL: CN2701.10 R2725.2(B) U2403.E2 U2700.V2(I2C_SCL)
TBT_I2C_SDA: CN2701.9 R2724.2(B) U2403.D2 U2700.V1(I2C_SDA)
TBT_MRESET: R352.1(A) R2742.2(B) U300.F5(GPIOF3/I2C4_SCL1)
TBT_PCIE_WAKE_N: Q2701.4 Q2701.6 R2705.1(A) R2759.1(A) R2760.2(B) U2700.Y2(PEWAKE#)
TBT_SVR_IND: L2701.1(INA) U2700.K1(SVR_IND<0>) U2700.K2(SVR_IND<1>) U2700.L1(SVR_IND<2>) U2700.L2(SVR_IND<3>)
TBT_TCK: R2745.2(B) TP2703.1 U2700.W19(TCK)
TBT_TDI: R2743.2(B) TP2700.1 U2700.W20(TDI)
TBT_TDO: R2746.2(B) TP2704.1 U2700.Y19(TDO)
TBT_TMS: R2744.2(B) TP2701.1 U2700.Y20(TMS)
TBT_TMU_CLK_OUT: R2703.2(B) R2740.2(B) R2775.2(B) U2700.Y1(GPIO_3)
TBT_USB_FORCE_PWR: R2727.2(B) R2731.2(B) U2700.V5(USB_FORCE_PWR)
TBT_WAKE#_PCH: Q2701.1 R2705.2(B) R4535.2(B) U4555.CM12(GPP_C23/UART2_CTS#)
TBT_XTAL_25_IN: L2700.1(INC) R2747.1(A) U2700.D22(XTAL_25_IN)
TBT_XTAL_25_OUT: L2700.4(INA) R2748.1(A) U2700.D23(XTAL_25_OUT)
TBT_XTAL_25_R_IN: C2744.1(A) L2700.2(IND) R2747.2(B) X2700.3
TBT_XTAL_25_R_OUT: C2745.1(A) L2700.3(INB) R2748.2(B) X2700.1
TBTA_AUX_DN: R2428.1(A) R2656.2(B) U2403.C11 U2700.J4(ASBU2)
TBTA_AUX_DP: R2425.1(A) R2655.2(B) U2403.B11 U2700.H4(ASBU1)
TBTA_AUX_R_DN: R2656.1(A) U2403.A11
TBTA_AUX_R_DP: R2655.1(A) U2403.A10
TBTA_CA2HD_0_C_DN: C2737.2(B) D2905.1 R2715.1(A)
TBTA_CA2HD_0_C_DP: C2736.2(B) D2904.1 R2713.1(A)
TBTA_CA2HD_0_DN: C2737.1(A) CN2900.B10 R2640.1(A)
TBTA_CA2HD_0_DP: C2736.1(A) CN2900.B11 R2641.1(A)
TBTA_CA2HD_0_R_DN: R2715.2(B) U2700.A21(ASSRXN1)
TBTA_CA2HD_0_R_DP: R2713.2(B) U2700.B21(ASSRXP1)
TBTA_CA2HD_1_C_DN: C2743.2(B) D2903.1 R2719.1(A)
TBTA_CA2HD_1_C_DP: C2742.2(B) D2902.1 R2718.1(A)
TBTA_CA2HD_1_DN: C2743.1(A) CN2900.A10 R2642.2(B)
TBTA_CA2HD_1_DP: C2742.1(A) CN2900.A11 R2643.2(B)
TBTA_CA2HD_1_R_DN: R2719.2(B) U2700.B15(ASSRXN2)
TBTA_CA2HD_1_R_DP: R2718.2(B) U2700.A15(ASSRXP2)
TBTA_CAP: C2613.1(A) U2602.D4(CAP)
TBTA_FO: R2401.1(A) R2633.1(A) U2602.C4(FO)
TBTA_FO_R: R2401.2(B) U2403.L7
TBTA_HD2CA_0_C_DN: C2739.2(B) D2901.1 R2714.1(A)
TBTA_HD2CA_0_C_DP: C2738.2(B) D2900.1 R2716.1(A)
TBTA_HD2CA_0_DN: C2739.1(A) CN2900.A3 R2623.2(B)
TBTA_HD2CA_0_DP: C2738.1(A) CN2900.A2 R2609.2(B)
TBTA_HD2CA_0_R_DN: R2714.2(B) U2700.B19(ASSTXN1)
TBTA_HD2CA_0_R_DP: R2716.2(B) U2700.A19(ASSTXP1)
TBTA_HD2CA_1_C_DN: C2740.2(B) D2907.1 R2720.1(A)
TBTA_HD2CA_1_C_DP: C2741.2(B) D2906.1 R2717.1(A)
TBTA_HD2CA_1_DN: C2740.1(A) CN2900.B3 R2608.1(A)
TBTA_HD2CA_1_DP: C2741.1(A) CN2900.B2 R2607.1(A)
TBTA_HD2CA_1_R_DN: R2720.2(B) U2700.B17(ASSTXN2)
TBTA_HD2CA_1_R_DP: R2717.2(B) U2700.A17(ASSTXP2)
TBTA_HPD: R2763.1(A) TP2603.1 U2403.K7
TBTA_HPD_R: R2732.2(B) R2763.2(B) R2764.2(B) U2700.T2(PA_HPD)
TBTA_I2C_INT#: CN2701.8 R2726.2(B) U2403.F2 U2700.M4(PA_I2C_INT)
TBTA_ILIM: R2617.2(B) U2602.A3(ILIM)
TBTA_VCC_HV_SYS_EN: C2609.1(A) C2610.1(A) Q2601.3(D) Q2609.4(G) R2600.1(A) R2601.1(A)
TBTB_AUX_DN: R2424.1(A) R2658.2(B) U2403.E11 U2700.L5(BSBU2)
TBTB_AUX_DP: R2423.1(A) R2657.2(B) U2403.D11 U2700.L4(BSBU1)
TBTB_AUX_R_DN: R2658.1(A) U2403.L11
TBTB_AUX_R_DP: R2657.1(A) U2403.K11
TBTB_CA2HD_0_C_DN: C2728.2(B) D2818.1 R2771.1(A)
TBTB_CA2HD_0_C_DP: C2729.2(B) D2817.1 R2772.1(A)
TBTB_CA2HD_0_DN: C2728.1(A) CN2800.B10 R2605.1(A)
TBTB_CA2HD_0_DP: C2729.1(A) CN2800.B11 R2616.1(A)
TBTB_CA2HD_0_R_DN: R2771.2(B) U2700.B13(BSSRXN1)
TBTB_CA2HD_0_R_DP: R2772.2(B) U2700.A13(BSSRXP1)
TBTB_CA2HD_1_C_DN: C2733.2(B) D2816.1 R2767.1(A)
TBTB_CA2HD_1_C_DP: C2732.2(B) D2815.1 R2768.1(A)
TBTB_CA2HD_1_DN: C2733.1(A) CN2800.A10 R2631.2(B)
TBTB_CA2HD_1_DP: C2732.1(A) CN2800.A11 R2632.2(B)
TBTB_CA2HD_1_R_DN: R2767.2(B) U2700.A7(BSSRXN2)
TBTB_CA2HD_1_R_DP: R2768.2(B) U2700.B7(BSSRXP2)
TBTB_CAP: C2601.1(A) U2600.D4(CAP)
TBTB_FO: R2402.1(A) R2634.1(A) U2600.C4(FO)
TBTB_FO_R: R2402.2(B) U2403.L8
TBTB_HD2CA_0_C_DN: C2731.2(B) D2814.1 R2769.1(A)
TBTB_HD2CA_0_C_DP: C2730.2(B) D2813.1 R2770.1(A)
TBTB_HD2CA_0_DN: C2731.1(A) CN2800.A3 R2630.2(B)
TBTB_HD2CA_0_DP: C2730.1(A) CN2800.A2 R2629.2(B)
TBTB_HD2CA_0_R_DN: R2769.2(B) U2700.B11(BSSTXN1)
TBTB_HD2CA_0_R_DP: R2770.2(B) U2700.A11(BSSTXP1)
TBTB_HD2CA_1_C_DN: C2735.2(B) D2820.1 R2765.1(A)
TBTB_HD2CA_1_C_DP: C2734.2(B) D2819.1 R2766.1(A)
TBTB_HD2CA_1_DN: C2735.1(A) CN2800.B3 R2622.1(A)
TBTB_HD2CA_1_DP: C2734.1(A) CN2800.B2 R2624.1(A)
TBTB_HD2CA_1_R_DN: R2765.2(B) U2700.B9(BSSTXN2)
TBTB_HD2CA_1_R_DP: R2766.2(B) U2700.A9(BSSTXP2)
TBTB_HPD: R2762.1(A) TP2602.1 U2403.E10
TBTB_HPD_R: R2734.2(B) R2761.2(B) R2762.2(B) U2700.T1(PB_HPD)
TBTB_I2C_INT#: CN2701.7 R2729.2(B) U2403.G2 U2700.M5(PB_I2C_INT)
TBTB_ILIM: R2603.2(B) U2600.A3(ILIM)
TBTB_VCC_HV_SYS_EN: C2602.1(A) C2608.1(A) Q2600.4(G) Q2603.3(D) R2610.1(A) R2635.1(A)
TCP2_HPD: R2733.2(B) U2700.R5(DPSRC_HPD)
TD_IREF: R4501.1(A) R4514.1(A) R4558.2(B) U4555.W4(ITP_PMODE)
TD_IREF_R: CN4920.46(RESET#_HOOK6) R4501.2(B) R4502.2(B)
TEST_PWR_GOOD: R2700.2(B) U2700.W5(TEST_PWR_GOOD)
THERM#: Q4300.5 R4416.2(B) U4411.4
THERM#_Q: Q4300.1 Q4300.3
THERM_CLK: Q4411.1 R4413.2(B) U4411.8
THERM_DATA: Q4411.4 R4412.2(B) U4411.7
THERM_SCI#: R4414.2(B) U4411.6 U4555.CE9(GPP_E3/CPU_GP0)
THERMTRIP_CPU#: R4605.2(B) U4555.BJ1(THRMTRIP#)
TLS_ENCRYTION: R4733.2(B) U4555.CJ15(GPP_C2/SMBALERT#)
TOUCH_INT#: Q3004.D R3018.1(A) U4555.CM14(GPP_C11/UART0_CTS#)
TOUCH_PWR_EN: Q3001.5 R3006.2(B) U4555.CK23(GPP_D23/I2S_MCLK)
TOUCH_PWR_EN#: Q3001.2 Q3001.3 R3005.2(B) R3030.2(B)
TOUCH_PWR_EN#_RC: C3000.2(B) Q3000.1 R3005.1(A)
TOUCH_Q_INT#: CN3000.8 Q3004.S R4930.1(A)
TOUCH_RST#: CN3000.9 R3026.1(A) U4555.CG14(GPP_C15/UART1_CTS#/ISH_UART1_CTS#)
TOUCH_SWITCH_EN: CN3000.7 D3001.2(A2) R3002.1(A)
TPM_GPIO: R3503.2(B) U3500.6(GPIO)
TPM_NCI_GND: R3505.1(A) U3500.16
TPM_NCI_VDD: R3504.1(A) U3500.14
TPM_PIRQ#: R3517.2(B) U3500.18(PIRQ#) U4555.CG25(GPP_D4/IMGCLKOUT0/BK4/SBK4)
TPM_PLT_RST#: Q2620.6 R3541.2(B) U3500.17(RST#)
TPM_PLT_RST#_RC: C3540.1(A) Q2620.2 R3542.1(A)
TPM_PP: R3501.2(B) R3502.1(A) U3500.7(PP)
TR_PLT_RST#: R2706.1(A) U2700.T4(PERST#) U2701.4
UART0_RXD: CN375.29 R4866.1(A) U4555.CR14(GPP_C8/UART0_RXD)
UART0_TXD: CN375.28 R4865.1(A) U4555.CP14(GPP_C9/UART0_TXD)
UIM_CD: CN1400.66(SIM DETECT) Q1401.D R1411.2(B)
UIM_CD#: C7504.1(A) CN1451.S/W D1402.1 Q1401.G R1410.2(B) R1411.1(A) R1452.2(B)
UIM_CLK: C1453.1(A) CN1400.32(UIM-CLK) CN1451.C3 D1405.1
UIM_DATA: CN1400.34(UIM-DATA) CN1451.C7 D1401.1 R1451.2(B)
UIM_PWR: C1451.1(A) C1452.1(A) CN1400.36(UIM-PWR) CN1451.C1 D1451.3(C) R1451.1(A) R1452.1(A)
UIM_RST: C1405.1(A) CN1400.30(UIM-RESET) CN1451.C2 D1404.1
UIM_VPP: CN1451.C6
UNNAMED_7_CSC0402_I34_A: C60020.1(A) R60024.1(A)
UNNAMED_7_CSC0402_I43_A: C60033.1(A) R60024.2(B) U60000.28
UNNAMED_7_CSC0402_I81_B: C60006.2(B) R60027.1(A)
UNNAMED_7_CSC0402_I84_B: C60007.2(B) R60027.2(B) U60000.27
UNNAMED_7_CSC0402_I110_B: C60034.2(B) Q60010.4(G) Q60033.3(D) R60032.1(A) R60045.2(B)
UNNAMED_7_CSC0402_I218_A: C60028.1(A) C60029.1(A) R60005.1(A) R60039.1(A)
UNNAMED_7_CSC0402_I218_B: C60028.2(B) C60030.1(A) R60038.1(A) R60092.2(B)
UNNAMED_7_CSC0603_I24_A: C60048.1(A) R60048.2(B)
UNNAMED_7_CSC0603_I200_A: C60035.1(A) D60097.2(A2) Q60035.G R60054.1(A)
UNNAMED_7_CSC0603_I217_A: C60001.1(A) C60002.1(A) C60003.1(A) C60004.1(A) PAD60000.1 Q60003.5(D3) Q60003.6(D2) Q60003.7(D1) Q60003.8(D0)
UNNAMED_7_CSC0805_I128_A: C60017.1(A) C60032.1(A) Q60012.5(D3) Q60012.6(D2) Q60012.7(D1) Q60012.8(D0) R60001.2
UNNAMED_7_ISL9241HRTZ_I169_14: R60092.1(A) R60094.1(A) U60000.14
UNNAMED_7_ISL9241HRTZ_I169_15: R60005.2(B) U60000.15
UNNAMED_7_ISL9241HRTZ_I169_19: R60014.2(B) U60000.19
UNNAMED_7_ISL9241HRTZ_I169_20: R60004.2(B) R60017.2(B) U60000.20
UNNAMED_7_ISL9241HRTZ_I169_29: R60011.1(A) U60000.29
UNNAMED_7_LBSS84LT1G_I27_G: Q60033.1(G) R60050.2(B) R60061.1(A)
UNNAMED_7_LBSS84LT1G_I208_G: Q60034.1(G) R60051.1(A) R60052.1(A)
UNNAMED_7_LBSS84LT1G_I208_S: D60098.1(A1) Q60034.2(S) R60051.2(B)
UNNAMED_7_NMOSC_I202_D: Q60035.D R60052.2(B)
UNNAMED_7_NMOSC_I234_D: Q60032.D R60061.2(B)
UNNAMED_7_PNPA_I117_B: Q68120.1(B) R68123.2(B) R68124.1(A)
UNNAMED_7_PNPA_I117_C: Q68120.3(C) Q68121.1(B) R68122.1(A)
UNNAMED_7_RSC0402_I114_B: R68120.1(A) R68124.2(B) R68125.1(A)
UNNAMED_7_RSC0402_I221_B: R60001.4 R60020.2(B)
UNNAMED_7_RSC0402_I224_B: R60000.3 R60039.2(B)
UNNAMED_7_RSC0805_I215_A: D60031.1(A1) D60099.3(C) R60009.1(A)
UNNAMED_7_RSC12064PIN_I16_4: R60000.4 R60038.2(B)
UNNAMED_7_RSC12064PIN_I238_3: R60001.3 R60018.2(B)
UNNAMED_8_LBSS84LT1G_I8_S: Q68102.1 Q68103.2(S)
UNNAMED_8_LBSS84LT1G_I15_S: Q68104.2(S) Q68105.4
UNNAMED_8_LBSS84LT1G_I26_S: Q68107.4 Q68108.2(S)
UNNAMED_8_PMBT3906YS_I3_2: Q68102.2 Q68102.5 R68103.1(A)
UNNAMED_8_PMBT3906YS_I3_3: Q68100.4(G) Q68102.3 R68102.1(A)
UNNAMED_8_PMBT3906YS_I3_6: Q68102.6 R68104.1(A)
UNNAMED_8_PMBT3906YS_I12_2: Q68105.2 Q68105.5 R68106.1(A)
UNNAMED_8_PMBT3906YS_I12_3: Q68105.3 R68100.1(A)
UNNAMED_8_PMBT3906YS_I12_6: Q68101.4(G) Q68105.6 R68105.1(A)
UNNAMED_8_PMBT3906YS_I21_2: Q68107.2 Q68107.5 R68108.1(A)
UNNAMED_8_PMBT3906YS_I21_3: Q68107.3 R68107.1(A)
UNNAMED_8_PMBT3906YS_I21_6: Q68106.4(G) Q68107.6 R68109.1(A)
UNNAMED_9_CSC0402_I17_A: C68099.1(A) R68095.1(A) R68096.2(B)
UNNAMED_9_CSC0402_I39_A: C68052.1(A) Q68000.2(E) R68009.1(A) R68067.1(A) R68068.2(B)
UNNAMED_9_NMOSC_I60_D: Q68051.2(E) Q68098.D R68086.2(B)
UNNAMED_9_NMOSC_I61_D: Q68054.D R68054.1(A)
UNNAMED_9_NPND_I37_B: Q68051.1(B) R68065.1(A)
UNNAMED_9_RSC0402_I44_A: R68065.2(B) R68067.2(B) R68086.1(A)
UNNAMED_11_RSCSHORT_I47_B: R60254.2(B) U60250.11
UNNAMED_13_CSC0402_I17_B: C60309.2(B) C60350.1(A) C60351.2(B) R60349.1(A) U60300.4
UNNAMED_13_RSC0402_I35_A: R60301.1(A) R60302.2(B)
UNNAMED_15_CSC0402_I62_A: C60630.1(A) R60630.2(B) U60600.12(BYP)
UNNAMED_17_CSC0402_I46_A: C60930.1(A) R60930.2(B) U60900.12(BYP)
UNNAMED_18_CSC0402_I59_B: C60509.2(B) R60505.1(A) R60506.1(A) U60500.10
UNNAMED_19_CSC0402_I55_A: C61409.1(A) R61401.1(A) R61428.1(A) U61400.11
UNNAMED_19_CSC0402_I55_B: C61409.2(B) R61405.1(A) R61406.1(A) U61400.10
UNNAMED_19_NB692GD_I42_12: R61400.2(B) R61401.2(B) U61400.12
UNNAMED_20_CSC0402_I154_A: C66197.1(A) R66195.2(B) R66197.2(B) U66000.46(PSYS)
UNNAMED_20_MP2949GQKLFZ_I283__1: R66004.2(B) R66108.1(A) U66000.33(SCL_P)
UNNAMED_20_MP2949GQKLFZ_I283__2: R66103.2(B) U66000.28(SDIO)
UNNAMED_20_MP2949GQKLFZ_I283_SC: R66102.2(B) U66000.27(SCLK)
UNNAMED_20_MP2949GQKLFZ_I283_SD: R66003.2(B) R66109.1(A) U66000.32(SDA_P)
UNNAMED_20_MP2949GQKLFZ_I283_VR: R66001.2(B) U66000.31(VRHOT#)
UNNAMED_32_CN304G_I195_1: CN375.1 TP375.1
UNNAMED_40_LBSS84LT1G_I1105_S: Q4754.2(S) Q4755.3(D)
UNNAMED_40_LBSS84LT1G_I1108_S: Q4755.2(S) R4861.2(B)
UNNAMED_40_NMOSC_I1131_G: Q4756.G R4899.1(A)
UNNAMED_45_J92043_I167_VSS300: TP4514.1 U4555.CP1(VSS_300)
UNNAMED_45_J92043_I167_VSS341: TP4512.1 U4555.A32(VSS_341)
UNNAMED_45_J92043_I167_VSS342: TP4509.1 U4555.CR34(VSS_342)
UNNAMED_45_J92043_I167_VSS388: TP4513.1 U4555.A36(VSS_388)
UNNAMED_45_J92043_I167_VSS399: TP4510.1 U4555.CN1(VSS_399)
UNNAMED_45_J92043_I167_VSS413: TP4515.1 U4555.CR36(VSS_413)
UNNAMED_45_J92043_I167_VSS433: TP4511.1 U4555.D1(VSS_433)
UNNAMED_45_J92043_I168_VSS283: TP4516.1 U4555.C1(VSS_283)
UNNAMED_60_APCI0020P001A01_I842: CN1951.10(DAS/DSS#) TP1952.1
UNNAMED_65_NMOS2D2SDIODE_I879_3: Q2620.3 R3542.2(B) R3543.1(A)
UNNAMED_66_NMOSC_I813_D: Q1300.D R1302.2(B)
UNNAMED_73_SDINADF432GH_I326_E5: TP3800.1 U3800.E5
UNNAMED_76_CSC0201_I56_A: C7624.1(A) R7600.2(B)
UNNAMED_84_CM32181E_I117_4: R9304.2(B) R9305.2(B) U9302.4
UNNAMED_85_CM32181E_I114_4: R9300.2(B) R9301.2(B) U9300.4
UNNAMED_85_CM32181E_I115_4: R9302.2(B) R9303.2(B) U9301.4
USB2_COMP: R4756.1(A) U4555.CC5(USB2_COMP)
USB30_RX1_C_DN_DB: C9225.2(B) U9203.23
USB30_RX1_C_DP_DB: C9224.2(B) U9203.22
USB30_RX1_DN: CN2500.13 TP2509.1 U4555.CB5(PCIE1_RXN/USB31_1_RXN)
USB30_RX1_DN_DB: C9225.1(A) CN9202.18
USB30_RX1_DP: CN2500.14 TP2510.1 U4555.CB6(PCIE1_RXP/USB31_1_RXP)
USB30_RX1_DP_DB: C9224.1(A) CN9202.17
USB30_RX1_RE_DN_DB: CN9201.5 D9203.1 D9203.10 U9203.8
USB30_RX1_RE_DP_DB: CN9201.6 D9203.2 D9203.9 U9203.9
USB30_RX2_C_DN_DB: C9211.2(B) U9201.23
USB30_RX2_C_DP_DB: C9212.2(B) U9201.22
USB30_RX2_DN: CN2500.4 TP2503.1 U4555.BY8(PCIE2_RXN/USB31_2_RXN/SSIC_1_RXN)
USB30_RX2_DN_DB: C9211.1(A) CN9202.27
USB30_RX2_DP: CN2500.5 TP2504.1 U4555.BY9(PCIE2_RXP/USB31_2_RXP/SSIC_1_RXP)
USB30_RX2_DP_DB: C9212.1(A) CN9202.26
USB30_RX2_RE_DN_DB: CN9200.5 D9200.1 D9200.10 U9201.8
USB30_RX2_RE_DP_DB: CN9200.6 D9200.2 D9200.9 U9201.9
USB30_TX1_C_DN_DB: C9222.2(B) U9203.20
USB30_TX1_C_DP_DB: C9223.2(B) U9203.19
USB30_TX1_DN: CN2500.16 TP2511.1 U4555.CA4(PCIE1_TXN/USB31_1_TXN)
USB30_TX1_DN_DB: C9222.1(A) CN9202.15
USB30_TX1_DP: CN2500.17 TP2512.1 U4555.CA3(PCIE1_TXP/USB31_1_TXP)
USB30_TX1_DP_DB: C9223.1(A) CN9202.14
USB30_TX1_RE_C_DN_DB: C9214.2(B) CN9201.8 D9203.4 D9203.7
USB30_TX1_RE_C_DP_DB: C9215.2(B) CN9201.9 D9203.5 D9203.6
USB30_TX1_RE_DN_DB: C9214.1(A) U9203.11
USB30_TX1_RE_DP_DB: C9215.1(A) U9203.12
USB30_TX2_C_DN_DB: C9210.2(B) U9201.20
USB30_TX2_C_DP_DB: C9209.2(B) U9201.19
USB30_TX2_DN: CN2500.7 TP2505.1 U4555.CA2(PCIE2_TXN/USB31_2_TXN/SSIC_1_TXN)
USB30_TX2_DN_DB: C9210.1(A) CN9202.24
USB30_TX2_DP: CN2500.8 TP2506.1 U4555.CA1(PCIE2_TXP/USB31_2_TXP/SSIC_1_TXP)
USB30_TX2_DP_DB: C9209.1(A) CN9202.23
USB30_TX2_RE_C_DN_DB: C9201.2(B) CN9200.8 D9200.4 D9200.7
USB30_TX2_RE_C_DP_DB: C9202.2(B) CN9200.9 D9200.5 D9200.6
USB30_TX2_RE_DN_DB: C9201.1(A) U9201.11
USB30_TX2_RE_DP_DB: C9202.1(A) U9201.12
USB_A_A_DE0: TP9200.1 U9201.16
USB_A_A_DE1: R9207.1(A) U9201.18
USB_A_A_EQ0: R9210.2(B) U9201.17
USB_A_A_EQ1: TP9201.1 U9201.15
USB_A_B_DE0: R9212.2(B) U9201.3
USB_A_B_DE1: R9203.1(A) R9214.2(B) U9201.6
USB_A_B_EQ0: R9211.2(B) U9201.2
USB_A_B_EQ1: R9213.2(B) U9201.4
USB_A_I2C_EN: R9215.2(B) U9201.24
USB_A_REXT: R9202.1(A) U9201.7
USB_A_TEST: R9208.2(B) U9201.14
USB_B_A_DE0: TP9204.1 U9203.16
USB_B_A_DE1: R9222.2(B) R9224.1(A) U9203.18
USB_B_A_EQ0: R9221.2(B) U9203.17
USB_B_A_EQ1: TP9203.1 U9203.15
USB_B_B_DE0: R9227.2(B) U9203.3
USB_B_B_DE1: R9220.1(A) R9229.2(B) U9203.6
USB_B_B_EQ0: R9226.2(B) U9203.2
USB_B_B_EQ1: R9228.2(B) U9203.4
USB_B_I2C_EN: R9225.2(B) U9203.24
USB_B_REXT: R9219.1(A) U9203.7
USB_B_TEST: R9223.2(B) U9203.14
USB_CHARGER_STATUS#: R315.1(A) R2420.1(A) R2513.2(B) U2501.9
USB_CHARGER_STATUS#_PD: R2420.2(B) U2403.L10
USB_CHARGER_STATUS#_R: R2513.1(A) U300.G2(GPIO66)
USB_ID: R4504.1(A) U4555.CE8(USB_ID)
USB_P1_CH_DN: CN2500.10 TP2507.1 U2501.11
USB_P1_CH_DP: CN2500.11 TP2508.1 U2501.10
USB_P1_DN: U2501.2 U4555.CE3(USB2N_1)
USB_P1_DN_DB: CN9202.21 L9200.4(IND)
USB_P1_DP: U2501.3 U4555.CE4(USB2P_1)
USB_P1_DP_DB: CN9202.20 L9200.3(INB)
USB_P1_L_DN_DB: CN9200.2 D9201.1 D9201.10 L9200.1(INC)
USB_P1_L_DP_DB: CN9200.3 D9201.2 D9201.9 L9200.2(INA)
USB_P2_DN: L3000.2(INA) U4555.CE1(USB2N_2)
USB_P2_DP: L3000.1(INC) U4555.CE2(USB2P_2)
USB_P2_L_DN: CN3001.8 L3000.3(INB)
USB_P2_L_DP: CN3001.7 L3000.4(IND)
USB_P3_DN: CN200.4 TP852.1 U4555.CG3(USB2N_3)
USB_P3_DP: CN200.3 TP855.1 U4555.CG4(USB2P_3)
USB_P4_DN: CN2500.19 U4555.CD3(USB2N_4)
USB_P4_DN_DB: CN9202.12 L9201.4(IND)
USB_P4_DP: CN2500.20 U4555.CD4(USB2P_4)
USB_P4_DP_DB: CN9202.11 L9201.3(INB)
USB_P4_L_DN_DB: CN9201.2 D9202.1 D9202.10 L9201.1(INC)
USB_P4_L_DP_DB: CN9201.3 D9202.2 D9202.9 L9201.2(INA)
USB_P5_DN: U2403.A7 U4555.CG5(USB2N_5)
USB_P5_DP: U2403.A6 U4555.CG6(USB2P_5)
USB_P6_DN: U2403.G11 U4555.CC1(USB2N_6)
USB_P6_DP: U2403.F11 U4555.CC2(USB2P_6)
USB_P7_DN: CN2200.6 D2202.1 U4555.CG8(USB2N_7)
USB_P7_DP: CN2200.5 D2201.1 U4555.CG9(USB2P_7)
USB_P9_DN: R1406.2(B) U4555.CH5(USB2N_9)
USB_P9_DP: R1405.2(B) U4555.CH6(USB2P_9)
USB_P9_R_DN: CN1400.9(USB_D-) R1406.1(A)
USB_P9_R_DP: CN1400.7(USB_D+) R1405.1(A)
USB_P10_C_DN: CN1300.5 R1339.1(A)
USB_P10_C_DP: CN1300.3 R1338.1(A)
USB_P10_DN: R1339.2(B) U4555.CC3(USB2N_10)
USB_P10_DP: R1338.2(B) U4555.CC4(USB2P_10)
USB_VBUSSENSE: R4505.1(A) U4555.CC6(USB_VBUSSENSE)
V_ADP_ADC4: C68098.1(A) R302.1(A) R68094.1(A) R68095.2(B)
VADPBL: Q60010.5(D3) Q60010.6(D2) Q60010.7(D1) Q60010.8(D0) Q68100.5(D3) Q68100.6(D2) Q68100.7(D1) Q68100.8(D0) Q68103.3(D)
VBIOS_SEL0: TP4523.1 U4555.CP20(GPP_F0/CNV_PA_BLANKING)
VBIOS_SEL1: TP4524.1 U4555.CK19(GPP_F1)
VBIOS_SEL2: TP4525.1 U4555.CG17(GPP_F2)
VGT_VCCSENSE: R4528.1(A) R66819.2(B) U4555.E3(VCCGT_SENSE)
VGT_VSSSENSE: R4529.1(A) R66821.2(B) U4555.D2(VSSGT_SENSE)
VID0_VCC_PRIM: R4889.2(B) R61403.2(B) R61424.1(A) U61400.4
VID0_VCCIO: R7008.2(B) R60524.1(A) U60500.4
VID1_VCC_PRIM: R4890.2(B) R61404.2(B) U61400.3
VID1_VCCIO: R7007.2(B) R60525.1(A) U60500.3
VIDALERT#: R4596.1(A) U4555.AA3(VIDALERT#)
VORTNA: R66831.1(A) U66000.9(VORTNA)
VORTNB: R66821.1(A) U66000.13(VORTNB)
VOSENA: R66829.1(A) U66000.8(VOSENA)
VOSENB: R66819.1(A) U66000.12(VOSENB)
VR_SVID_ALERT#: R4594.1(A) R4596.2(B) U66000.29(ALT#)
VR_SVID_CLK: R66101.2(B) R66102.1(A) U4555.AA1(VIDSCK)
VR_SVID_DATA: R4595.1(A) R66100.2(B) R66103.1(A) U4555.AA2(VIDSOUT)
VRA1V5_FB: C61705.2(B) R61700.2(B) R61701.1(A) U61700.5
VRA1V05A_FB: C60920.2(B) R60900.2(B) R60901.1(A) U60900.11(FB)
VRA1V05A_FF: C60920.1(A) R60920.1(A)
VRA1V05A_ILMT: R60905.1(A) U60900.10(ILMT)
VRA1V05A_SNB: C60916.1(A) R60916.2(B)
VRA1V05A_VOUT: PAD60900.3 R60900.1(A) R60920.2(B)
VRA1V8A_FB: C60620.2(B) R60600.2(B) R60601.1(A) U60600.11(FB)
VRA1V8A_FF: C60620.1(A) R60620.1(A)
VRA1V8A_ILMT: R60605.1(A) U60600.10(ILMT)
VRA1V8A_SNB: C60616.1(A) R60616.2(B)
VRA1V8A_VOUT: PAD60600.3 R60600.1(A) R60620.2(B)
VRA2V5_FB: C60405.2(B) R60400.2(B) R60401.1(A) U60400.6
VRA3V3A_AGND: C60109.1(A) R60110.1(A) R60199.1(A) U60100.10
VRA3V3A_SNB: C60116.1(A) R60116.2(B)
VRA3V3A_VCC: C60109.2(B) U60100.9
VRA3V3DS_VOUT: C60190.1(A) PAD60100.3 U60100.5
VRA5V0_EN1: R60202.2(B) R60204.2(B) R60205.1(A) U60200.6(EN1)
VRA5V0_EN2: R60205.2(B) U60200.5(EN2)
VRA5V0_FF: C60200.2(B) R60200.1(A) R60201.2(B) U60200.7(FF)
VRA5V0_FF_R: C60200.1(A) R60218.1(A)
VRA5V0_LDO: C60217.1(A) U60200.9(LDO)
VRA5V0_SNB: C60216.1(A) R60216.2(B)
VRA5V0_VCC: C60209.1(A) U60200.10(VCC)
VRA5V0_VOUT: PAD60200.3 R60200.2(B) R60217.2(B) R60218.2(B)
VRA5V0_VOUT1: R60217.1(A) U60200.8(OUT)
VRA5V0A_FF: C60281.2(B) U60250.13
VRA5V0A_FF_R: C60281.1(A) R60289.1(A)
VRA5V0A_LDO: C60280.1(A) U60250.15
VRA5V0A_OUT: R60253.1(A) U60250.14
VRA5V0A_SNB: C60266.1(A) R60266.2(B)
VRA5V0A_VOUT: PAD60250.3 R60253.2(B) R60289.2(B)
VRA_1V05A_VCC: C60909.1(A) U60900.13(VCC)
VRA_1V8A_VCC: C60609.1(A) U60600.13(VCC)
VRA_5V0A_VCC: C60259.1(A) U60250.16 U60250.17
VRA_VDD18: C66111.1(A) R66111.1(A) U66000.26(VDD18)
VRABGATE: C60018.1(A) C60019.1(A) Q60012.4(G) U60000.32
VRABYPSGATE: U60000.16
VRABYPSRC: R60028.1(A) U60000.13
VRACHG_BATGONE: C60049.1(A) R60012.2(B) U60000.25
VRACHG_SNB1: C60016.1(A) R60016.1(A)
VRACHG_SNB2: C60026.1(A) R60026.1(A)
VRACPU_BST1: C66015.1(A) U66010.21(BST)
VRACPU_BST2: C66025.1(A) U66020.21(BST)
VRACPU_BST3: C66035.1(A) U66030.21(BST)
VRACPU_CS1: R66454.1(A) U66000.5(CS1) U66010.18(CS)
VRACPU_CS2: R66455.1(A) U66000.4(CS2) U66020.18(CS)
VRACPU_CS3: R66154.1(A) U66000.3(CS3) U66030.18(CS)
VRACPU_IMON: C66407.2(B) R66407.2(B) U66000.21(IMONA)
VRACPU_IREF: R66113.1(A) U66000.24(IREF)
VRACPU_PE: C66115.1(A) R66106.2(B) R66114.2(B) R66115.1(A) U66000.36(PE)
VRACPU_PE_EC: R66106.1(A) U300.G3(GPIOF1/ADC8)
VRACPU_PWM1: U66000.43(PWM1) U66010.15(PWM)
VRACPU_PWM2: U66000.42(PWM2) U66020.15(PWM)
VRACPU_PWM3: U66000.41(PWM3) U66030.15(PWM)
VRACPU_SNB1: C66016.1(A) R66016.2(B)
VRACPU_SNB2: C66026.1(A) R66026.2(B)
VRACPU_SNB3: C66036.1(A) R66036.2(B)
VRACPU_STB: U66000.34(STB) U66010.16(SYNC) U66020.16(SYNC) U66030.16(SYNC) U66310.16(SYNC) U66610.8(SYNC)
VRACPU_VDD33: C66110.1(A) R66110.2(B) U66000.44(VDD33)
VRACPU_VDIFF: R66471.1(A) U66000.6(VDIFFA)
VRACPU_VFB: R66471.2(B) R66472.1(A) U66000.7(VFBA)
VRACPU_VFB1: C66472.2(B) R66472.2(B)
VRACPU_VINSEN: C66806.1(A) R66198.1(A) R66199.2(B) U66000.47(VIN_SEN)
VRACPU_VTEMP: R66161.1(A) U66010.17(VTEP/FLT) U66020.17(VTEP/FLT) U66030.17(VTEP/FLT) U66310.17(VTEP/FLT) U66610.9(VTEMP/FLT)
VRACPU_VTEMP1: C66160.1(A) R66160.1(A) R66161.2(B) U66000.45(TEMP)
VRAGT_BST1: C66315.1(A) U66310.21(BST)
VRAGT_CS1: R66155.1(A) U66000.1(CS5) U66310.18(CS)
VRAGT_IMON: C66107.1(A) R66107.1(A) U66000.22(IMONB)
VRAGT_PWM1: U66000.39(PWM5) U66310.15(PWM)
VRAGT_SNB1: C66316.1(A) R66316.2(B)
VRAGT_VDIFF: R66171.1(A) U66000.10(VDIFFB)
VRAGT_VFB: R66171.2(B) R66172.1(A) U66000.11(VFBB)
VRAGT_VFB1: C66172.2(B) R66172.2(B)
VRAPACK_VBAT: R60013.2(B) R60019.2(B)
VRASA_BST1: C66615.1(A) U66610.13(BST)
VRASA_CS1: R66654.1(A) U66000.48(CS6) U66610.10(CS)
VRASA_CSUMC: R66654.2(B) U66000.20(CSSUMC)
VRASA_IMON: C66607.1(A) R66607.1(A) U66000.23(IMONC)
VRASA_PWM1: U66000.38(PWM6) U66610.7(PWM)
VRASA_SNB1: C66616.1(A) R66616.2(B)
VRASA_VDIFF: R66671.1(A) U66000.14(VDIFFC)
VRASA_VFB: R66671.2(B) R66672.1(A) U66000.15(VFBC)
VRASA_VFB1: C66672.2(B) R66672.2(B)
VRASA_VORTN: R66681.1(A) U66000.17(VORTNC)
VRASA_VOSEN: R66680.1(A) U66000.16(VOSENC)
VRAVCC_PRIM_SNB: C61416.1(A) R61416.2(B)
VRAVCCIO_BST: R60515.1(A) U60500.9
VRAVCCIO_BST1: C60515.1(A) R60515.2(B)
VRAVCCIO_MODE: R60529.2(B) U60500.7
VRAVCCIO_SNB: C60516.1(A) R60516.2(B)
VRAVDD: C60008.2(B) D60098.2(A2) R60003.2(B) R60004.1(A) R60028.2(B) R60054.2(B) U60000.18
VRAVDDP: C60022.1(A) R60003.1(A) U60000.8
VRAVDDQ_BST: R60315.1(A) U60300.10
VRAVDDQ_BST1: C60315.1(A) R60315.2(B)
VRAVDDQ_FB: C60348.1(A) R60300.1(A) R60301.2(B) U60300.13
VRAVDDQ_MODE: R60346.2(B) U60300.14
VRAVDDQ_OTW#: U60300.11
VRAVDDQ_SNB: C60316.1(A) R60316.2(B)
VRAVDDQ_VOUT: C60348.2(B) PAD60300.3 R60300.2(B)
VRAVR_ON: C66101.1(A) R4855.2(B) R66000.2(B) TP66001.1 U66000.37(EN)
VRB1V05A_BST: R60915.1(A) U60900.1(BS)
VRB1V05A_BST1: C60915.1(A) R60915.2(B)
VRB1V8A_BST: R60615.1(A) U60600.1(BS)
VRB1V8A_BST1: C60615.1(A) R60615.2(B)
VRB3V3A_BST: R60115.1(A) U60100.8
VRB3V3A_BST1: C60115.1(A) R60115.2(B)
VRB5V0_BST: R60215.1(A) U60200.13(BS)
VRB5V0_BST1: C60215.1(A) R60215.2(B)
VRB5V0A_BST: R60265.1(A) U60250.1
VRB5V0A_BST1: C60265.1(A) R60265.2(B)
VRB_ADP_SELEC: D68200.2(IN) Q68103.1(G) Q68104.1(G) Q68108.1(G) R68101.1(A)
VRB_VDD3: C60309.1(A) C66017.1(A) C66027.1(A) C66037.1(A) C66317.1(A) C66617.1(A) PAD60100.4 R60506.2(B) R60630.1(A) R60930.1(A) R61406.2(B) R66105.1(A) R66108.2(B) R66109.2(B) R66110.1(A) R66114.1(A) U60300.3 U66010.20(VCC) U66020.20(VCC) U66030.20(VCC) U66310.20(VCC) U66610.12(VCC)
VRB_VDD5: PAD60250.4 R60505.2(B) R61405.2(B)
VRBVCC_PRIM_BST: R61415.1(A) U61400.9
VRBVCC_PRIM_BST1: C61415.1(A) R61415.2(B)
VREF_PECI: R383.2(B) R386.2(B) U300.M6(VREF_PECI)
VRP1V5: C61700.1(A) C61705.1(A) L61700.2 PAD61799.1 R61700.1(A)
VRP1V5_PH: L61700.1 U61700.3
VRP1V5_VIN: C61710.1(A) PAD61710.2 U61700.4
VRP1V05A: C7558.1(A) C7559.1(A) C7560.1(A) C60900.1(A) C60901.1(A) C60902.1(A) C60903.1(A) C60904.1(A) L60900.2(INB) PAD60900.1
VRP1V05A_PH: C60915.2(B) L60900.1(INA) R60916.1(A) U60900.5(LX_2) U60900.15(LX) U60900.16(LX_1)
VRP1V05A_VIN: C60910.1(A) C60911.1(A) C60912.1(A) PAD60910.2 U60900.2(IN) U60900.3(IN_1) U60900.4(IN_2)
VRP1V8A: C60600.1(A) C60601.1(A) C60602.1(A) C60603.1(A) C60604.1(A) L60600.2(INB) PAD60600.1
VRP1V8A_PH: C60615.2(B) L60600.1(INA) R60616.1(A) U60600.5(LX_2) U60600.15(LX) U60600.16(LX_1)
VRP1V8A_VIN: C60610.1(A) C60611.1(A) C60612.1(A) PAD60610.2 U60600.2(IN) U60600.3(IN_1) U60600.4(IN_2)
VRP2V5: C60400.1(A) C60401.1(A) C60405.1(A) L60400.2 PAD60400.1 R60400.1(A)
VRP2V5_PH: L60400.1 U60400.3
VRP2V5_VIN: C60410.1(A) PAD60410.2 U60400.4
VRP3V3A: C60101.1(A) C60102.1(A) C60103.1(A) C60104.1(A) L60100.2(INB) PAD60100.1
VRP3V3A_LDO_RC: C1000.1(A) R1000.2(B) R1001.1(A)
VRP3V3A_PH: C60115.2(B) L60100.1(INA) R60116.1(A) U60100.7
VRP3V3A_VIN: C7567.1(A) C7568.1(A) C60110.1(A) C60111.1(A) C60112.1(A) PAD60110.2 U60100.1
VRP5V0: C60201.1(A) C60202.1(A) C60203.1(A) C60204.1(A) C60205.1(A) C76020.1(A) L60200.2(INB) PAD60200.1
VRP5V0_PH: C60215.2(B) L60200.1(INA) R60216.1(A) U60200.2(LX_1) U60200.12(LX)
VRP5V0_VIN: C60210.1(A) C60211.1(A) C60212.1(A) PAD60210.2 U60200.1(IN)
VRP5V0A: C60250.1(A) C60251.1(A) C60252.1(A) C60253.1(A) C60254.1(A) L60250.2(INB) PAD60250.1
VRP5V0A_PH: C60265.2(B) L60250.1(INA) R60266.1(A) U60250.6 U60250.19 U60250.20
VRP5V0A_VIN: C60260.1(A) C60261.1(A) C60262.1(A) PAD60260.2 U60250.2 U60250.3 U60250.4 U60250.5
VRPCHG_BST1: R60015.2(B) U60000.12
VRPCHG_BST1_R: C60015.2(B) R60015.1(A)
VRPCHG_BST2: R60025.2(B) U60000.4
VRPCHG_BST2_R: C60025.2(B) R60025.1(A)
VRPCHG_HG1: Q60000.4(G) U60000.11
VRPCHG_HG2: Q60003.4(G) U60000.5
VRPCHG_LG1: Q60001.4(G) U60000.9
VRPCHG_LG2: Q60002.4(G) U60000.7
VRPCHG_PH1: C60015.1(A) L60000.1 L60000.3 Q60000.1(S0) Q60000.2(S1) Q60000.3(S2) Q60001.5(D3) Q60001.6(D2) Q60001.7(D1) Q60001.8(D0) R60016.2(B) U60000.10
VRPCHG_PH2: C60025.1(A) L60000.2 L60000.4 Q60002.5(D3) Q60002.6(D2) Q60002.7(D1) Q60002.8(D0) Q60003.1(S0) Q60003.2(S1) Q60003.3(S2) R60026.2(B) U60000.6
VRPCPU_PH1: C66015.2(B) L66010.1 L66010.3 R66016.1(A) U66010.2(SW1) U66010.3(SW2) U66010.4(SW3)
VRPCPU_PH2: C66025.2(B) L66020.1 L66020.3 R66026.1(A) U66020.2(SW1) U66020.3(SW2) U66020.4(SW3)
VRPCPU_PH3: C66035.2(B) L66030.1 L66030.3 R66036.1(A) U66030.2(SW1) U66030.3(SW2) U66030.4(SW3)
VRPGT_PH1: C66315.2(B) L66310.1 L66310.3 R66316.1(A) U66310.2(SW1) U66310.3(SW2) U66310.4(SW3)
VRPPM_SLP_S0_N: CN4941.15 R4624.2(B) R7155.1(A) R7156.1(A) U4555.BJ37(GPP_B12/SLP_S0#)
VRPRIM_VIN: C61410.1(A) C61411.1(A) PAD61410.2 U61400.1
VRPSA_PH1: C66615.2(B) L66610.1 L66610.3 R66616.1(A) U66610.2(SW) U66610.3(SW_1)
VRPVCC_PRIM: C61400.1(A) C61401.1(A) C61402.1(A) L61400.2 L61400.4 PAD61499.1 R61400.1(A)
VRPVCC_PRIM_PH: C61415.2(B) L61400.1 L61400.3 R61416.1(A) U61400.8
VRPVCCIO: C60500.1(A) C60501.1(A) C60502.1(A) L60500.2 L60500.4 PAD60500.1
VRPVCCIO_PH: C60515.2(B) L60500.1 L60500.3 R60516.1(A) U60500.8
VRPVCCIO_VIN: C60510.1(A) C60511.1(A) PAD60510.2 U60500.1
VRPVDDQ: C60300.1(A) C60301.1(A) C60302.1(A) C60303.1(A) C60304.1(A) L60300.2 L60300.4 PAD60300.1 U60300.6
VRPVDDQ_PH: C60315.2(B) L60300.1 L60300.3 R60316.1(A) U60300.9
VRPVDDQ_VIN: C60310.1(A) C60311.1(A) C60312.1(A) C60313.1(A) PAD60310.2 U60300.1
VRPVTT: C60350.2(B) PAD60350.1 U60300.5 U60300.8
VRPVTT_REF: C60351.1(A) U60300.7
WL_LED_ALL#: CN1300.6 CN1300.16
WLAN_ALERT#: CN1300.62 TP1303.1
WLAN_GND: CN1300.18 R1317.2(B)
WLAN_I2CCLK: CN1300.60 TP1302.1
WLAN_I2DATA: CN1300.58 TP1301.1
WLAN_LED_EN: R4545.2(B) U4555.CN4(GPP_E23/DPPD_CTRLDATA)
WLAN_OFF: Q1300.G R348.1(A) R1349.1(A) U300.E4(GPO32/TRIS#)
WLAN_OFF_R: D1302.1(A2) R1342.2(B) R1343.1(A) R1349.2(B)
WLAN_PLT_RST#: CN1300.52 R1301.1(A) R1347.2(B) U1300.4
WLAN_PWR_EN#: C1309.2(B) D1302.3(A1) Q1307.3(G) R1343.2(B)
WLAN_TRANSMIT_OFF#: D1300.3(A1) R1300.2(B) U4555.CP12(GPP_C21/UART2_TXD)
WLAN_TRANSMIT_OFF#_R: D1300.1(A2) Q1304.S
WLAN_TRANSMIT_OFF#_R_Q: CN1300.56 Q1304.D R1346.2(B)
WLAN_WAKE#: CN1300.55 Q1301.S R1303.1(A) R1305.2(B)
WP_RCOMP: R4900.1(A) U4555.CP32(CNV_WT_RCOMP_1) U4555.CR32(CNV_WT_RCOMP_2)
WR_CLK_C_DN: CN1300.21 R1327.1(A)
WR_CLK_C_DP: CN1300.23 R1326.1(A)
WR_CLK_DN: R1327.2(B) U4555.CN31(CNV_WR_CLKN)
WR_CLK_DP: R1326.2(B) U4555.CP31(CNV_WR_CLKP)
WR_LANE0_C_DN: CN1300.15 R1329.1(A)
WR_LANE0_C_DP: CN1300.17 R1328.1(A)
WR_LANE0_DN: R1329.2(B) U4555.CR30(CNV_WR_D0N)
WR_LANE0_DP: R1328.2(B) U4555.CP30(CNV_WR_D0P)
WR_LANE1_C_DN: CN1300.9 R1335.1(A)
WR_LANE1_C_DP: CN1300.11 R1334.1(A)
WR_LANE1_DN: R1335.2(B) U4555.CM30(CNV_WR_D1N)
WR_LANE1_DP: R1334.2(B) U4555.CN30(CNV_WR_D1P)
WT_CLK_C_DN: CN1300.71 R1321.1(A)
WT_CLK_C_DP: CN1300.73 R1320.1(A)
WT_CLK_DN: R1321.2(B) U4555.CP34(CNV_WT_CLKN)
WT_CLK_DP: R1320.2(B) U4555.CN34(CNV_WT_CLKP)
WT_LANE0_C_DN: CN1300.65 R1323.1(A)
WT_LANE0_C_DP: CN1300.67 R1322.1(A)
WT_LANE0_DN: R1323.2(B) U4555.CN32(CNV_WT_D0N)
WT_LANE0_DP: R1322.2(B) U4555.CM32(CNV_WT_D0P)
WT_LANE1_C_DN: CN1300.59 R1325.1(A)
WT_LANE1_C_DP: CN1300.61 R1324.1(A)
WT_LANE1_DN: R1325.2(B) U4555.CP33(CNV_WT_D1N)
WT_LANE1_DP: R1324.2(B) U4555.CN33(CNV_WT_D1P)
WWAN_ANTCTL0: CN1400.59(ANTCTL0) TP1411.1
WWAN_ANTCTL1: CN1400.61(ANTCTL1) TP1412.1
WWAN_ANTCTL2: CN1400.63(ANTCTL2) TP1413.1
WWAN_ASPM_EXIT: R1417.2(B) R4763.2(B) U1401.6 U4555.CE28(GPP_B16/GSPI0_CLK)
WWAN_CONFIG_0: CN1400.21(WWAN/SSD IND GND-WWAN/OC-SSD) R4918.2(B) U4555.CR24(GPP_D16/ISH_UART0_CTS#/SML0BALERT#)
WWAN_CONFIG_2: CN1400.75(USB3.0IND/GND-OTHER) R4915.2(B) U4555.CH23(GPP_D22/SPI1_IO3)
WWAN_CONFIG_3: CN1400.1(GND_PRESENCE_IND) D1400.1(A1) Q1400.G R1400.2(B)
WWAN_CONFIG_3_PCH: D1400.2(A2) R4914.2(B) U4555.CG23(GPP_D21/SPI1_IO2)
WWAN_DET#: CN1400.69(PEDET_OC-PCIE/GND-SATA) R4835.2(B) U300.E6(GPIO01)
WWAN_FWUPD#: Q1400.S R4961.2(B) U4555.BY32(GPP_A15/SUSACK#)
WWAN_FWUPD#_CONN: C1401.2(B) CN1400.67(RESET#) Q1400.D
WWAN_NC56: C1403.2(B) CN1400.56(NC_56)
WWAN_NC58: C1404.2(B) CN1400.58(NC_58)
WWAN_NGFF_DPR: CN1400.25(RESERVED_25) R1408.2(B)
WWAN_OFF#: CN1400.6(FULL_CARD_POWER_OFF#) R349.1(A) R1404.2(B) U300.K2(GPO35/TEST#)
WWAN_PLT_RST#: CN1400.50(PERST#) U1401.4
WWAN_SSCLK: CN1400.68(SSCLK) R1412.1(A)
WWAN_TRANSMIT_OFF#: D1410.3(A1) R4766.2(B) U4555.CN22(GPP_D9/ISH_SPI_CS#/GSPI2_CS0#)
WWAN_TRANSMIT_OFF#_D: CN1400.8(W_DISABLE#) D1410.1(A2)
WWAN_WAKE#: R1414.1(A) R4754.2(B) U4555.CP7(GPP_E15/DPPD_HPD2/DISP_MISC2)
WWAN_WAKE#_R: CN1400.54(PEWAKE#) R1414.2(B)
XCLK_BIASREF: R4893.1(A) U4555.CJ1(XCLK_BIASREF)
XDP_CFG<0>: CN4920.45(HOOK2) R4822.2(B) R4940.1(A)
XDP_CFG<3>: CN4920.1(GND0) R4823.2(B) R4932.2(B)
XDP_DBRESET#: CN4920.48(DBR#_HOOK7) CN4941.13 R4922.2(B) U4555.CN10(SYS_RESET#)
XDP_PRSNT: Q4921.D R4925.2(B) U4920.6 U4921.6
