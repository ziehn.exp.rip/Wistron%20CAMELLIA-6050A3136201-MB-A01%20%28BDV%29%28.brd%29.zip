# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Nets (continued)
DGND: C100.2(B) C131.2(B) C300.2(B) C302.2(B) C303.2(B) C305.1(A) C306.1(A) C307.2(B) C308.2(B) C310.2(B) C311.2(B) C312.2(B) C314.2(B) C315.2(B) C316.2(B) C317.2(B) C319.2(B) C321.2(B) C322.2(B) C323.2(B) C324.2(B) C325.1(A) C327.2(B) C366.2(B) C504.2(B) C505.2(B) C510.2(B) C511.2(B) C512.2(B) C513.2(B) C518.2(B) C519.2(B) C520.2(B) C521.2(B) C522.2(B) C523.2(B) C524.1(A) C525.1(A) C640.2(B) C641.2(B) C642.2(B) C643.2(B) C1000.2(B) C1001.2(B) C1002.2(B) C1300.2(B) C1301.2(B) C1302.2(B) C1303.2(B) C1304.2(B) C1305.2(B) C1306.2(B) C1307.2(B) C1400.2(B) C1401.1(A) C1402.2(B) C1403.1(A) C1404.1(A) C1405.2(B) C1406.2(B) C1407.2(B) C1408.2(B) C1409.2(B) C1410.2(B) C1411.2(B) C1413.2(B) C1414.2(B) C1415.2(B) C1451.2(B) C1452.2(B) C1453.2(B) C1956.2(B) C2200.2(B) C2201.2(B) C2250.2(B) C2251.2(B) C2255.2(B) C2256.2(B) C2257.2(B) C2258.2(B) C2410.2(B) C2411.2(B) C2419.2(B) C2420.2(B) C2421.2(B) C2422.2(B) C2423.2(B) C2424.2(B) C2425.2(B) C2427.2(B) C2432.2(B) C2500.2(B) C2501.2(B) C2502.2(B) C2503.2(B) C2504.2(B) C2505.2(B) C2506.2(B) C2507.2(B) C2508.2(B) C2600.1(A) C2601.2(B) C2603.2(B) C2604.2(B) C2605.2(B) C2606.2(B) C2607.2(B) C2611.2(B) C2612.2(B) C2613.2(B) C2614.2(B) C2615.2(B) C2616.2(B) C2617.2(B) C2620.1(A) C2630.2(B) C2633.2(B) C2634.2(B) C2744.2(B) C2745.2(B) C2746.2(B) C2747.2(B) C2748.2(B) C2749.2(B) C2750.2(B) C2751.2(B) C2752.2(B) C2753.2(B) C2754.2(B) C2755.2(B) C2756.2(B) C2757.2(B) C2758.2(B) C2759.2(B) C2760.2(B) C2761.2(B) C2762.2(B) C2763.2(B) C2764.2(B) C2765.2(B) C2766.2(B) C2767.2(B) C2768.2(B) C2769.2(B) C2770.2(B) C2771.2(B) C2772.2(B) C2773.2(B) C2774.2(B) C2775.2(B) C2776.2(B) C2777.2(B) C2778.2(B) C2779.2(B) C2780.2(B) C2781.2(B) C2782.2(B) C2783.2(B) C2784.2(B) C2785.2(B) C2786.2(B) C2815.2(B) C2900.2(B) C3001.2(B) C3003.2(B) C3006.2(B) C3150.2(B) C3151.2(B) C3152.2(B) C3302.2(B) C3315.2(B) C3316.2(B) C3369.2(B) C3375.2(B) C3503.2(B) C3504.2(B) C3506.2(B) C3540.2(B) C3800.2(B) C3801.2(B) C3802.2(B) C3803.2(B) C3804.2(B) C4100.2(B) C4101.2(B) C4102.2(B) C4103.2(B) C4104.2(B) C4105.2(B) C4107.2(B) C4108.2(B) C4109.2(B) C4110.2(B) C4111.2(B) C4112.2(B) C4113.2(B) C4114.2(B) C4115.2(B) C4116.2(B) C4117.2(B) C4118.2(B) C4119.2(B) C4121.2(B) C4123.2(B) C4125.2(B) C4126.2(B) C4127.2(B) C4128.2(B) C4129.2(B) C4130.2(B) C4131.2(B) C4132.2(B) C4133.2(B) C4134.2(B) C4135.2(B) C4136.2(B) C4137.2(B) C4138.2(B) C4139.2(B) C4140.2(B) C4141.2(B) C4142.2(B) C4143.2(B) C4144.2(B) C4145.2(B) C4146.2(B) C4147.2(B) C4148.2(B) C4149.2(B) C4150.2(B) C4151.2(B) C4152.2(B) C4350.2(B) C4351.2(B) C4411.2(B) C4413.2(B) C4500.2(B) C4501.2(B) C4502.2(B) C4503.2(B) C4504.1(A) C4505.2(B) C4506.2(B) C4507.2(B) C4508.2(B) C4509.2(B) C4510.2(B) C4511.2(B) C4512.1(A) C4513.1(A) C4514.2(B) C4515.1(A) C4516.1(A) C4517.2(B) C4518.1(A) C4519.1(A) C4520.2(B) C4521.2(B) C4522.2(B) C4523.1(A) C4524.1(A) C4525.2(B) C4526.2(B) C4527.2(B) C4528.2(B) C4529.2(B) C4530.1(A) C4531.1(A) C4532.1(A) C4533.1(A) C4534.1(A) C4535.1(A) C4536.1(A) C4538.1(A) C4539.1(A) C4540.1(A) C4541.2(B) C4542.2(B) C4543.1(A) C4544.2(B) C4545.1(A) C4546.1(A) C4547.2(B) C4548.2(B) C4549.1(A) C4550.2(B) C4551.2(B) C4552.2(B) C4553.2(B) C4554.2(B) C4555.2(B) C4556.2(B) C4557.2(B) C4558.2(B) C4559.2(B) C4560.2(B) C4561.2(B) C4562.2(B) C4563.2(B) C4564.2(B) C4565.2(B) C4566.2(B) C4567.2(B) C4568.2(B) C4569.2(B) C4570.2(B) C4571.2(B) C4572.2(B) C4573.2(B) C4574.2(B) C4575.2(B) C4576.2(B) C4577.2(B) C4578.2(B) C4579.2(B) C4580.2(B) C4581.2(B) C4582.2(B) C4583.2(B) C4584.2(B) C4585.2(B) C4586.2(B) C4587.2(B) C4588.2(B) C4589.2(B) C4590.2(B) C4591.2(B) C4592.2(B) C4593.2(B) C4594.2(B) C4595.2(B) C4596.2(B) C4597.2(B) C4598.2(B) C4599.2(B) C4600.2(B) C4601.2(B) C4602.2(B) C4603.2(B) C4604.2(B) C4605.2(B) C4606.2(B) C4607.2(B) C4608.2(B) C4609.2(B) C4610.2(B) C4611.2(B) C4620.2(B) C4621.2(B) C4622.2(B) C4623.2(B) C4624.1(A) C4625.1(A) C4626.1(A) C4628.2(B) C4629.2(B) C4630.2(B) C4631.2(B) C4636.2(B) C4637.2(B) C4638.2(B) C4639.2(B) C4640.2(B) C4641.2(B) C4642.2(B) C4643.2(B) C4644.2(B) C4645.2(B) C4646.2(B) C4647.2(B) C4648.2(B) C4649.2(B) C4764.2(B) C4766.2(B) C4767.1(A) C4768.2(B) C4788.1(A) C4826.2(B) C4828.2(B) C4920.2(B) C4921.2(B) C4937.2(B) C6035.2(B) C6037.2(B) C6038.2(B) C7000.2(B) C7001.2(B) C7002.1(A) C7003.2(B) C7004.1(A) C7005.1(A) C7007.2(B) C7008.2(B) C7009.2(B) C7010.2(B) C7012.2(B) C7013.1(A) C7023.2(B) C7024.2(B) C7025.2(B) C7027.2(B) C7029.2(B) C7040.1(A) C7041.2(B) C7400.2(B) C7401.2(B) C7402.1(A) C7403.2(B) C7406.2(B) C7500.1(A) C7501.1(A) C7502.2(B) C7503.1(A) C7504.2(B) C7505.2(B) C7506.2(B) C7507.2(B) C7508.2(B) C7511.2(B) C7512.2(B) C7513.2(B) C7514.2(B) C7515.2(B) C7516.2(B) C7517.2(B) C7518.2(B) C7519.2(B) C7520.2(B) C7521.2(B) C7522.2(B) C7523.2(B) C7524.2(B) C7525.2(B) C7526.2(B) C7527.2(B) C7528.2(B) C7529.2(B) C7530.2(B) C7531.2(B) C7532.2(B) C7533.2(B) C7534.2(B) C7535.2(B) C7536.2(B) C7537.2(B) C7538.2(B) C7539.2(B) C7540.2(B) C7541.2(B) C7542.2(B) C7543.2(B) C7544.2(B) C7545.2(B) C7546.2(B) C7547.2(B) C7548.2(B) C7549.2(B) C7550.2(B) C7551.2(B) C7552.2(B) C7553.2(B) C7554.2(B) C7555.2(B) C7556.2(B) C7557.2(B) C7558.2(B) C7559.2(B) C7560.2(B) C7561.2(B) C7562.2(B) C7563.2(B) C7564.2(B) C7565.2(B) C7566.2(B) C7567.2(B) C7568.2(B) C7600.2(B) C7601.2(B) C7602.2(B) C7603.2(B) C7604.2(B) C7605.2(B) C7606.2(B) C7607.2(B) C7608.2(B) C7609.2(B) C7610.2(B) C7611.2(B) C7612.2(B) C7613.2(B) C7614.2(B) C7615.2(B) C7616.2(B) C7617.2(B) C7618.2(B) C7619.2(B) C7620.2(B) C7621.2(B) C7622.2(B) C7623.2(B) C7624.2(B) C7625.2(B) C7626.2(B) C7627.2(B) C7628.2(B) C60000.2(B) C60001.2(B) C60002.2(B) C60003.2(B) C60004.2(B) C60006.1(A) C60007.1(A) C60008.1(A) C60009.1(A) C60010.2(B) C60011.2(B) C60012.2(B) C60013.2(B) C60014.2(B) C60016.2(B) C60017.2(B) C60018.2(B) C60020.2(B) C60021.2(B) C60022.2(B) C60024.2(B) C60026.2(B) C60027.2(B) C60029.2(B) C60030.2(B) C60031.2(B) C60032.2(B) C60033.2(B) C60035.2(B) C60048.2(B) C60049.2(B) C60050.2(B) C60099.2(B) C60101.2(B) C60102.2(B) C60103.2(B) C60104.2(B) C60110.2(B) C60111.2(B) C60112.2(B) C60116.2(B) C60190.2(B) C60191.2(B) C60201.2(B) C60202.2(B) C60203.2(B) C60204.2(B) C60205.2(B) C60209.2(B) C60210.2(B) C60211.2(B) C60212.2(B) C60216.2(B) C60217.2(B) C60250.2(B) C60251.2(B) C60252.2(B) C60253.2(B) C60254.2(B) C60259.2(B) C60260.2(B) C60261.2(B) C60262.2(B) C60263.2(B) C60266.2(B) C60280.2(B) C60300.2(B) C60301.2(B) C60302.2(B) C60303.2(B) C60304.2(B) C60310.2(B) C60311.2(B) C60312.2(B) C60313.2(B) C60316.2(B) C60400.2(B) C60401.2(B) C60410.2(B) C60500.2(B) C60501.2(B) C60502.2(B) C60510.2(B) C60511.2(B) C60516.2(B) C60600.2(B) C60601.2(B) C60602.2(B) C60603.2(B) C60604.2(B) C60609.2(B) C60610.2(B) C60611.2(B) C60612.2(B) C60616.2(B) C60630.2(B) C60900.2(B) C60901.2(B) C60902.2(B) C60903.2(B) C60904.2(B) C60909.2(B) C60910.2(B) C60911.2(B) C60912.2(B) C60916.2(B) C60930.2(B) C61400.2(B) C61401.2(B) C61402.2(B) C61410.2(B) C61411.2(B) C61416.2(B) C61700.2(B) C61710.2(B) C66000.2(B) C66001.2(B) C66002.2(B) C66003.2(B) C66004.2(B) C66005.2(B) C66010.2(B) C66011.2(B) C66012.2(B) C66014.2(B) C66016.2(B) C66017.2(B) C66020.2(B) C66021.2(B) C66022.2(B) C66024.2(B) C66026.2(B) C66027.2(B) C66030.2(B) C66031.2(B) C66032.2(B) C66034.2(B) C66036.2(B) C66037.2(B) C66100.2(B) C66101.2(B) C66107.2(B) C66110.2(B) C66111.2(B) C66115.2(B) C66160.2(B) C66172.1(A) C66197.2(B) C66199.2(B) C66299.2(B) C66300.2(B) C66301.2(B) C66302.2(B) C66303.2(B) C66304.2(B) C66305.2(B) C66310.2(B) C66311.2(B) C66312.2(B) C66314.2(B) C66316.2(B) C66317.2(B) C66399.2(B) C66407.1(A) C66472.1(A) C66599.2(B) C66600.2(B) C66601.2(B) C66607.2(B) C66610.2(B) C66614.2(B) C66616.2(B) C66617.2(B) C66672.1(A) C66806.2(B) C68052.2(B) C68098.2(B) C68099.2(B) C76020.2(B) CN200.1 CN200.2 CN200.G1 CN200.G2 CN300.2 CN300.10 CN300.G1 CN300.G2 CN301.1 CN301.2 CN301.G1 CN301.G2 CN303.5 CN303.G1 CN303.G2 CN366.4 CN367.4 CN375.3 CN375.24 CN375.G1 CN375.G2 CN375.G3 CN375.G4 CN550.G1(G) CN550.G2(G_1) CN1300.1 CN1300.7 CN1300.13 CN1300.19 CN1300.33 CN1300.39 CN1300.45 CN1300.51 CN1300.57 CN1300.63 CN1300.69 CN1300.75 CN1300.G1 CN1300.G2 CN1400.3(GND3) CN1400.5(GND5) CN1400.11(GND11) CN1400.27(GND_27) CN1400.33(GND_33) CN1400.39(GND_39) CN1400.45(GND_45) CN1400.51(GND_51) CN1400.57(GND_57) CN1400.71(GND_71) CN1400.73(GND_73) CN1400.G1(GND_G1) CN1400.G2(GND_G2) CN1451.C5 CN1451.G1 CN1451.G2 CN1451.G3 CN1451.G4 CN1451.G5 CN1451.G6 CN1951.1(GND1) CN1951.3(GND2) CN1951.9(GND3) CN1951.15(GND4) CN1951.21(GND5) CN1951.27(GND6) CN1951.33(GND7) CN1951.39(GND8) CN1951.45(GND9) CN1951.51(GND10) CN1951.57(GND11) CN1951.71(GND12) CN1951.73(GND13) CN1951.G1(GND15) CN1951.G2(GND16) CN2200.4 CN2200.G1 CN2200.G2 CN2500.3 CN2500.6 CN2500.9 CN2500.12 CN2500.15 CN2500.18 CN2500.21 CN2500.G1 CN2500.G2 CN2501.1 CN2501.2 CN2501.3 CN2501.G1 CN2501.G2 CN2700.4 CN2701.15 CN2701.G1 CN2701.G2 CN2800.A1 CN2800.A12 CN2800.B1 CN2800.B12 CN2800.G1 CN2800.G2 CN2800.G3 CN2800.G4 CN2800.G5 CN2800.G6 CN2800.G7 CN2800.G8 CN2800.G9 CN2800.G10 CN2900.A1 CN2900.A12 CN2900.B1 CN2900.B12 CN2900.G1 CN2900.G2 CN2900.G3 CN2900.G4 CN2900.G5 CN2900.G6 CN2900.G7 CN2900.G8 CN2900.G9 CN2900.G10 CN3000.5 CN3000.14 CN3000.15 CN3000.20 CN3000.28 CN3000.31 CN3000.34 CN3000.37 CN3000.40 CN3000.G1 CN3000.G2 CN3000.G3 CN3000.G4 CN3000.G5 CN3001.3 CN3001.6 CN3001.11 CN3001.G1 CN3001.G2 CN3001.G3 CN3001.G4 CN3150.2 CN3150.5 CN3150.8 CN3150.11 CN3150.17 CN3150.G1 CN3150.G2 CN3150.G3 CN3150.G4 CN4100.1(VSS) CN4100.2(VSS_1) CN4100.5(VSS_2) CN4100.6(VSS_3) CN4100.9(VSS_4) CN4100.10(VSS_5) CN4100.14(VSS_6) CN4100.15(VSS_7) CN4100.18(VSS_8) CN4100.19(VSS_9) CN4100.22(VSS_10) CN4100.23(VSS_11) CN4100.26(VSS_12) CN4100.27(VSS_13) CN4100.30(VSS_14) CN4100.31(VSS_15) CN4100.35(VSS_16) CN4100.36(VSS_17) CN4100.39(VSS_18) CN4100.40(VSS_19) CN4100.43(VSS_20) CN4100.44(VSS_21) CN4100.47(VSS_22) CN4100.48(VSS_23) CN4100.51(VSS_24) CN4100.52(VSS_25) CN4100.56(VSS_26) CN4100.57(VSS_27) CN4100.60(VSS_28) CN4100.61(VSS_29) CN4100.64(VSS_30) CN4100.65(VSS_31) CN4100.68(VSS_32) CN4100.69(VSS_33) CN4100.72(VSS_34) CN4100.73(VSS_35) CN4100.77(VSS_36) CN4100.78(VSS_37) CN4100.81(VSS_38) CN4100.82(VSS_39) CN4100.85(VSS_40) CN4100.86(VSS_41) CN4100.89(VSS_42) CN4100.90(VSS_43) CN4100.93(VSS_44) CN4100.94(VSS_45) CN4100.98(VSS_46) CN4100.99(VSS_47) CN4100.102(VSS_48) CN4100.103(VSS_49) CN4100.106(VSS_50) CN4100.107(VSS_51) CN4100.167(VSS_52) CN4100.168(VSS_53) CN4100.171(VSS_54) CN4100.172(VSS_55) CN4100.175(VSS_56) CN4100.176(VSS_57) CN4100.180(VSS_58) CN4100.181(VSS_59) CN4100.184(VSS_60) CN4100.185(VSS_61) CN4100.188(VSS_62) CN4100.189(VSS_63) CN4100.192(VSS_64) CN4100.193(VSS_65) CN4100.196(VSS_66) CN4100.197(VSS_67) CN4100.201(VSS_68) CN4100.202(VSS_69) CN4100.205(VSS_70) CN4100.206(VSS_71) CN4100.209(VSS_72) CN4100.210(VSS_73) CN4100.213(VSS_74) CN4100.214(VSS_75) CN4100.217(VSS_76) CN4100.218(VSS_77) CN4100.222(VSS_78) CN4100.223(VSS_79) CN4100.226(VSS_80) CN4100.227(VSS_81) CN4100.230(VSS_82) CN4100.231(VSS_83) CN4100.234(VSS_84) CN4100.235(VSS_85) CN4100.238(VSS_86) CN4100.239(VSS_87) CN4100.243(VSS_88) CN4100.244(VSS_89) CN4100.247(VSS_90) CN4100.248(VSS_91) CN4100.251(VSS_92) CN4100.252(VSS_93) CN4100.G1 CN4100.G2 CN4125.1(VSS) CN4125.2(VSS_1) CN4125.5(VSS_2) CN4125.6(VSS_3) CN4125.9(VSS_4) CN4125.10(VSS_5) CN4125.14(VSS_6) CN4125.15(VSS_7) CN4125.18(VSS_8) CN4125.19(VSS_9) CN4125.22(VSS_10) CN4125.23(VSS_11) CN4125.26(VSS_12) CN4125.27(VSS_13) CN4125.30(VSS_14) CN4125.31(VSS_15) CN4125.35(VSS_16) CN4125.36(VSS_17) CN4125.39(VSS_18) CN4125.40(VSS_19) CN4125.43(VSS_20) CN4125.44(VSS_21) CN4125.47(VSS_22) CN4125.48(VSS_23) CN4125.51(VSS_24) CN4125.52(VSS_25) CN4125.56(VSS_26) CN4125.57(VSS_27) CN4125.60(VSS_28) CN4125.61(VSS_29) CN4125.64(VSS_30) CN4125.65(VSS_31) CN4125.68(VSS_32) CN4125.69(VSS_33) CN4125.72(VSS_34) CN4125.73(VSS_35) CN4125.77(VSS_36) CN4125.78(VSS_37) CN4125.81(VSS_38) CN4125.82(VSS_39) CN4125.85(VSS_40) CN4125.86(VSS_41) CN4125.89(VSS_42) CN4125.90(VSS_43) CN4125.93(VSS_44) CN4125.94(VSS_45) CN4125.98(VSS_46) CN4125.99(VSS_47) CN4125.102(VSS_48) CN4125.103(VSS_49) CN4125.106(VSS_50) CN4125.107(VSS_51) CN4125.167(VSS_52) CN4125.168(VSS_53) CN4125.171(VSS_54) CN4125.172(VSS_55) CN4125.175(VSS_56) CN4125.176(VSS_57) CN4125.180(VSS_58) CN4125.181(VSS_59) CN4125.184(VSS_60) CN4125.185(VSS_61) CN4125.188(VSS_62) CN4125.189(VSS_63) CN4125.192(VSS_64) CN4125.193(VSS_65) CN4125.196(VSS_66) CN4125.197(VSS_67) CN4125.201(VSS_68) CN4125.202(VSS_69) CN4125.205(VSS_70) CN4125.206(VSS_71) CN4125.209(VSS_72) CN4125.210(VSS_73) CN4125.213(VSS_74) CN4125.214(VSS_75) CN4125.217(VSS_76) CN4125.218(VSS_77) CN4125.222(VSS_78) CN4125.223(VSS_79) CN4125.226(VSS_80) CN4125.227(VSS_81) CN4125.230(VSS_82) CN4125.231(VSS_83) CN4125.234(VSS_84) CN4125.235(VSS_85) CN4125.238(VSS_86) CN4125.239(VSS_87) CN4125.243(VSS_88) CN4125.244(VSS_89) CN4125.247(VSS_90) CN4125.248(VSS_91) CN4125.251(VSS_92) CN4125.252(VSS_93) CN4125.G1 CN4125.G2 CN4300.2 CN4300.G1(G) CN4300.G2(G_1) CN4350.7 CN4350.14 CN4350.G1 CN4350.G2 CN4750.2 CN4750.G1 CN4750.G2 CN4920.2(GND1) CN4920.7(GND2) CN4920.8(GND3) CN4920.13(GND4) CN4920.14(GND5) CN4920.19(GND6) CN4920.20(GND7) CN4920.25(GND8) CN4920.26(GND9) CN4920.31(GND10) CN4920.32(GND11) CN4920.37(GND12) CN4920.38(GND13) CN4920.49(GND14) CN4920.50(GND15) CN4920.59(GND16) CN4941.8 CN4941.10 CN4941.12 CN4941.14 CN4941.G1 CN4941.G2 CN6000.5 CN6000.6 CN6000.7 CN6000.G1 CN6000.G2 CN6050.7 CN6050.8 CN6050.9 CN6050.G1 CN6050.G2 CP1.1 CP2.1 CP3.1 CP4.1 CP5.1 CP6.1 CP7.1 CP8.1 CP10.1 CP11.1 CP12.1 CP13.1 CP17.1 CP18.1 CP19.1 CP20.1 CP21.1 CP22.1 CP23.1 D500.1 D1401.2 D1402.2 D1404.2 D1405.2 D1451.2(A2) D2201.2 D2202.2 D2603.2 D2604.2 D2605.2 D2606.3 D2606.8 D2614.3 D2614.8 D2615.2 D2618.2 D2619.2 D2806.2 D2807.2 D2813.2 D2814.2 D2815.2 D2816.2 D2817.2 D2818.2 D2819.2 D2820.2 D2900.2 D2901.2 D2902.2 D2903.2 D2904.2 D2905.2 D2906.2 D2907.2 D4300.2 D4301.2 D6035.3 D7500.1 D7504.1 D7505.1 L7500.5(GND1) L7500.6(GND2) L7501.5(GND1) L7501.6(GND2) L7502.5(GND1) L7502.6(GND2) L7503.5(GND1) L7503.6(GND2) PAD300.1 PAD310.1 Q301.S Q303.1 Q303.4 Q305.1 Q305.4 Q307.1 Q307.4 Q500.S Q1001.1 Q1001.4 Q1002.1 Q1002.4 Q1004.S Q1300.S Q1302.S Q1401.S Q1951.S Q2602.S Q2605.1 Q2605.4 Q2607.1 Q2607.4 Q2613.S Q2620.1 Q2620.4 Q3001.1 Q3001.4 Q3003.S Q3800.1 Q3800.4 Q4300.4 Q4751.1 Q4751.4 Q4921.S Q7000.1 Q7000.4 Q7002.1 Q7002.4 Q7003.1 Q7003.4 Q7005.1 Q7005.4 Q7006.S Q7011.S Q7300.1 Q7300.4 Q7306.1 Q7306.4 Q7307.1 Q7307.4 Q60001.1(S0) Q60001.2(S1) Q60001.3(S2) Q60002.1(S0) Q60002.2(S1) Q60002.3(S2) Q60035.S Q68000.3(C) Q68054.S Q68098.S R321.2(B) R329.2(B) R342.2(B) R345.2(B) R348.2(B) R349.2(B) R357.2(B) R370.2(B) R380.2(B) R387.2(B) R399.1(A) R402.1(A) R431.2(B) R509.1(A) R510.1(A) R519.1(A) R906.2(B) R1004.2(B) R1007.2(B) R1009.2(B) R1016.1(A) R1018.2(B) R1019.1(A) R1317.1(A) R1332.2(B) R1333.1(A) R1336.1(A) R1345.1(A) R1412.2(B) R1417.1(A) R2200.2(B) R2423.2(B) R2425.2(B) R2457.1(A) R2464.1(A) R2465.1(A) R2500.1(A) R2501.2(B) R2503.1(A) R2600.2(B) R2603.1(A) R2605.2(B) R2606.1(A) R2607.2(B) R2608.2(B) R2609.1(A) R2610.2(B) R2614.1(A) R2615.1(A) R2616.2(B) R2617.1(A) R2622.2(B) R2623.1(A) R2624.2(B) R2627.1(A) R2629.1(A) R2630.1(A) R2631.1(A) R2632.1(A) R2640.2(B) R2641.2(B) R2642.1(A) R2643.1(A) R2700.1(A) R2701.1(A) R2706.2(B) R2708.1(A) R2721.1(A) R2723.1(A) R2731.1(A) R2732.1(A) R2733.1(A) R2734.1(A) R2735.1(A) R2736.1(A) R2737.1(A) R2738.1(A) R2739.1(A) R2740.1(A) R2741.1(A) R2749.2(B) R3003.2(B) R3006.1(A) R3007.2(B) R3008.2(B) R3012.2(B) R3021.2(B) R3023.2(B) R3026.2(B) R3028.1(A) R3033.2(B) R3035.1(A) R3036.1(A) R3300.2(B) R3302.2(B) R3304.2(B) R3305.2(B) R3308.2(B) R3310.2(B) R3312.2(B) R3314.2(B) R3320.2(B) R3323.2(B) R3324.1(A) R3339.2(B) R3342.2(B) R3356.2(B) R3502.2(B) R3505.2(B) R3801.1(A) R3813.1(A) R4100.2(B) R4101.2(B) R4111.1(A) R4122.1(A) R4125.2(B) R4131.1(A) R4136.1(A) R4415.2(B) R4504.2(B) R4505.2(B) R4509.2(B) R4510.1(A) R4514.2(B) R4518.2(B) R4519.1(A) R4523.2(B) R4524.2(B) R4526.2(B) R4527.2(B) R4529.2(B) R4531.2(B) R4533.1(A) R4534.2(B) R4540.2(B) R4541.2(B) R4543.1(A) R4555.1(A) R4559.1(A) R4562.1(A) R4564.2(B) R4566.2(B) R4572.1(A) R4574.1(A) R4576.1(A) R4578.1(A) R4582.2(B) R4587.1(A) R4588.1(A) R4589.2(B) R4597.2(B) R4598.2(B) R4603.2(B) R4606.1(A) R4619.1(A) R4621.1(A) R4713.2(B) R4724.1(A) R4727.1(A) R4756.2(B) R4758.2(B) R4759.2(B) R4774.1(A) R4803.2(B) R4804.2(B) R4805.2(B) R4806.2(B) R4811.2(B) R4812.2(B) R4819.2(B) R4823.1(A) R4837.1(A) R4842.2(B) R4851.2(B) R4858.2(B) R4859.2(B) R4860.2(B) R4863.2(B) R4864.2(B) R4893.2(B) R4900.2(B) R4945.2(B) R4970.1(A) R7003.2(B) R7008.1(A) R7029.1(A) R7401.2(B) R7412.1(A) R7418.2(B) R60002.2(B) R60014.1(A) R60017.1(A) R60022.2(B) R60032.2(B) R60199.2(B) R60201.1(A) R60206.2(B) R60255.1(A) R60302.1(A) R60346.1(A) R60349.2(B) R60401.2(B) R60523.2(B) R60526.2(B) R60529.1(A) R60601.2(B) R60605.2(B) R60901.2(B) R60903.1(A) R60905.2(B) R61421.2(B) R61428.2(B) R61701.2(B) R66107.2(B) R66112.2(B) R66113.2(B) R66115.2(B) R66160.2(B) R66197.1(A) R66198.2(B) R66407.1(A) R66607.2(B) R68004.2(B) R68094.2(B) R68099.2(B) R68100.2(B) R68101.2(B) R68102.2(B) R68103.2(B) R68104.2(B) R68105.2(B) R68106.2(B) R68107.2(B) R68108.2(B) R68109.2(B) R68121.2(B) R68122.2(B) R68125.2(B) S5.1 S6.1 S7.1 S8.1 S9.1 S12.1 S13.1 S14.1 S15.1 S16.1 S17.1 S18.1 S19.1 S20.1 S21.1 S22.1 S30.1 S31.1 S32.1 S33.1 ST1300.1 ST1400.1 ST1950.1 SW1000.T1 TP854.1 TP2522.1 TP4301.1 TP4751.1 TP6002.1 TP6052.1 U300.A1(VSS_2) U300.A5 U300.A8(VSS_1) U300.E12(VSS_8) U300.G1(VSS_4) U300.J12(VSS_7) U300.M3(VSS_5) U300.M9(VSS_6) U302.2(GND) U366.4 U366.9 U367.4 U367.9 U500.49 U1000.7 U1300.3 U1400.A2 U1400.A3 U1400.B1 U1400.B3 U1400.C1 U1400.D3 U1401.2 U1401.3 U2403.D5 U2403.D6 U2403.D7 U2403.D8 U2403.E4 U2403.E5 U2403.E6 U2403.E7 U2403.E8 U2403.F4 U2403.F5 U2403.F6 U2403.F7 U2403.F8 U2403.G4 U2403.G5 U2403.G6 U2403.G7 U2403.H7 U2500.2 U2501.14 U2501.17 U2600.B3(GND1) U2600.C3(GND2) U2600.D3(GND3) U2602.B3(GND1) U2602.C3(GND2) U2602.D3(GND3) U2700.A1(PB_MONDC) U2700.A2(VSS_ANA<40>) U2700.A4(VSS_ANA<41>) U2700.A6(VSS_ANA<39>) U2700.A8(VSS_ANA<44>) U2700.A10(VSS_ANA<42>) U2700.A12(VSS_ANA<43>) U2700.A14(VSS_ANA<38>) U2700.A16(VSS_ANA<37>) U2700.A18(VSS_ANA<36>) U2700.A20(VSS_ANA<35>) U2700.A22(VSS_ANA<34>) U2700.A23(PA_MONDC) U2700.AA22(VSS_ANA<32>) U2700.AA23(VSS_ANA<33>) U2700.AB1(VSS_ANA<110>) U2700.AB2(VSS_ANA<31>) U2700.AB4(VSS_ANA<30>) U2700.AB6(VSS_ANA<29>) U2700.AB8(VSS_ANA<28>) U2700.AB10(VSS_ANA<27>) U2700.AB12(VSS_ANA<26>) U2700.AB14(VSS_ANA<25>) U2700.AB16(VSS_ANA<24>) U2700.AB18(VSS_ANA<23>) U2700.AB20(VSS_ANA<22>) U2700.AB22(VSS_ANA<21>) U2700.AC1(USB_MONDC) U2700.AC2(VSS_ANA<20>) U2700.AC4(VSS_ANA<19>) U2700.AC6(VSS_ANA<18>) U2700.AC8(VSS_ANA<17>) U2700.AC10(VSS_ANA<16>) U2700.AC12(VSS_ANA<15>) U2700.AC14(VSS_ANA<14>) U2700.AC16(VSS_ANA<13>) U2700.AC18(VSS_ANA<12>) U2700.AC20(VSS_ANA<11>) U2700.AC22(VSS_ANA<10>) U2700.AC23(PC_MONDC) U2700.B1(VSS_ANA<9>) U2700.B2(VSS_ANA<8>) U2700.B4(VSS_ANA<7>) U2700.B6(VSS_ANA<45>) U2700.B8(VSS_ANA<6>) U2700.B10(VSS_ANA<5>) U2700.B12(VSS_ANA<4>) U2700.B14(VSS_ANA<3>) U2700.B16(VSS_ANA<2>) U2700.B18(VSS_ANA<1>) U2700.B20(VSS_ANA<0>) U2700.B22(VSS_ANA<46>) U2700.C22(VSS_ANA<47>) U2700.C23(VSS_ANA<48>) U2700.D1(VSS_ANA<49>) U2700.D2(VSS_ANA<50>) U2700.D4(TEST_EDM) U2700.D5(MONDC_SVR) U2700.D6(VSS_ANA<51>) U2700.D8(VSS_ANA<52>) U2700.D9(VSS_ANA<53>) U2700.D11(VSS_ANA<54>) U2700.D12(VSS_ANA<55>) U2700.D13(VSS_ANA<56>) U2700.D15(VSS_ANA<99>) U2700.D16(VSS_ANA<100>) U2700.D18(VSS_ANA<101>) U2700.E4(VSS_ANA<102>) U2700.E9(VSS_ANA<103>) U2700.E11(VSS_ANA<63>) U2700.E12(VSS_ANA<64>) U2700.E13(VSS_ANA<65>) U2700.E15(VSS_ANA<66>) U2700.E18(VSS_ANA<67>) U2700.E22(VSS_ANA<68>) U2700.E23(VSS_ANA<69>) U2700.F1(VSS_ANA<70>) U2700.F2(VSS_ANA<71>) U2700.F4(VSS<8>) U2700.F5(VSS_ANA<72>) U2700.F6(VSS_ANA<111>) U2700.F8(VSS_ANA<112>) U2700.F9(VSS_ANA<113>) U2700.F11(VSS_ANA<117>) U2700.F12(VSS_ANA<116>) U2700.F13(VSS_ANA<115>) U2700.F15(VSS_ANA<114>) U2700.F16(VSS_ANA<73>) U2700.F20(VSS_ANA<74>) U2700.G22(VSS_ANA<75>) U2700.G23(VSS_ANA<76>) U2700.H1(SVR_VSS<0>) U2700.H20(VSS_ANA<77>) U2700.J1(SVR_VSS<1>) U2700.J2(SVR_VSS<2>) U2700.J12(VSS_ANA<78>) U2700.J15(VSS_ANA<79>) U2700.J16(VSS_ANA<130>) U2700.J19(VSS_ANA<80>) U2700.J20(VSS_ANA<81>) U2700.J22(VSS_ANA<82>) U2700.J23(VSS_ANA<83>) U2700.L8(FUSE_VQPS_64) U2700.L9(VSS<7>) U2700.L12(VSS<6>) U2700.L15(VSS<5>) U2700.L20(VSS_ANA<84>) U2700.L22(VSS_ANA<85>) U2700.L23(VSS_ANA<86>) U2700.M1(VSS<4>) U2700.M2(VSS<3>) U2700.M6(VSS_ANA<118>) U2700.M9(VSS<2>) U2700.M12(VSS<1>) U2700.M15(VSS<0>) U2700.M20(VSS_ANA<87>) U2700.N9(VSS<9>) U2700.N12(VSS<10>) U2700.N15(VSS<11>) U2700.N18(VSS_ANA<120>) U2700.N19(VSS_ANA<119>) U2700.N20(VSS_ANA<88>) U2700.N22(VSS_ANA<89>) U2700.N23(VSS_ANA<90>) U2700.R4(TEST_EN) U2700.R9(VSS<12>) U2700.R12(VSS<13>) U2700.R15(VSS<14>) U2700.R18(VSS_ANA<91>) U2700.R19(VSS_ANA<92>) U2700.R20(VSS_ANA<93>) U2700.R22(VSS_ANA<94>) U2700.R23(VSS_ANA<95>) U2700.T6(VSS<15>) U2700.T18(VSS<16>) U2700.T20(VSS_ANA<62>) U2700.U22(VSS_ANA<61>) U2700.U23(VSS_ANA<60>) U2700.V9(VSS_ANA<59>) U2700.V11(VSS_ANA<58>) U2700.V12(VSS_ANA<57>) U2700.V13(VSS_ANA<96>) U2700.V15(VSS_ANA<97>) U2700.V16(VSS<17>) U2700.V18(VSS<18>) U2700.V20(VSS_ANA<98>) U2700.W8(VSS_ANA<104>) U2700.W9(VSS_ANA<105>) U2700.W11(VSS_ANA<106>) U2700.W12(VSS_ANA<107>) U2700.W13(VSS_ANA<108>) U2700.W15(VSS_ANA<109>) U2700.W22(VSS_ANA<121>) U2700.W23(VSS_ANA<122>) U2700.Y5(VSS_ANA<123>) U2700.Y8(VSS_ANA<124>) U2700.Y9(VSS_ANA<125>) U2700.Y11(VSS_ANA<126>) U2700.Y12(VSS_ANA<127>) U2700.Y13(VSS_ANA<128>) U2700.Y15(VSS_ANA<129>) U2701.3 U2702.3 U2703.4 U2703.9 U3000.2 U3001.2 U3002.2 U3003.2 U3150.2 U3300.26(GND) U3300.35(GND_1) U3300.43(GND_2) U3300.57(EPAD) U3500.2 U3500.9 U3500.23 U3500.32 U3500.33(THERMEAL PAD) U3800.A6 U3800.C4 U3800.E7 U3800.G5 U3800.H10 U3800.J5 U3800.K8 U3800.N2 U3800.N5 U3800.P4 U3800.P6 U4411.5 U4412.2(GND) U4413.2(GND) U4413.4(HYST) U4555.A3(VSS_358) U4555.A4(VSS_390) U4555.AB3(VSS_340) U4555.AB4(VSS_339) U4555.AB7(VSS_366) U4555.AB27(VSS_418) U4555.AB30(VSS_357) U4555.AB33(VSS_387) U4555.AB36(VSS_417) U4555.AC5(VSS_121) U4555.AC10(VSS_396) U4555.AC27(VSS_324) U4555.AC30(VSS_346) U4555.AD33(VSS_395) U4555.AD35(VSS_323) U4555.AE7(VSS_322) U4555.AE24(VSS_400) U4555.AE25(VSS_337) U4555.AE26(VSS_410) U4555.AE27(VSS_364) U4555.AE30(VSS_302) U4555.AF3(VSS_373) U4555.AF4(VSS_343) U4555.AF7(VSS_362) U4555.AF25(VSS_420) U4555.AF27(VSS_344) U4555.AF30(VSS_307) U4555.AF33(VSS_321) U4555.AF36(VSS_335) U4555.AG5(VSS_133) U4555.AG10(VSS_432) U4555.AG24(VSS_428) U4555.AG26(VSS_434) U4555.AH24(VSS_296) U4555.AH25(VSS_350) U4555.AH27(VSS_320) U4555.AH28(VSS_405) U4555.AH29(VSS_431) U4555.AH30(VSS_305) U4555.AH31(VSS_319) U4555.AH33(VSS_404) U4555.AH35(VSS_423) U4555.AJ7(VSS_383) U4555.AJ25(VSS_292) U4555.AJ28(VSS_304) U4555.AK3(VSS_403) U4555.AK4(VSS_310) U4555.AK33(VSS_422) U4555.AK36(VSS_291) U4555.AL7(VSS_208) U4555.AL28(VSS_382) U4555.AL29(VSS_412) U4555.AL32(VSS_156) U4555.AM5(VSS_67) U4555.AM10(VSS_227) U4555.AM28(VSS_263) U4555.AM33(VSS_289) U4555.AM35(VSS_200) U4555.AN7(VSS_274) U4555.AN8(VSS_193) U4555.AN25(VSS_249) U4555.AN28(VSS_288) U4555.AN29(VSS_199) U4555.AN30(VSS_215) U4555.AN31(VSS_236) U4555.AP3(VSS_235) U4555.AP4(VSS_204) U4555.AP33(VSS_273) U4555.AP36(VSS_192) U4555.AR4(VSS_61) U4555.AR28(VSS_223) U4555.AT4(VSS_184) U4555.AT33(VSS_259) U4555.AT35(VSS_153) U4555.AT36(VSS_171) U4555.AU4(VSS_68) U4555.AU10(VSS_191) U4555.AU28(VSS_285) U4555.AU29(VSS_170) U4555.AU32(VSS_186) U4555.AV3(VSS_179) U4555.AV4(VSS_160) U4555.AV6(VSS_178) U4555.AV8(VSS_243) U4555.AV25(VSS_270) U4555.AV28(VSS_161) U4555.AV33(VSS_244) U4555.AV36(VSS_269) U4555.AW1(VSS_401) U4555.AW3(VSS_221) U4555.AW4(VSS_74) U4555.AW28(VSS_282) U4555.AW29(VSS_167) U4555.AW30(VSS_254) U4555.AW31(VSS_148) U4555.AY4(VSS_360) U4555.AY33(VSS_203) U4555.AY35(VSS_230) U4555.B2(VSS_359) U4555.B5(VSS_89) U4555.B7(VSS_110) U4555.B9(VSS_145) U4555.B12(VSS_253) U4555.B15(VSS_280) U4555.B18(VSS_196) U4555.B21(VSS_219) U4555.B23(VSS_240) U4555.B25(VSS_265) U4555.B27(VSS_190) U4555.B29(VSS_209) U4555.B31(VSS_239) U4555.B34(VSS_370) U4555.B36(VSS_369) U4555.B37(VSS_73) U4555.BA3(VSS_72) U4555.BA4(VSS_26) U4555.BA6(VSS_122) U4555.BA10(VSS_35) U4555.BA28(VSS_59) U4555.BB3(VSS_144) U4555.BB4(VSS_119) U4555.BB33(VSS_34) U4555.BB36(VSS_58) U4555.BC4(VSS_134) U4555.BC8(VSS_41) U4555.BC25(VSS_12) U4555.BC29(VSS_57) U4555.BC32(VSS_129) U4555.BD4(VSS_36) U4555.BD6(VSS_421) U4555.BD7(VSS_54) U4555.BD28(VSS_101) U4555.BD33(VSS_128) U4555.BD35(VSS_21) U4555.BD36(VSS_48) U4555.BE3(VSS_93) U4555.BE4(VSS_3) U4555.BE8(VSS_15) U4555.BE10(VSS_107) U4555.BE28(VSS_140) U4555.BE29(VSS_30) U4555.BE30(VSS_115) U4555.BE31(VSS_8) U4555.BF3(VSS_92) U4555.BF4(VSS_18) U4555.BF33(VSS_114) U4555.BF36(VSS_138) U4555.BG4(VSS_45) U4555.BG25(VSS_86) U4555.BG28(VSS_97) U4555.BH28(VSS_6) U4555.BH29(VSS_81) U4555.BH32(VSS_90) U4555.BH33(VSS_103) U4555.BH35(VSS_123) U4555.BJ7(VSS_368) U4555.BK2(VSS_426) U4555.BK3(VSS_367) U4555.BK4(VSS_325) U4555.BK7(VSS_347) U4555.BK10(VSS_398) U4555.BK28(VSS_348) U4555.BK33(VSS_397) U4555.BL7(VSS_330) U4555.BL25(VSS_376) U4555.BL28(VSS_406) U4555.BL29(VSS_331) U4555.BL30(VSS_355) U4555.BL31(VSS_375) U4555.BL32(VSS_309) U4555.BM9(VSS_329) U4555.BM33(VSS_345) U4555.BM35(VSS_374) U4555.BM36(VSS_308) U4555.BN7(VSS_295) U4555.BN30(VSS_353) U4555.BP3(VSS_294) U4555.BP4(VSS_415) U4555.BP7(VSS_293) U4555.BP12(VSS_4) U4555.BP15(VSS_328) U4555.BP19(VSS_5) U4555.BP25(VSS_416) U4555.BP32(VSS_306) U4555.BP33(VSS_327) U4555.BP36(VSS_1) U4555.BR16(VSS_17) U4555.BR19(VSS_326) U4555.BR22(VSS_69) U4555.BR25(VSS_414) U4555.BT5(VSS_351) U4555.BT14(VSS_135) U4555.BT15(VSS_298) U4555.BT16(VSS_311) U4555.BT25(VSS_297) U4555.BT28(VSS_372) U4555.BT33(VSS_392) U4555.BT35(VSS_277) U4555.BT36(VSS_165) U4555.BU7(VSS_262) U4555.BU11(VSS_238) U4555.BU16(VSS_55) U4555.BU20(VSS_75) U4555.BU23(VSS_155) U4555.BU24(VSS_207) U4555.BU25(VSS_226) U4555.BV3(VSS_248) U4555.BV4(VSS_214) U4555.BV11(VSS_154) U4555.BV31(VSS_287) U4555.BV33(VSS_198) U4555.BW7(VSS_177) U4555.BW11(VSS_247) U4555.BW15(VSS_185) U4555.BW24(VSS_272) U4555.BY5(VSS_361) U4555.BY11(VSS_187) U4555.BY15(VSS_258) U4555.BY18(VSS_28) U4555.BY19(VSS_38) U4555.BY22(VSS_152) U4555.BY25(VSS_180) U4555.BY28(VSS_245) U4555.BY33(VSS_284) U4555.BY35(VSS_169) U4555.BY36(VSS_182) U4555.C4(VSS_173) U4555.C9(VSS_231) U4555.C21(VSS_168) U4555.C25(VSS_222) U4555.C29(VSS_255) U4555.C33(VSS_149) U4555.C36(VSS_379) U4555.C37(VSS_389) U4555.CA11(VSS_267) U4555.CA15(VSS_158) U4555.CA22(VSS_211) U4555.CA25(VSS_147) U4555.CB2(VSS_218) U4555.CB3(VSS_79) U4555.CB4(VSS_120) U4555.CB7(VSS_14) U4555.CB11(VSS_202) U4555.CB18(VSS_279) U4555.CB19(VSS_195) U4555.CB20(VSS_251) U4555.CB24(VSS_16) U4555.CB25(VSS_278) U4555.CB33(VSS_95) U4555.CC7(VSS_130) U4555.CC11(VSS_44) U4555.CC14(VSS_62) U4555.CC16(VSS_47) U4555.CC20(VSS_78) U4555.CC24(VSS_27) U4555.CC25(VSS_13) U4555.CC28(VSS_43) U4555.CC31(VSS_64) U4555.CD11(VSS_23) U4555.CD12(VSS_42) U4555.CD14(VSS_63) U4555.CD20(VSS_80) U4555.CD24(VSS_142) U4555.CD25(VSS_22) U4555.CE7(VSS_31) U4555.CE33(VSS_49) U4555.CE35(VSS_108) U4555.CE36(VSS_141) U4555.CF2(VSS_39) U4555.CF3(VSS_19) U4555.CF4(VSS_83) U4555.CF11(VSS_94) U4555.CF14(VSS_116) U4555.CF19(VSS_9) U4555.CF23(VSS_99) U4555.CF28(VSS_126) U4555.CG7(VSS_125) U4555.CG33(VSS_98) U4555.CH31(VSS_77) U4555.CJ2(VSS_53) U4555.CJ3(VSS_60) U4555.CJ4(VSS_408) U4555.CJ11(VSS_104) U4555.CJ14(VSS_124) U4555.CJ19(VSS_70) U4555.CJ23(VSS_85) U4555.CJ28(VSS_96) U4555.CJ33(VSS_112) U4555.CJ35(VSS_136) U4555.CJ36(VSS_378) U4555.CK1(VSS_333) U4555.CK4(VSS_377) U4555.CK7(VSS_407) U4555.CK37(VSS_391) U4555.CL2(VSS_332) U4555.CM1(VSS_411) U4555.CM4(VSS_111) U4555.CM5(VSS_354) U4555.CM9(VSS_384) U4555.CM13(VSS_356) U4555.CM17(VSS_386) U4555.CM21(VSS_317) U4555.CM25(VSS_338) U4555.CM29(VSS_365) U4555.CM31(VSS_385) U4555.CM33(VSS_316) U4555.CM37(VSS_381) U4555.CN2(VSS_409) U4555.CN5(VSS_352) U4555.CN9(VSS_425) U4555.CN13(VSS_315) U4555.CN17(VSS_336) U4555.CN21(VSS_363) U4555.CN25(VSS_301) U4555.CN29(VSS_314) U4555.CN37(VSS_419) U4555.CP2(VSS_427) U4555.CP9(VSS_318) U4555.CP11(VSS_313) U4555.CP13(VSS_334) U4555.CP15(VSS_424) U4555.CP19(VSS_299) U4555.CP21(VSS_312) U4555.CP27(VSS_394) U4555.CP35(VSS_371) U4555.CP37(VSS_430) U4555.CR2(VSS_393) U4555.CR6(VSS_2) U4555.D5(VSS_402) U4555.D6(VSS_290) U4555.D8(VSS_172) U4555.D9(VSS_217) U4555.D21(VSS_429) U4555.D25(VSS_303) U4555.E9(VSS_275) U4555.E23(VSS_250) U4555.E27(VSS_276) U4555.E29(VSS_164) U4555.E31(VSS_216) U4555.E33(VSS_237) U4555.E35(VSS_380) U4555.F2(VSS_261) U4555.F3(VSS_224) U4555.F4(VSS_260) U4555.F12(VSS_194) U4555.F15(VSS_206) U4555.F18(VSS_225) U4555.F21(VSS_189) U4555.F24(VSS_205) U4555.F33(VSS_349) U4555.G9(VSS_286) U4555.G21(VSS_188) U4555.G27(VSS_197) U4555.G33(VSS_213) U4555.G35(VSS_234) U4555.G36(VSS_246) U4555.H9(VSS_271) U4555.H21(VSS_163) U4555.H27(VSS_181) U4555.J5(VSS_37) U4555.J6(VSS_256) U4555.J12(VSS_162) U4555.J15(VSS_176) U4555.J18(VSS_183) U4555.J21(VSS_257) U4555.J24(VSS_151) U4555.J33(VSS_175) U4555.J36(VSS_233) U4555.K3(VSS_281) U4555.K4(VSS_266) U4555.K9(VSS_157) U4555.K21(VSS_150) U4555.K22(VSS_174) U4555.K24(VSS_232) U4555.K25(VSS_268) U4555.K27(VSS_159) U4555.K28(VSS_212) U4555.K29(VSS_242) U4555.K30(VSS_166) U4555.K31(VSS_220) U4555.K32(VSS_241) U4555.L6(VSS_201) U4555.L27(VSS_210) U4555.L33(VSS_229) U4555.L35(VSS_252) U4555.L36(VSS_146) U4555.N6(VSS_66) U4555.N25(VSS_228) U4555.N27(VSS_264) U4555.P3(VSS_102) U4555.P4(VSS_52) U4555.P7(VSS_65) U4555.P10(VSS_84) U4555.P33(VSS_132) U4555.P36(VSS_25) U4555.R27(VSS_131) U4555.R28(VSS_24) U4555.R29(VSS_51) U4555.R30(VSS_71) U4555.R31(VSS_143) U4555.T7(VSS_32) U4555.T27(VSS_33) U4555.T30(VSS_50) U4555.T33(VSS_109) U4555.T35(VSS_118) U4555.T36(VSS_11) U4555.U7(VSS_117) U4555.U24(VSS_46) U4555.U26(VSS_56) U4555.V3(VSS_100) U4555.V4(VSS_106) U4555.V26(VSS_10) U4555.V27(VSS_40) U4555.V30(VSS_127) U4555.V33(VSS_20) U4555.V36(VSS_88) U4555.W7(VSS_105) U4555.W10(VSS_139) U4555.W27(VSS_29) U4555.W30(VSS_87) U4555.Y7(VSS_76) U4555.Y26(VSS_7) U4555.Y27(VSS_82) U4555.Y30(VSS_91) U4555.Y33(VSS_113) U4555.Y35(VSS_137) U4700.3(GND) U4920.2 U4921.2 U7000.3 U7001.11 U7001.15 U7400.4(V-) U60000.33 U60100.2 U60200.3(GND) U60200.11(GND_1) U60250.7 U60250.8 U60250.18 U60250.21 U60300.2 U60400.2 U60500.2 U60600.6(GND_2) U60600.14(GND_1) U60600.17(GND) U60900.6(GND_2) U60900.14(GND_1) U60900.17(GND) U61400.2 U61700.2 U66000.49(AGND) U66010.5(PGND1) U66010.6(PGND2) U66010.7(PGND3) U66010.8(PGND4) U66010.9(PGND5) U66010.10(PGND6) U66010.11(PGND7) U66010.12(PGND8) U66010.13(PGND9) U66010.19(AGND) U66020.5(PGND1) U66020.6(PGND2) U66020.7(PGND3) U66020.8(PGND4) U66020.9(PGND5) U66020.10(PGND6) U66020.11(PGND7) U66020.12(PGND8) U66020.13(PGND9) U66020.19(AGND) U66030.5(PGND1) U66030.6(PGND2) U66030.7(PGND3) U66030.8(PGND4) U66030.9(PGND5) U66030.10(PGND6) U66030.11(PGND7) U66030.12(PGND8) U66030.13(PGND9) U66030.19(AGND) U66310.5(PGND1) U66310.6(PGND2) U66310.7(PGND3) U66310.8(PGND4) U66310.9(PGND5) U66310.10(PGND6) U66310.11(PGND7) U66310.12(PGND8) U66310.13(PGND9) U66310.19(AGND) U66610.4(PGND) U66610.5(PGND_1) U66610.11(AGND) X2700.2 X2700.4 X4750.2 X4750.3 X4751.2 X4751.4
DGND_2ALS_H: C9302.2(B) CN9302.5 CN9302.6 CN9302.G1 CN9302.G2 R9305.1(A) U9302.1
DGND_ALS: C9300.2(B) CN9300.5 CN9300.6 CN9300.G1 CN9300.G2 R9301.1(A) U9300.1
DGND_DMIC_FRONT: C9353.2(B) C9354.2(B) C9357.2(B) C9360.2(B) CN9354.3 CN9354.G1 CN9354.G2 MIC9350.5 MIC9350.6 MIC9350.7 MIC9350.8 MIC9352.5 MIC9352.6 MIC9352.7 MIC9352.8 R9350.1(A)
DGND_USB: C9200.2(B) C9203.2(B) C9204.2(B) C9205.2(B) C9206.2(B) C9207.2(B) C9208.2(B) C9213.2(B) C9216.2(B) C9217.2(B) C9218.2(B) C9229.2(B) CN9200.4 CN9200.7 CN9200.G1 CN9200.G2 CN9200.G3 CN9200.G4 CN9201.4 CN9201.7 CN9201.G1 CN9201.G2 CN9201.G3 CN9201.G4 CN9202.9 CN9202.10 CN9202.13 CN9202.16 CN9202.19 CN9202.22 CN9202.25 CN9202.28 CN9202.G1 CN9202.G2 CN9203.4 CN9203.5 CN9203.6 CN9203.G1 CN9203.G2 D9200.3 D9200.8 D9201.3 D9201.8 D9202.3 D9202.8 D9203.3 D9203.8 D9204.2 D9205.2 D9206.2 R9202.2(B) R9203.2(B) R9207.2(B) R9219.2(B) R9220.2(B) R9224.2(B) S9201.1 S9202.1 S9203.1 U9201.10 U9201.21 U9201.25 U9203.10 U9203.21 U9203.25 U9204.GND
GND_ALS: C9301.2(B) CN9301.6 CN9301.G1 CN9301.G2 R9303.1(A) U9301.1
P0V6S: C4100.1(A) C4101.1(A) C4102.1(A) C4103.1(A) C4125.1(A) C4126.1(A) C4127.1(A) C4128.1(A) CN4100.258(VTT) CN4125.258(VTT) PAD60350.2 TP60350.1
P0V6S_DIMM0_VREF_CA: C4110.1(A) C4111.1(A) CN4100.164(VREFCA) R4106.1(A) R4122.2(B) R4503.1(A)
P0V6S_DIMM1_VREF_CA: C4144.1(A) C4145.1(A) CN4125.164(VREFCA) R4112.1(A) R4131.2(B) R4132.1(A)
P0V9_LC: C2781.1(A) U2700.J8(VCC0P9_LC)
P0V9_PCIE: C2768.1(A) C2769.1(A) C2770.1(A) C2771.1(A) C2772.1(A) U2700.J18(VCC0P9_PCIE) U2700.L18(VCC0P9_ANA_PCIE_2<0>) U2700.L19(VCC0P9_ANA_PCIE_1<0>) U2700.M16(VCC0P9_ANA_PCIE_2<1>) U2700.M18(VCC0P9_ANA_PCIE_2<2>) U2700.M19(VCC0P9_ANA_PCIE_1<1>)
P1V2: C4107.1(A) C4108.1(A) C4109.1(A) C4112.1(A) C4113.1(A) C4114.1(A) C4115.1(A) C4116.1(A) C4117.1(A) C4118.1(A) C4121.1(A) C4123.1(A) C4131.1(A) C4132.1(A) C4133.1(A) C4134.1(A) C4135.1(A) C4136.1(A) C4137.1(A) C4138.1(A) C4139.1(A) C4140.1(A) C4141.1(A) C4142.1(A) C4143.1(A) C4146.1(A) C4147.1(A) C4148.1(A) C4149.1(A) C4150.1(A) C4151.1(A) C4152.1(A) C4500.1(A) C4501.1(A) C4502.1(A) C4503.1(A) C4505.1(A) C4506.1(A) C4507.1(A) C4508.1(A) C4509.1(A) C4510.1(A) C4511.1(A) C7536.1(A) C7537.1(A) C7538.1(A) C7539.1(A) C7540.1(A) C7541.1(A) C7542.1(A) C7543.1(A) C7544.1(A) C7545.1(A) C7546.1(A) C7547.1(A) C7548.1(A) C7549.1(A) C7550.1(A) C7551.1(A) C7552.1(A) C7553.1(A) C7554.1(A) CN4100.12(DM0#/DBI0#) CN4100.33(DM1#/DBI1#) CN4100.54(DM2#/DBI2#) CN4100.75(DM3#/DBI3#) CN4100.96(DM8#/DBI8#) CN4100.111(VDD) CN4100.112(VDD_1) CN4100.117(VDD_2) CN4100.118(VDD_3) CN4100.123(VDD_4) CN4100.124(VDD_5) CN4100.129(VDD_6) CN4100.130(VDD_7) CN4100.135(VDD_8) CN4100.136(VDD_9) CN4100.141(VDD_10) CN4100.142(VDD_11) CN4100.147(VDD_12) CN4100.148(VDD_13) CN4100.153(VDD_14) CN4100.154(VDD_15) CN4100.159(VDD_16) CN4100.160(VDD_17) CN4100.163(VDD_18) CN4100.178(DM4#/DBI4#) CN4100.199(DM5#/DBI5#) CN4100.220(DM6#/DBI6#) CN4100.241(DM7#/DBI7#) CN4125.12(DM0#/DBI0#) CN4125.33(DM1#/DBI1#) CN4125.54(DM2#/DBI2#) CN4125.75(DM3#/DBI3#) CN4125.96(DM8#/DBI8#) CN4125.111(VDD) CN4125.112(VDD_1) CN4125.117(VDD_2) CN4125.118(VDD_3) CN4125.123(VDD_4) CN4125.124(VDD_5) CN4125.129(VDD_6) CN4125.130(VDD_7) CN4125.135(VDD_8) CN4125.136(VDD_9) CN4125.141(VDD_10) CN4125.142(VDD_11) CN4125.147(VDD_12) CN4125.148(VDD_13) CN4125.153(VDD_14) CN4125.154(VDD_15) CN4125.159(VDD_16) CN4125.160(VDD_17) CN4125.163(VDD_18) CN4125.178(DM4#/DBI4#) CN4125.199(DM5#/DBI5#) CN4125.220(DM6#/DBI6#) CN4125.241(DM7#/DBI7#) PAD60300.2 PAD60300.4 Q7159.1(D0) Q7159.2(D1) Q7159.5(D2) Q7159.6(D3) R4106.2(B) R4132.2(B) R4200.1(A) R4201.1(A) R4553.1(A) TP60300.1 U4555.AD36(VDDQ_1) U4555.AH32(VDDQ_2) U4555.AH36(VDDQ_3) U4555.AM36(VDDQ_4) U4555.AN32(VDDQ_5) U4555.AW32(VDDQ_6) U4555.AY36(VDDQ_7) U4555.BE32(VDDQ_8) U4555.BH36(VDDQ_9) U4555.R32(VDDQ_10) U4555.Y36(VDDQ_11)
P1V05A: C4513.2(B) C4519.2(B) C4533.2(B) C4540.2(B) C4543.2(B) C4547.1(A) C4548.1(A) CN4920.43(VCC_OBS_AB) CN4920.44(VCC_OBS_CD) PAD60900.2 PAD60900.4 Q7151.1(D0) Q7151.2(D1) Q7151.5(D2) Q7151.6(D3) Q7153.1(D0) Q7153.2(D1) Q7153.5(D2) Q7153.6(D3) R4558.1(A) R4583.1(A) R4585.1(A) R4609.1(A) R4933.1(A) TP60900.1 U4555.BP14(VCCA_BCLK_1P05) U4555.BP20(VCCPRIM_1P05_5) U4555.BP22(VCCPRIM_1P05_2) U4555.BR12(VCCA_19P2_1P05) U4555.BR14(VCCAPLL_1P05_2) U4555.BR20(VCCPRIM_1P05_4) U4555.BT12(VCCAPLL_1P05_1) U4555.BT18(VCCPRIM_1P05_11) U4555.BT19(VCCPRIM_1P05_12) U4555.BT22(VCCPRIM_1P05_1) U4555.BU12(VCCA_SRC_1P05) U4555.BU14(VCCAPLL_1P05_4) U4555.BU18(VCCPRIM_1P05_13) U4555.BU19(VCCPRIM_1P05_14) U4555.BV12(VCCPRIM_MPHY_1P05_2) U4555.BV14(VCCPRIM_MPHY_1P05_1) U4555.BW12(VCCPRIM_MPHY_1P05_3) U4555.BW14(VCCPRIM_MPHY_1P05_4) U4555.BW16(VCCPRIM_1P05_6) U4555.BW18(VCCPRIM_1P05_7) U4555.BW19(VCCPRIM_1P05_8) U4555.BY12(VCCPRIM_MPHY_1P05_5) U4555.BY14(VCCPRIM_MPHY_1P05_6) U4555.BY16(VCCPRIM_1P05_9) U4555.BY20(VCCPRIM_1P05_3) U4555.CA14(VCCPRIM_1P05_10) U4555.CC12(VCCDUSB_1P05)
P1V5S: C3302.1(A) C3316.1(A) C3369.1(A) C3375.1(A) PAD61799.2 TP61700.1 U3300.1(VDD15) U3300.14(VDD15_1) U3300.28(VDD15_2) U3300.41(VDD15_3)
P1V8A: C4538.2(B) C4539.2(B) C7561.1(A) C7562.1(A) C7563.1(A) PAD60600.2 PAD60600.4 Q7154.3(D) R334.2(B) R359.1(A) R386.1(A) R417.1(A) R1309.2(B) R1344.2(B) R3027.1(A) R3800.2(B) R3814.2(B) R3815.2(B) R3816.2(B) R3817.2(B) R3818.2(B) R3819.2(B) R3820.2(B) R3823.2(B) R3824.1(A) R3826.1(A) R4460.2(B) R4520.1(A) R4537.1(A) R4538.2(B) R4539.1(A) R4761.2(B) R4762.2(B) R4905.2(B) R4908.2(B) R4961.1(A) R7428.1(A) TP60600.1 U4555.CC15(VCCPRIM_1P8_6) U4555.CC18(VCCPRIM_1P8_1) U4555.CC19(VCCPRIM_1P8_2) U4555.CD15(VCCPRIM_1P8_7) U4555.CD16(VCCPRIM_1P8_8) U4555.CD18(VCCPRIM_1P8_3) U4555.CD19(VCCPRIM_1P8_4) U4555.CP17(VCCPRIM_1P8_9) U4555.CP23(VCCPRIM_1P8_5)
P1V8A_EMMC: C3803.1(A) C3804.1(A) R3824.2(B) U3800.C6 U3800.M4 U3800.N4 U3800.P3 U3800.P5
P1V8S: Q7154.2(S) R514.1(A) R7038.2(B) R7413.1(A)
P1V8S_AUDIO: C502.1(A) C503.1(A) R514.2(B) U500.20(CPVDD/AVDD2)
P1V8S_EN: C7024.1(A) Q7154.1(G) Q7306.6 R7313.1(A)
P1V8S_EN#: Q7306.2 Q7306.3 R7303.1(A)
P2V5: CN4100.257(VPP) CN4100.259(VPP_1) CN4125.257(VPP) CN4125.259(VPP_1) PAD60400.2 TP60400.1
P2V8S_FRONT_DMIC: C9353.1(A) C9354.1(A) C9357.1(A) C9360.1(A) CN9354.6 MIC9350.4 MIC9352.4 R9352.1(A)
P3V3_ANA: C2778.1(A) U2700.E16(VCC3P3_ANA)
P3V3_ANA_PCIE: C2779.1(A) U2700.L16(VCC3P3_ANA_PCIE)
P3V3_ANA_USB2: C2780.1(A) U2700.H18(VCC3P3_ANA_USB2)
P3V3_LC: C2777.1(A) R2743.1(A) R2744.1(A) R2745.1(A) R2746.1(A) U2700.V6(VCC3P3_LC)
P3V3_RTC: C311.1(A) C312.1(A) C4541.1(A) C4542.1(A) C4766.1(A) D4750.3(C) R1008.1(A) R4834.1(A) R4845.1(A) U300.L4(VBAT) U4555.BR23(VCCRTC)
P3V3_SVR: C2750.1(A) C2751.1(A) C2752.1(A) C2753.1(A) C2754.1(A) C2755.1(A) R2710.1(A) R2711.1(A) R2712.1(A) R2757.2(B) R2758.2(B) U2700.E6(VCC3P3A) U2700.G1(VCC3P3_SVR<0>) U2700.G2(VCC3P3_SVR<2>) U2700.H2(VCC3P3_SVR<1>) U2700.L6(VCC3P3_S0)
P3V3_SX: C2746.1(A) C2747.1(A) C2748.1(A) C2749.1(A) CN2700.8 R2724.1(A) R2725.1(A) R2726.1(A) R2728.1(A) R2729.1(A) R2730.1(A) R2751.2(B) R2752.2(B) R2753.2(B) R2754.2(B) R2755.2(B) R2756.2(B) R2760.1(A) R2775.1(A) U2700.F18(VCC3P3_SX<0>) U2700.R6(VCC3P3_SX<1>) U2701.5 U2702.6 U2703.8
P3V3A: C4504.2(B) CN4941.1 Q2701.2 R373.1(A) R1002.1(A) R1003.1(A) R1021.2(B) R1300.1(A) R1307.1(A) R3827.2(B) R4353.2(B) R4512.1(A) R4525.1(A) R4535.1(A) R4536.1(A) R4545.1(A) R4550.1(A) R4556.1(A) R4557.1(A) R4610.2(B) R4620.1(A) R4623.1(A) R4624.1(A) R4678.1(A) R4700.1(A) R4702.1(A) R4703.1(A) R4733.1(A) R4734.1(A) R4742.1(A) R4754.1(A) R4763.1(A) R4766.1(A) R4768.1(A) R4771.1(A) R4772.1(A) R4792.1(A) R4797.1(A) R4809.1(A) R4827.1(A) R4830.1(A) R4831.1(A) R4839.1(A) R4856.1(A) R4861.1(A) R4884.1(A) R4914.1(A) R4915.1(A) R4918.1(A) R4925.1(A) R7007.1(A) R7010.1(A) R7012.2(B) R7025.1(A) R7424.2(B) R7425.1(A) R7427.1(A) R60522.1(A) R61403.1(A) R61404.1(A) R61422.1(A) U4700.5(VCC)
P3V3A_EMMC: C3800.1(A) C3802.1(A) R3827.1(A) U3800.E6 U3800.F5 U3800.J10 U3800.K9
P3V3A_EN: R7024.2(B) U7001.5
P3V3A_LDO: C1001.1(A) C60191.1(A) CN2500.30 D4750.2(A2) R129.2(B) R327.2(B) R1001.2(B) R1012.1(A) R1017.2(B) R7005.1(A) R7019.1(A) R7410.1(A) TP2519.1 U1000.1 U7000.5 U60100.6
P3V3A_LDO_DB: C9229.1(A) CN9202.1 D9205.1 U9204.VDD
P3V3A_PRIME: C4545.2(B) C4546.2(B) C7013.2(B) Q7004.2(S) R7001.2(B) U4555.BP23(VCCPRIM_3P3_1) U4555.BW23(VCCPRIM_3P3_2) U4555.CB16(VCCPRIM_3P3_3) U4555.CB22(VCCPRIM_3P3_4) U4555.CB23(VCCPRIM_3P3_5) U4555.CC22(VCCPRIM_3P3_6) U4555.CC23(VCCPRIM_3P3_7) U4555.CD22(VCCPRIM_3P3_8) U4555.CD23(VCCPRIM_3P3_9) U4555.CP29(VCCPRIM_3P3_10)
P3V3A_PRIME_EN: C7012.1(A) Q7003.6 Q7004.1(G) R7029.2(B) R7040.1(A)
P3V3A_PRIME_EN#: Q7003.2 Q7003.3 Q7006.G R7039.1(A)
P3V3A_Q_WLAN: C1300.1(A) C1301.1(A) C1302.1(A) C1303.1(A) C1304.1(A) C1305.1(A) C1306.1(A) C1307.1(A) CN1300.2 CN1300.4 CN1300.72 CN1300.74 Q1301.G R1302.1(A) R1304.1(A) R1305.1(A) R1306.1(A) R1315.2(B) R1346.1(A)
P3V3A_SS2: C7041.1(A) U7001.10
P3V3AL_KBC: C322.1(A) R347.2(B) R379.1(A) R405.2(B)
P3V3AL_RTC_BAT: CN4750.1 R4832.2(B) TP4750.1
P3V3AL_RTC_BAT_D4750: D4750.1(A1) R4832.1(A)
P3V3DS: C300.1(A) C1309.1(A) C1410.1(A) C4531.2(B) C4920.1(A) C4921.1(A) C7000.1(A) C7002.2(B) C7621.1(A) C7622.1(A) CN375.22 CN4941.3 CN4941.7 D1451.1(A1) PAD60100.2 PAD61710.1 Q1000.G Q1307.4(S) Q7004.3(D) Q60032.G Q68000.1(B) Q68120.2(E) Q68121.2(E) R101.1(A) R103.1(A) R303.2(B) R306.2(B) R307.2(B) R309.2(B) R310.2(B) R311.2(B) R315.2(B) R317.2(B) R320.2(B) R322.2(B) R324.2(B) R325.2(B) R326.2(B) R341.2(B) R343.1(A) R352.2(B) R354.2(B) R356.2(B) R362.1(A) R372.2(B) R375.2(B) R376.2(B) R378.2(B) R384.1(A) R385.2(B) R389.2(B) R391.2(B) R393.1(A) R394.2(B) R397.2(B) R403.1(A) R405.1(A) R406.2(B) R423.2(B) R445.1(A) R449.1(A) R1014.2(B) R1342.1(A) R1400.1(A) R1403.2(B) R1404.1(A) R1408.1(A) R1410.1(A) R2418.2(B) R2424.2(B) R2428.2(B) R2456.1(A) R2633.2(B) R2634.2(B) R2756.1(A) R2758.1(A) R3015.1(A) R3825.1(A) R4411.2(B) R4554.1(A) R4579.1(A) R4717.1(A) R4743.1(A) R4744.1(A) R4835.1(A) R4934.1(A) R4947.1(A) R7017.1(A) R7500.1(A) R60021.1(A) R60053.2(B) RS300.5 RS300.10 TP60100.1 U302.5(VCC) U1401.5 U3001.5 U4412.4(VDD) U4555.BR24(VCCDSW_3P3_1) U4555.BT23(VCCDSW_3P3_2) U4920.3 U4920.5 U4921.3 U4921.5 U7001.1 U7001.2 U7001.4 U7001.6 U7001.7
P3V3DS_AUDIO_LED: CN300.6 R362.2(B)
P3V3DS_CCG5: C2410.1(A) C2411.1(A) R2456.2(B) U2403.A5
P3V3DS_FN_CAP_PP_LED: CN300.13 R393.2(B)
P3V3DS_PWR_LED: CN300.4 R343.2(B)
P3V3DS_U5002_PIN3: R4411.1(A) U4412.3(ALERT#)
P3V3DS_WLAN: C7520.1(A) C7521.1(A) C7522.1(A) Q1307.1(D) Q1307.2(D1) Q1307.5(D3) Q1307.6(D2) R1315.1(A) R7500.2(B)
P3V3DS_WWAN: C1400.1(A) C1406.1(A) C1407.1(A) C1408.1(A) C1411.1(A) C1413.1(A) C1414.1(A) C1415.1(A) CN1400.2(3P3VAUX_2) CN1400.4(3P3VAUX_4) CN1400.70(3P3VAUX_70) CN1400.72(3P3VAUX_72) CN1400.74(3P3VAUX_74) R1403.1(A)
P3V3S: C3000.1(A) C3006.1(A) C3315.1(A) C4104.1(A) C4105.1(A) C4129.1(A) C4130.1(A) C4351.1(A) C4411.1(A) C7508.1(A) C7611.1(A) C7612.1(A) C7613.1(A) C7614.1(A) C7615.1(A) CN4100.255(VDDSPD) CN4125.255(VDDSPD) F300.1(A) F2200.1(A) F2500.1(A) F3001.1(A) Q3000.3 Q4411.2 Q4411.5 Q4750.2 Q4750.5 Q4752.2 Q4752.5 R318.2(B) R396.2(B) R400.2(B) R426.2(B) R513.1(A) R1301.2(B) R1953.2(B) R1954.1(A) R2755.1(A) R2757.1(A) R3010.1(A) R3013.1(A) R3018.2(B) R3030.1(A) R3034.1(A) R3301.2(B) R3303.2(B) R3306.1(A) R3307.1(A) R3309.2(B) R3311.2(B) R3319.2(B) R3322.2(B) R3340.2(B) R3341.2(B) R3355.2(B) R3543.2(B) R4103.1(A) R4126.1(A) R4301.2(B) R4303.2(B) R4352.1(A) R4354.2(B) R4355.2(B) R4412.1(A) R4413.1(A) R4414.1(A) R4416.1(A) R4542.1(A) R4549.1(A) R4560.1(A) R4561.1(A) R4563.1(A) R4565.1(A) R4571.1(A) R4573.1(A) R4575.1(A) R4577.1(A) R4584.1(A) R4590.1(A) R4591.1(A) R4628.1(A) R4629.1(A) R4650.1(A) R4705.1(A) R4707.1(A) R4708.1(A) R4711.1(A) R4714.1(A) R4715.1(A) R4718.1(A) R4721.1(A) R4725.1(A) R4729.1(A) R4748.1(A) R4749.1(A) R4765.1(A) R4769.1(A) R4782.1(A) R4786.1(A) R4787.1(A) R4798.1(A) R4802.1(A) R4816.1(A) R4825.1(A) R4828.1(A) R4854.1(A) R4865.2(B) R4866.2(B) R4870.1(A) R4913.1(A) R4922.1(A) R4950.1(A) R7004.1(A) R7011.2(B) R7404.1(A) R7411.1(A) R7422.1(A) R66002.1(A) U1300.5 U3000.5 U3002.5 U3003.5 U3300.56(VDD33) U4411.1
P3V3S_2ALS_H: C9302.1(A) CN9302.1 R9304.1(A) U9302.6
P3V3S_ALS: C9301.1(A) CN9301.1 R9302.1(A) U9301.6
P3V3S_ALS_HUB_DB: C9300.1(A) CN9300.1 R9300.1(A) U9300.6
P3V3S_AUDIO: C504.1(A) C505.1(A) C520.1(A) C521.1(A) R500.1(A) R501.2(B) R513.2(B) R516.1(A) U500.3(DVDD) U500.18(DVDD_IO)
P3V3S_CAMERA_ALS: C2250.1(A) C2251.1(A) C2255.1(A) C2256.1(A) CN3001.4 CN3001.16 F3001.2(B)
P3V3S_CLKPAD: C323.1(A) CN303.8 F300.2(B)
P3V3S_EN: R7016.2(B) U7001.3
P3V3S_KBL_EN#: Q301.D R351.1(A) R382.1(A)
P3V3S_KBL_EN#_RC: C326.1(A) Q300.1 R382.2(B)
P3V3S_LCDVDD: C3003.1(A) R3000.1(A) R3029.2(B) U3000.1(OUT)
P3V3S_R_LCDVDD: CN3000.17 CN3000.23 CN3000.24 R3000.2(B)
P3V3S_SS1: C7040.2(B) U7001.12
P3V3S_SSD: C1956.1(A) CN1951.2(3.3VAUX1) CN1951.4(3.3VAUX2) CN1951.12(3.3VAUX3) CN1951.14(3.3VAUX4) CN1951.16(3.3VAUX5) CN1951.18(3.3VAUX6) CN1951.70(3.3VAUX7) CN1951.72(3.3VAUX8) CN1951.74(3.3VAUX9) R1953.1(A)
P3V3S_TOUCH_F: F3002.1(A) Q3000.2
P3V3S_TOUCH_VCC: C3001.1(A) CN3000.12 CN3000.13 F3002.2(B) Q3004.G Q3005.2 Q3005.5 R3031.2(B) R4927.1(A) R4928.1(A) R4930.2(B)
P3V3S_USB: CN2500.1 F2500.2(B) TP2502.1
P3V3S_USB_DB: C9203.1(A) C9204.1(A) C9205.1(A) C9216.1(A) C9217.1(A) C9218.1(A) CN9202.30 R9204.1(A) R9205.1(A) R9208.1(A) R9210.1(A) R9211.1(A) R9212.1(A) R9213.1(A) R9214.1(A) R9215.1(A) R9221.1(A) R9222.1(A) R9223.1(A) R9225.1(A) R9226.1(A) R9227.1(A) R9228.1(A) R9229.1(A) U9201.1 U9201.13 U9203.1 U9203.13
P5V0A_USB: C2501.1(A) C2502.1(A) C2504.1(A) C2505.1(A) C2508.1(A) C2606.1(A) C2607.1(A) C2611.1(A) C2617.1(A) C7618.1(A) C7619.1(A) C7620.1(A) PAD60200.2 PAD60200.4 R2502.2(B) R2618.2(B) R2625.1(A) R2628.2(B) R2638.1(A) R2639.1(A) R2647.1(A) R2669.1(A) R2671.1(A) TP60200.1 U2500.5 U2501.1 U2501.5
P5V0A_USB1: C2500.1(A) CN2501.6 TP2501.1 U2500.1
P5V0A_USB_CHARGE: C2503.1(A) C2506.1(A) C2507.1(A) CN2501.4 CN2501.5 TP2500.1 U2501.12
P5V0A_USB_CHARGE_DB: C9200.1(A) C9206.1(A) C9208.1(A) CN9200.1 CN9203.2 CN9203.3
P5V0A_USB_DB: C9207.1(A) C9213.1(A) CN9201.1 CN9203.1
P5V0DS: C3151.1(A) C7006.1(A) C7400.1(A) CN375.30 PAD60250.2 PAD60410.1 Q7001.4(S) R413.2(B) R435.2(B) R2469.2(B) R4417.1(A) R7015.2(B) R7303.2(B) R7313.2(B) TP60250.1 U3150.5 U7400.8(V+)
P5V0DS_CCG5: R2469.1(A) U2403.B3 U2403.J1 U2403.J2 U2403.K8 U2403.L2 U2403.L9
P5V0DS_RC: C4413.1(A) R4417.2(B) U4413.5(VCC)
P5V0S: C326.2(B) C7003.1(A) C7616.1(A) C7617.1(A) CN4300.1 F3000.1(A) F4350.1(A) Q300.3 Q7001.1(D) Q7001.2(D1) Q7001.5(D3) Q7001.6(D2) R200.1(A) R351.2(B) R512.1(A) R4899.2(B) R7014.2(B) R7405.1(A) TP4300.1
P5V0S_AUDIO_AVDD: C522.1(A) C523.1(A) D500.2 R512.2(B) R520.1(A) R521.1(A)
P5V0S_EN#: C7006.2(B) Q7001.3(G) R7009.2(B)
P5V0S_EN#_R: Q7005.2 Q7005.3 R7009.1(A) R7015.1(A)
P5V0S_HDMI: C3150.1(A) C3152.1(A) CN3150.18 R3150.2(B) R3151.2(B) U3150.1
P5V0S_IR_LED: C2257.1(A) C2258.1(A) CN3001.12 CN3001.13 CN3001.14 F3000.2(B)
P5V0S_KBL: CN301.6 CN301.7 CN301.8 Q300.2
P5V0S_NFC: C4350.1(A) CN4350.12 F4350.2(B)
P5V0S_RC: C7010.1(A) Q7005.5 R7023.2(B)
P5V0S_SM: CN200.9 CN200.10 R200.2(B) TP850.1
PVBAT: C7511.1(A) C7512.1(A) C7513.1(A) C7514.1(A) C7515.1(A) C7516.1(A) C7517.1(A) C7518.1(A) C7519.1(A) C7533.1(A) C7534.1(A) C7535.1(A) C7564.1(A) C7565.1(A) C7566.1(A) C7608.1(A) C7609.1(A) C7610.1(A) C60000.1(A) C60263.1(A) D60099.2(A2) F3003.1(A) PAD60000.2 PAD60110.1 PAD60210.1 PAD60260.1 PAD60310.1 PAD60510.1 PAD60610.1 PAD60910.1 PAD61410.1 PAD66010.1 PAD66020.1 PAD66030.1 PAD66310.1 PAD66610.1 Q60034.3(D) R1015.2(B) R7039.2(B) R7040.2(B) R7301.2(B) R7304.2(B) R7306.2(B) R7311.2(B) R60001.1 R66199.1(A) TP60000.1
PVBAT_CPU1: C66010.1(A) C66011.1(A) C66012.1(A) C66014.1(A) C66199.1(A) PAD66010.2 U66010.1(VIN1) U66010.14(VIN2)
PVBAT_CPU2: C66020.1(A) C66021.1(A) C66022.1(A) C66024.1(A) C66299.1(A) PAD66020.2 U66020.1(VIN1) U66020.14(VIN2)
PVBAT_CPU3: C66030.1(A) C66031.1(A) C66032.1(A) C66034.1(A) C66399.1(A) PAD66030.2 U66030.1(VIN1) U66030.14(VIN2)
PVBAT_GT: C66310.1(A) C66311.1(A) C66312.1(A) C66314.1(A) C66599.1(A) PAD66310.2 U66310.1(VIN1) U66310.14(VIN2)
PVBAT_LCM: CN3000.1 CN3000.2 CN3000.3 F3003.2(B)
PVBAT_SA: C66610.1(A) C66614.1(A) PAD66610.2 U66610.1(VIN) U66610.6(VIN_1)
PVCC_PRIM: C4523.2(B) C4535.2(B) C4536.2(B) PAD61499.2 TP61400.1 U4555.BU15(VCCPRIM_CORE_1) U4555.BU22(VCCPRIM_CORE_2) U4555.BV15(VCCPRIM_CORE_3) U4555.BV16(VCCPRIM_CORE_4) U4555.BV18(VCCPRIM_CORE_5) U4555.BV19(VCCPRIM_CORE_6) U4555.BV20(VCCPRIM_CORE_7) U4555.BV22(VCCPRIM_CORE_8) U4555.BW20(VCCPRIM_CORE_9) U4555.BW22(VCCPRIM_CORE_10) U4555.CA12(VCCPRIM_CORE_11) U4555.CA16(VCCPRIM_CORE_12) U4555.CA18(VCCPRIM_CORE_13) U4555.CA19(VCCPRIM_CORE_14) U4555.CA20(VCCPRIM_CORE_15) U4555.CB12(VCCPRIM_CORE_16) U4555.CB14(VCCPRIM_CORE_17) U4555.CB15(VCCPRIM_CORE_18)
PVCCGT: C4553.1(A) C4566.1(A) C4567.1(A) C4568.1(A) C4597.1(A) C4598.1(A) C4599.1(A) C4600.1(A) C4601.1(A) C4602.1(A) C4603.1(A) C4604.1(A) C4605.1(A) C4606.1(A) C4607.1(A) C4608.1(A) C4609.1(A) C4610.1(A) C4611.1(A) C4620.1(A) C4621.1(A) C4622.1(A) C4623.1(A) C4645.1(A) C4646.1(A) C4647.1(A) C4648.1(A) C4649.1(A) C66300.1(A) C66301.1(A) C66302.1(A) C66303.1(A) C66304.1(A) C66305.1(A) L66310.2 L66310.4 R4528.2(B) TP66300.1 U4555.A5(VCCGT_1) U4555.A6(VCCGT_2) U4555.A8(VCCGT_3) U4555.A11(VCCGT_4) U4555.A12(VCCGT_5) U4555.A14(VCCGT_6) U4555.A15(VCCGT_7) U4555.A17(VCCGT_8) U4555.A18(VCCGT_9) U4555.A20(VCCGT_10) U4555.B3(VCCGT_11) U4555.B4(VCCGT_12) U4555.B6(VCCGT_13) U4555.B8(VCCGT_14) U4555.B11(VCCGT_15) U4555.B14(VCCGT_16) U4555.B17(VCCGT_17) U4555.B20(VCCGT_18) U4555.C2(VCCGT_19) U4555.C3(VCCGT_20) U4555.C6(VCCGT_21) U4555.C7(VCCGT_22) U4555.C8(VCCGT_23) U4555.C11(VCCGT_24) U4555.C12(VCCGT_25) U4555.C14(VCCGT_26) U4555.C15(VCCGT_27) U4555.C17(VCCGT_28) U4555.C18(VCCGT_29) U4555.C20(VCCGT_30) U4555.D4(VCCGT_31) U4555.D7(VCCGT_32) U4555.D11(VCCGT_33) U4555.D12(VCCGT_34) U4555.D14(VCCGT_35) U4555.D15(VCCGT_36) U4555.D17(VCCGT_37) U4555.D18(VCCGT_38) U4555.D20(VCCGT_39) U4555.E4(VCCGT_40) U4555.F5(VCCGT_41) U4555.F6(VCCGT_42) U4555.F7(VCCGT_43) U4555.F8(VCCGT_44) U4555.F11(VCCGT_45) U4555.F14(VCCGT_46) U4555.F17(VCCGT_47) U4555.F20(VCCGT_48) U4555.G11(VCCGT_49) U4555.G12(VCCGT_50) U4555.G14(VCCGT_51) U4555.G15(VCCGT_52) U4555.G17(VCCGT_53) U4555.G18(VCCGT_54) U4555.G20(VCCGT_55) U4555.H5(VCCGT_56) U4555.H6(VCCGT_57) U4555.H7(VCCGT_58) U4555.H8(VCCGT_59) U4555.H11(VCCGT_93) U4555.H12(VCCGT_60) U4555.H14(VCCGT_61) U4555.H15(VCCGT_62) U4555.H17(VCCGT_63) U4555.H18(VCCGT_64) U4555.H20(VCCGT_65) U4555.J7(VCCGT_66) U4555.J8(VCCGT_67) U4555.J11(VCCGT_68) U4555.J14(VCCGT_69) U4555.J17(VCCGT_70) U4555.J20(VCCGT_71) U4555.K2(VCCGT_72) U4555.K11(VCCGT_73) U4555.L7(VCCGT_74) U4555.L8(VCCGT_75) U4555.L10(VCCGT_76) U4555.M9(VCCGT_77) U4555.N7(VCCGT_78) U4555.N8(VCCGT_79) U4555.N9(VCCGT_80) U4555.N10(VCCGT_81) U4555.P2(VCCGT_82) U4555.P8(VCCGT_83) U4555.R9(VCCGT_84) U4555.T8(VCCGT_85) U4555.T9(VCCGT_86) U4555.T10(VCCGT_87) U4555.U8(VCCGT_88) U4555.U10(VCCGT_89) U4555.V9(VCCGT_90) U4555.W8(VCCGT_91) U4555.W9(VCCGT_92)
