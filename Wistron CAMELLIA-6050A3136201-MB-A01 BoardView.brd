# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGND_2ALS_H: length 6.7
  TOP w0.254: v1(76.1,78.45) R9305.1 C9302.2 75.59,79.77 U9302.1 ; CN9302.6 80.36,78.51 81,79.15 v1(81,79.35) 80.36,79.35 79.86,78.84 CN9302.5 ; CN9302.G2 v1(80.68,80.85) ; CN9302.G1 v1(77.6,80.85)
DGND_ALS: length 9.4
  TOP w0.254: 76.89,106.75 R9301.1 76.7,107.08 v1(76.43,106.8) ; 76.73,108.75 C9300.2 76.89,109.29 77.28,109.68 77.28,110.48 v1(77.27,110.49) ; v1(78.02,107.89) 78.28,108.14 U9300.1
  TOP w0.356: CN9300.5 77.49,99.52 77.77,99.24 v1(77.77,98.7) ; 76.95,98.58 CN9300.6
  TOP w0.381: 78.88,102.52 CN9300.G1 79.45,102.04 ; CN9300.G2 79.53,98.1 v1(79.53,98.73)
  TOP w0.508: 78.88,98.02 CN9300.G2 ; CN9300.G2 79.45,98.5 ; CN9300.G2 79.45,97.54
  vias: v1(77.78,98.11) v1(79.56,101.75)
DGND_DMIC_FRONT: length 25.1
  TOP w0.152: MIC9350.6 61.85,117.29 62.05,117.49 62.05,117.85 61.8,118.1 61.44,118.1 61.23,117.89 MIC9350.5
  TOP w0.178: 62,46.93 62.02,46.91 62.02,45.87 61.85,45.7 MIC9352.8
  TOP w0.254: R9350.1 v1(60.62,110.43) ; MIC9352.7 60.11,46.33 60.11,46.33 59.71,46.74 v1(59.71,47.15) ; v1(60.64,55.56) 60.98,55.56 CN9354.G1 ; v1(59.4,114.67) 59.4,116.15 MIC9350.8 ; CN9354.3 59.56,53.05 v1(60.07,53.56) ; C9357.2 62.12,66.11 C9353.2 62.25,67 v1(62.25,67.88) C9354.2 v3(61.74,68.59) ; MIC9350.7 v1(60.64,113.95) ; v1(60.93,48.7) 60.93,48.62 61.49,48.06 CN9354.G2 ; 59.15,46.85 59.15,45.93 59.43,45.65 59.43,45.65 MIC9352.6 59.43,43.62 59.33,43.53 59.33,43.52 59.13,43.32 59.13,42.92 59.41,42.64 59.81,42.64 60.01,42.84 60.02,42.84 60.08,42.91 MIC9352.5 ; C9360.2 v1(61.36,64.58) ; MIC9350.6 61.9,116.13 v1(61.9,114.67)
  vias: v1(59.2,84.39) v1(59.74,106.47) v1(59.76,62.19) v1(60.64,112.93) v1(61.49,81.98)
DGND_USB: length 46.7
  TOP w0.254: v1(37.72,108.14) 37.54,108.32 C9200.2 ; D9202.8 D9202.3 v1(34.54,84.65) ; D9206.2 v1(47.02,66.74) ; v1(35.91,103.13) D9201.3 D9201.8 ; v1(33.04,88.71) 33.02,88.73 33.02,90.1 ; v1(39.74,85.41) D9203.8 D9203.3 ; v1(36.94,77.4) 37.06,77.52 R9224.2 ; U9204.GND 41.2,122.11 41.53,122.11 v1(42,121.64) ; U9203.10 v1(41.68,83.33) ; C9204.2 32.36,99.92 CN9200.4 ; C9213.2 35.71,89.13 v1(35.45,89.39) 34.64,89.39 C9207.2 ; U9201.21 v1(38.76,96.5) ; R9207.2 35.16,97.72 35.63,97.25 v1(36.42,97.25) ; C9203.2 C9205.2 34.57,101.58 34.57,101.58 v1(34.44,101.45) ; v1(38.74,102) 38.76,101.98 U9201.10 ; v1(39.97,83.3) 39.78,83.3 C9218.2 C9217.2 C9216.2 ; v1(43.58,103.3) R9203.2 R9202.2 ; R9220.2 v1(46.8,82.76) ; R9219.2 v1(45.98,82.74) ; D9200.3 D9200.8 39.27,103.9 v1(39.06,103.7) ; 32.75,97.47 v1(32.75,98.74) ; D9205.2 v1(47.02,68.16) ; U9203.21 v1(41.68,77.83) ; 33.02,76.06 v1(33.52,75.55)
  TOP w0.381: 35.26,88.75 C9213.2
  BOTTOM w0.254: CN9202.19 v1(41.75,72.79) ; v1(46.8,82.76) 46.8,82.76 CN9203.G1 ; v1(33.04,88.71) 33.02,88.73 33.02,90.1 ; v1(43.58,103.3) 43.58,103.05 C9229.2 ; 33.02,76.06 v1(33.52,75.55) ; CN9202.9 36.75,71.34 37,71.08 v1(37.21,71.08) ; CN9202.25 v1(44.75,72.79) ; CN9202.G2 31.75,69.1 v1(32.38,68.47) ; CN9202.10 v1(37.25,72.79) ; CN9202.13 v1(38.75,72.79) ; v1(39.97,82.71) 39.2,81.94 CN9203.G2 ; CN9202.G1 v2(48.25,70.25) ; CN9202.22 v1(43.25,72.79) ; 32.75,97.47 v1(32.75,98.74) ; CN9202.16 v1(40.25,72.79) ; CN9202.28 v1(46.25,72.79)
  vias: v1(32.61,111.89) v1(32.81,68.9) v1(33.07,67.63) v1(33.25,68.47) v1(34.14,69.94) v1(34.36,104.87) v1(34.36,103.39) v1(36.17,69.99) v1(37,102.52) v1(38,100.27) v1(38,98.24) v1(38.4,83.54) v1(38.89,85.45) v1(39.75,67.58) v1(39.97,83.88) v1(40.03,100.27) v1(40.03,98.24) v1(40.92,81.6) v1(40.92,79.57) v1(41.04,117.93) v1(41.47,67.55) v1(41.51,102.4) v1(41.9,88.86) v1(42.9,89.45) v1(42.95,81.6) v1(42.95,79.57) v1(43.17,107.24) v1(43.49,83.86) v1(45.4,83.86) v1(46.75,71.16) v5(34.9,111.77) v5(34.9,111.01) v5(34.97,110.25) v5(35.66,111.77) v5(39.37,87.19) v5(39.65,110.99) v5(40.13,87.19) v5(40.41,110.99) v5(41.17,111.75) v5(41.17,110.99) v5(41.35,87.19)
GND_ALS: length 4.4
  TOP w0.254: R9303.1 v1(76.59,105.4) ; C9301.2 v1(76.59,106.07)
  TOP w0.356: CN9301.6 v1(76.95,92.79)
  TOP w0.381: v1(78.03,103.2) 78.15,103.2 78.6,103.65 U9301.1 ; CN9301.G2 v1(79.45,93.04) ; CN9301.G1 v1(79.45,96.16)
P0V6S: length 72.5
  TOP w0.254: 241.58,13.84 C4128.1 ; 242.21,13.84 C4127.1 ; 240.31,13.84 C4126.1 ; 162.37,8.38 C4101.1 162.21,8.47 162.46,8.22 ; 240.94,13.84 C4125.1
  TOP w0.762: 220.35,9.3 220.95,9.9 237.31,9.9 237.77,10.35
  TOP w1.016: 220.35,9.3 215.8,4.74 199.64,4.74 195.76,8.63 192.43,8.63 ; 192.07,8.98 177.29,8.98
  BOTTOM w0.33: v5(240.31,12.08) 238.88,10.99 237.37,10.99 237.11,11.25 237.11,11.28 237.08,11.31 CN4125.258
  BOTTOM w0.356: v1(161.38,11.01) CN4100.258
P0V6S_DIMM0_VREF_CA: length 106.2
  TOP w0.254: C4111.1 139.8,13.19 C4110.1
  TOP w0.508: R4106.1 137.48,12.87 136.83,12.22 136.71,12.22 136.5,12 96.58,12 92.64,15.94 92.64,20.34 97.25,24.95 99.62,24.95 101.42,26.75 118.17,26.75 v3(131.8,40.38) 132.73,41.31 R4503.1 ; R4106.1 137.52,13.19 R4122.2 139.21,13.19 C4111.1 ; R4106.1 137.48,13.67 v1(137.88,14.06)
  BOTTOM w0.33: CN4100.164 v1(137.88,14.06)
P0V6S_DIMM1_VREF_CA: length 191
  TOP w0.254: C4144.1 215.11,11.88 C4145.1
  TOP w0.508: C4145.1 215.03,11.96 R4131.2 214.14,11.96 R4132.1 213.26,11.29 v1(213.57,10.99) 212.96,10.38 188.96,10.38 188.88,10.45 176.73,10.45 171.6,5.32 167.33,5.32 164.56,8.09 164.56,11.26 164.21,11.62 163.08,11.62 162.57,12.13 158.15,12.13 157.66,11.64 154.9,11.64 152.32,9.06 144.67,9.06 143.33,10.4 141.16,10.4 140.15,11.41 137.45,11.41 137.24,11.21 137.13,11.21 136.92,10.99 96.16,10.99 91.89,15.26 91.89,15.29 91.63,15.55 91.63,20.76 96.83,25.96 99.2,25.96 101,27.76 117.02,27.76 128.95,39.68 v3(128.95,40.93) R4112.1
  BOTTOM w0.254: v1(213.57,10.99) 213.58,10.98 CN4125.164
P0V9_LC: length 16.5
  TOP w0.254: v1(270.98,73.78) 271.32,73.78 C2781.1 ; v1(259.89,65.6) U2700.J8
  L5 w0.254: v1(259.89,65.6) 259.99,65.6 260.37,65.22 261.52,65.22 261.68,65.38 262.2,65.38 263.12,66.3 263.12,66.82 263.43,67.13 264.18,67.13 264.47,67.41 264.47,68.08 269.72,73.34 270.38,73.34 270.81,73.78 v1(270.98,73.78)
P0V9_PCIE: length 6.3
  TOP w0.203: U2700.J18 v1(259.24,61.05) U2700.L19 v1(258.59,61.05) ; U2700.M19 258.26,60.72 v1(258.59,61.05) ; U2700.M18 v1(258.59,61.05) ; v1(258.59,61.05) U2700.L18 U2700.M16
  BOTTOM w0.254: C2769.1 259.49,59.37 ; C2770.1 258.21,57.72 ; C2771.1 258.39,60.03 ; C2768.1 259.48,57.72
  vias: v3(258.8,57.77)
P1V2: length 153.9
  TOP w0.254: 175.21,21.28 C7541.1 ; 150.19,55.19 C4501.1 ; 120.03,19.93 C4116.1 ; C4107.1 157.41,19.74 v1(157.13,19.46) ; v1(198.58,13.79) 198.58,13.55 197.1,12.07 R4553.1 ; C4109.1 133.34,13.75 v1(133,14.09) ; 183.09,23.43 C7543.1 ; v1(137.25,22.54) 137.31,22.48 C4118.1 ; v1(212.59,14.03) 213.26,13.36 R4132.2 ; C4131.1 128.93,13.77 v1(128.88,13.72) 129.35,13.24 R4201.1 ; 214.71,22.67 C4135.1 ; v1(204.83,13.89) 204.92,13.8 R4200.1 ; 219.03,21.41 C7540.1 ; 187.28,21.41 C7551.1 ; C4151.1 134.9,14.75 v1(134.42,14.75) ; 145.62,18.86 C7542.1 146.48,18.86 v1(146.63,19) ; v1(133.42,22.25) 133.04,21.87 C4137.1 ; 217,21.28 C7537.1 ; 224.74,21.15 C7553.1 ; 141.05,19.49 C7554.1 ; 142.26,55.24 C7539.1 ; v1(125.05,22.96) 125.05,22.97 C4123.1 ; 97.3,21.27 97.05,21.53 C4121.1 ; C4132.1 211.7,13.11 v1(211.08,13.73) ; v1(118.39,14.46) 118.43,14.42 C4108.1 119.03,14.09 ; v1(130.29,13.8) 130.1,13.61 130.1,13.34 ; 149.05,55.19 C4505.1 ; 193.5,21.28 C7550.1 ; v1(136.88,14.62) 136.63,14.38 R4106.2 ; 149.05,12.13 C7547.1 ; 146.51,55.19 C4500.1 ; C4136.1 203.93,15.05 ; v1(129.32,22.23) 129.69,21.85 C4117.1 ; 98.19,21.4 98.31,21.52 98.31,23.35 97.97,23.68 C7545.1 ; 111.84,21.66 C7552.1 ; v1(151.77,13.72) 151.75,13.71 152.17,13.29 152.17,13.29 C4113.1 ; 232.17,17.52 C7546.1 ; 163.85,28.82 C7536.1 ; 232.95,21.2 C4142.1 ; 144.99,55.22 C4506.1 ; 154,55.19 C7548.1 ; 162.59,27.55 C7538.1 ; 223.04,21.2 C4139.1 ; 191.16,13.58 C7544.1 ; 115.52,13.28 C4114.1 ; 113.24,13.28 C4112.1 ; 142.95,21.28 C7549.1
  TOP w0.381: 133.04,21.21 C4137.1 ; 205.44,21.45 C4152.1 ; 173.46,12.57 C4149.1 ; 135.1,14.1 C4151.1 ; 128.1,21.57 C4115.1 ; 206.46,13.61 C4150.1 ; 204.92,12.44 R4200.1 ; C4147.1 227.94,13.47 ; 184,12.44 C4148.1 ; 202.65,12.94 C4134.1 ; 128.48,14.5 C4131.1 ; R4201.1 129.55,13.34 ; C4146.1 130.1,13.34 ; 213.03,13.21 R4132.2 ; 136.23,13.59 R4106.2 ; 189.46,19.36 C4138.1 ; 123.78,22.97 C4123.1
  BOTTOM w0.102: v1(154.36,53.95) U4555.AM36 ; U4555.AD36 v1(149.33,53.95) ; U4555.AY36 159.4,53.95 v1(159.41,53.94) ; v1(146.81,53.95) U4555.Y36 ; v1(151.84,53.95) U4555.AH36
  BOTTOM w0.203: v1(205.87,22.24) 204.54,22.24 204.33,22.02 CN4125.135 ; CN4100.117 124.13,22.1 124.99,22.96 v1(125.05,22.96) ; CN4100.159 136.63,21.96 137.16,22.49 137.2,22.49 v1(137.25,22.54) 137.3,22.49 137.33,22.49 137.63,22.19 137.63,20.83 CN4100.163 ; v1(202.71,22.81) 202.04,22.81 201.34,22.11 201.34,20.83 CN4125.123 ; CN4100.111 122.63,21.95 v1(122.3,22.28) ; CN4125.33 178.83,18.84 v1(178.75,18.76) ; v1(157.13,19.46) CN4100.241 ; CN4125.129 202.83,22.11 v1(202.74,22.19)
  BOTTOM w0.254: U4555.BE32 v1(162.24,57.95) ; CN4100.178 v1(141.38,14.12) ; CN4125.141 205.83,22.19 v1(205.87,22.24) ; CN4100.142 130.38,13.72 v1(130.29,13.8) ; U4555.R32 v1(143.1,57.95) ; v1(189.1,18.77) 189.33,19 CN4125.75 ; CN4125.12 v1(173.58,14.04) ; v1(212.11,22.29) 212.11,22.24 212.34,22.02 212.34,20.84 CN4125.159 ; v1(209.59,13.73) 209.59,12.39 CN4125.148 ; CN4100.154 135.38,13.79 v1(134.42,14.75) ; CN4125.118 v1(200.08,13.76) ; v1(146.63,19) CN4100.199 ; v1(212.09,22.88) 211.34,22.88 210.83,22.37 CN4125.153 ; CN4100.123 125.67,20.87 125.67,22.63 125.33,22.96 v1(125.05,22.96) ; v1(212.59,14.03) 212.59,12.37 CN4125.160 ; v1(133.42,22.25) 133.61,22.06 133.61,20.84 CN4100.147 ; v1(214.36,22.76) 213.69,22.76 213.34,22.41 213.34,20.83 CN4125.163 ; v1(194.4,14.07) 194.4,13.95 194.59,13.77 194.59,12.37 CN4125.96 ; CN4125.136 204.58,13.63 v1(204.83,13.89) ; v1(223.58,22.8) 222.73,22.8 222.43,22.5 222.43,22.02 222.34,21.94 222.34,20.84 CN4125.199 ; CN4100.148 133.88,13.44 133.22,14.09 v1(133,14.09) ; CN4100.96 118.88,12.37 118.88,13.98 v1(118.39,14.46) ; v1(129.32,22.23) 129.87,22.23 130.13,21.97 CN4100.141 ; CN4125.130 203.08,13.69 v1(203.03,13.74) ; CN4100.33 103.13,19.4 v1(103.22,19.31) ; U4555.AH32 v1(151.3,57.95) ; v1(164.45,53.94) 164.45,53.97 164.56,54.09 164.56,54.82 U4555.BH36 ; CN4100.129 127.13,21.98 127.33,22.19 v1(127.88,22.19) 128.37,22.19 128.63,21.94 CN4100.135 ; CN4125.241 232.84,20.83 232.84,21.04 232.84,21.04 232.84,22.33 233.28,22.77 v1(233.41,22.77) ; CN4100.160 v1(136.88,14.62) ; CN4125.142 206.08,12.43 v1(206.08,13.73) ; CN4100.220 151.88,13.61 v1(151.77,13.72) ; v1(134.69,23.18) 135.13,22.75 CN4100.153 ; CN4100.54 v1(108.38,14.02) ; v1(217.09,13.77) 217.09,12.37 CN4125.178 ; CN4100.124 v1(125.88,13.74) ; v1(198.28,22.74) 198.28,22.73 198.33,22.68 CN4125.111 ; CN4100.118 v1(124.38,13.72) ; v1(208.99,22.31) 208.99,22.24 209.33,21.91 CN4125.147 ; CN4125.154 v1(211.08,13.73) ; CN4125.124 201.59,12.37 v1(201.59,13.75) ; U4555.AN32 v1(155,57.89) ; v1(227.59,13.72) 227.59,12.37 CN4125.220 ; CN4100.136 v1(128.88,13.72) ; U4555.AW32 v1(158.63,57.92) ; v1(184.07,13.86) 184.07,13.85 184.08,13.85 CN4125.54 ; CN4125.112 v1(198.58,13.79) ; v1(113.63,22.22) CN4100.75 ; CN4100.130 v1(127.38,13.72) ; CN4100.112 v1(122.88,13.72)
  BOTTOM w0.305: CN4100.12 v1(97.88,13.8)
  BOTTOM w0.33: CN4125.117 v1(199.83,22.36)
  vias: v5(169.62,8.14) v5(169.62,7.38) v5(170.38,8.14) v5(170.38,7.38) v5(171.14,8.14) v5(171.14,7.38) v5(171.9,8.14) v5(171.9,7.38) v5(172.67,8.14)
P1V05A: length 144.6
  TOP w0.254: CN4920.44 118.59,70.15 118.89,70.44 v1(118.89,71.06) ; 171.09,77.87 C4547.1 ; v1(131.21,69.4) 131.21,68.8 126.56,64.15 126.56,61.79 R4933.1 ; v1(174.08,69.72) 174.15,69.65 C4548.1 ; 174.57,85.36 178.23,85.36 178.84,85.97 v1(181.45,85.97) ; CN4920.43 121.86,70.15 121.55,70.47 v1(121.55,71.06) ; 173.49,71.46 C4519.2
  TOP w0.381: 173.21,72.16 C4543.2
  L3 w0.254: v1(131.21,69.4) 130.81,69.81 130.81,70.57 129.69,71.69 126.39,71.69 125.75,71.06 v1(121.55,71.06) v1(118.89,71.06) 118.75,71.06 118.13,71.68 118.13,72.96 125.57,80.41 v1(125.57,82.46) 126.07,82.96 132.48,82.96 133.27,83.75 140.77,83.75 v1(141.39,84.37) ; v1(174.08,69.72) 174.08,69.65 173.64,69.21 172.49,69.21 v1(172.15,68.86) ; v1(169.55,67.16) 169.55,67.18 170,67.63 171.04,67.63 171.5,67.18 v1(171.5,67.16)
  L5 w0.254: v5(166.47,87.42) 166.47,87.62 159.13,94.96 159.13,95.47 158.68,95.92 156.39,95.92 156.34,95.98 126.02,95.98 124.69,94.64 124.69,89.13 125.57,88.24 v1(125.57,82.46)
  L6 w0.254: v1(171.5,67.16) v1(171.5,65.48)
  BOTTOM w0.2: U4555.CC12 174.08,69.79 174.08,69.72 v1(174.08,69.72) ; v1(172.15,68.86) 172.47,69.19 U4555.CA14
  BOTTOM w0.254: U4555.BU14 v1(170.2,68.8) ; U4555.BY16 171.82,67.49 v1(171.5,67.16) ; v1(171.5,67.16) 171.5,67.26 U4555.BW16 ; v1(171.5,67.16) 171.5,67.07 U4555.BW18 U4555.BW19 171.5,65.58 v1(171.5,65.48) 171.5,65.39 U4555.BY20 ; v1(181.45,85.97) 182.18,85.97 R4609.1 ; U4555.BW14 v1(171.5,68.84) ; U4555.BT12 v1(169.55,69.72) ; v1(169.55,64.64) 169.55,64.55 U4555.BT22 ; R4558.1 v1(141.39,84.37) ; U4555.BP14 167.93,69.25 168.56,69.25 U4555.BR14 ; U4555.BU12 v1(170.19,69.72) ; U4555.BW12 v1(171.49,69.64) ; U4555.BV14 v1(170.85,68.84)
  vias: v1(168.25,65.48) v1(168.9,68) v1(168.9,67.16) v1(168.9,66.32) v1(168.9,65.48) v1(169.55,66.32) v1(171.54,74.67) v1(171.54,74.06) v1(171.54,73.45) v5(166.47,86.65) v5(167.74,87.62) v5(167.74,86.86) v5(168.37,87.24)
P1V5S: length 31
  TOP w0.254: U3300.41 245.17,93.32 TP61700.1 245.94,94.02 C3316.1 246.15,94.58 v1(246.25,94.68) ; U3300.28 243.04,87.3 v1(243.84,86.5) 243.83,86.49 C3375.1 ; U3300.14 v1(236.97,87.52) 236.84,87.39 C3302.1 ; C3369.1 235.25,94.84 v1(235.49,94.84) 236.6,93.72 U3300.1
  L3 w0.508: v1(243.84,86.5) 243.14,87.2 237.28,87.2 v1(236.97,87.52)
  L5 w0.254: v1(246.25,94.68) 244.4,96.53 241.72,96.53 241.46,96.79 237.44,96.79 v1(235.49,94.84)
P1V8A: length 421.6
  TOP w0.254: v1(58.44,21.6) 58.44,22.95 v1(59.46,23.97) 59.41,24.14 59.41,24.88 v1(59.51,24.98) ; R3815.2 R3819.2 194.94,83.85 194.69,83.61 193.93,83.61 ; R3816.2 197.1,78.32 196.98,78.44 196.45,78.44 v1(195.87,79.02) ; C4539.2 174.77,66.35 v1(174.75,66.32) ; v1(203.6,64.23) 203.58,64.21 R4761.2 ; R4762.2 184.63,65.49 184.13,64.99 R4460.2 183.84,64.99 181.72,67.11 v1(181.05,67.11) ; v1(240.86,50.04) 240.86,49.79 241.09,49.56 R334.2 ; 193.93,81.68 193.93,83.61 ; 193.93,81.68 R3814.2 ; 193.93,81.68 193.93,79.46 194.37,79.02 v1(195.87,79.02) ; 193.93,83.61 193.93,84.22 194.18,84.47 R3820.2 ; R386.1 238.87,48.87 v1(238.87,49.38) ; R4539.1 214.5,62.17 214.5,63.25 215.33,64.07 215.69,64.07 v1(215.8,64.07) ; v1(195.87,79.02) 196.62,79.77 R3818.2 197.13,80.56 R3800.2 197.22,80.44 197.22,79.74 197.5,79.45 197.9,79.45 198.19,79.75 R3817.2 ; R3027.1 20.8,28.13 v1(20.98,28.13) ; R359.1 249.6,42.25 249.86,41.99 249.86,41.39 250.18,41.06 v1(251.38,41.06) ; v1(174.1,68) v1(174.71,68) C4538.2 ; R3826.1 v1(197.53,73.84) ; R4520.1 196.36,53.76 196.74,54.13 R4537.1 R4961.1 196.92,54.93 197.27,55.28 197.37,55.28 197.52,55.43 199.43,55.43 199.84,55.02 v1(199.84,54.97) ; v5(205.9,73.66) 205.85,73.72 204.28,73.72 204.08,73.51 200.8,73.51 199.07,71.78 198.88,71.78 198.27,71.17 197.14,71.17 R3823.2
  L3 w0.254: v5(205.9,73.66) 204.85,74.72 201.42,74.72 200.54,73.84 v1(197.53,73.84) 196.87,74.5 v1(194.25,74.5) ; v1(181.05,67.11) 180.06,68.09 174.84,68.09 v1(174.71,68) ; v1(181.95,63.55) 185.33,63.55 185.74,63.96 v1(194.22,63.96) 194.22,63.9 194.35,63.77 194.35,63.76 194.63,63.48 195.03,63.48 195.42,63.86 198.24,63.86 198.53,63.57 198.55,63.57 198.6,63.51 202.89,63.51 v1(203.6,64.23) ; v1(248.89,33.7) 248.89,33.11 246.91,31.13 246.91,30.96 245.64,29.69 245.64,25.26 v1(243.94,23.57)
  L3 w0.508: v1(109.7,88.62) 112.55,88.62 114.17,90.24 v5(118.13,90.24)
  L5 w0.254: v1(251.38,41.06) 249.91,39.59 249.15,39.59 248.21,38.65 248.21,35.8 247.62,35.22 247.62,34.19 248.11,33.7 v1(248.89,33.7) ; v1(20.98,28.13) 20.98,27.8 22.25,26.53 22.65,26.53 22.95,26.84 25.14,26.84 31.29,20.69 31.29,18.85 32.74,17.4 35.14,17.4 35.37,17.17 39.12,17.17 41.22,19.27 41.22,21.06 44.92,24.75 46.8,24.75 46.97,24.93 52.96,24.93 53.43,24.46 54.64,24.46 55.13,23.97 v1(59.46,23.97) ; v1(199.84,54.97) 199.84,55.02 199.43,55.43 196.98,55.43 v1(192.29,60.11) ; v1(238.87,49.38) 239.53,50.04 v1(240.86,50.04) 240.86,46.09 239.27,44.5 236.67,44.5 235.62,43.44 235.62,37.86 233.71,35.95 232.71,35.95 232.43,35.67 232.43,34.29 233.66,33.06 234.58,33.06 234.65,33.14 235.75,33.14 236.07,32.82 236.22,32.66 236.52,32.36 236.52,31.81 237.59,30.74 237.59,25.93 239.47,24.05 241.5,24.05 241.99,23.57 v1(243.94,23.57)
  L5 w0.508: v1(215.8,64.07) 215.24,64.63 215.24,69.3 214.68,69.86 v1(214.63,69.86) ; v1(109.7,88.62) 107.41,86.33 107.41,77.45 101.81,71.85 101.55,71.85 99.55,69.84 99.55,66.04 100.1,65.49 100.33,65.49 103.12,62.7 103.12,61 100.66,58.54 99.9,58.54 91.92,50.56 89.13,50.56 77.09,38.52 73.92,38.52 70.65,37.36 69.64,36.35 69.64,33.77 69.24,33.36 68.81,33.36 62.35,26.91 60.02,26.91 59.51,26.41 v1(59.51,24.98)
  L6 w0.254: v1(195.87,79.02) 195.87,75.5 v1(197.53,73.84) ; v1(221.71,66.56) 221.71,65.17 224.33,62.55 224.33,57.65 224.92,57.06 237.96,57.06 241.83,53.19 241.83,51.81 240.87,50.84 v1(240.86,50.04)
  L6 w0.508: v1(214.63,69.86) 214.63,69.97 214.89,70.24 215.46,70.81 215.46,72 214.27,73.19 207.21,73.19 206.74,73.66 v5(205.9,73.66)
  BOTTOM w0.102: U4555.CP17 v1(181.05,67.11)
  BOTTOM w0.18: v1(181.95,63.55) 181.95,63.45 181.83,63.33 U4555.CP23
  BOTTOM w0.254: U4555.CD19 v1(174.75,66.32) U4555.CD18 174.57,66.97 174.57,67.36 U4555.CD16 v1(174.71,68) U4555.CD15 ; R1309.2 59.71,23.5 59.46,23.76 v1(59.46,23.97) 59.62,24.12 R4908.2 ; v1(221.71,66.56) 221.43,66.56 220.95,66.08 217.75,66.08 217.5,65.83 217.5,64.48 217.21,64.2 215.92,64.2 v1(215.8,64.07) ; R417.1 250.11,33.54 249.05,33.54 v1(248.89,33.7) ; v1(192.29,60.11) 193.13,59.27 194.02,59.27 195.06,60.31 195.06,63.05 194.35,63.76 194.35,63.83 v1(194.22,63.96) 193.32,63.05 R1344.2 ; C7562.1 116.28,89.12 ; v1(214.63,69.86) 216.05,69.86 216.81,70.62 216.81,71.44 217.45,72.08 R7428.1 ; v1(58.44,21.6) 58.44,21.64 59.14,22.34 R4905.2 ; R4538.2 194.25,73.42 v1(194.25,74.5) ; 115.87,89.57 C7561.1 116.07,89.32 ; U4555.CC18 v1(174.1,66.32) U4555.CC19 ; R3824.1 v5(205.9,73.66) ; C7563.1 116.71,88.23 ; v1(174.1,68) 174.1,68.1 U4555.CC15
  vias: v5(118.89,90.24)
P1V8A_EMMC: length 11
  TOP w0.254: U3800.P5 204.66,75.96 v1(204.52,75.82) ; U3800.C6 205.68,81.28 v1(205.87,81.28) ; U3800.M4 U3800.N4 U3800.P3 v1(203.18,75.82)
  L5 w0.254: v1(205.87,81.28) 205.8,81.28 204.64,80.13 204.64,80 204.52,79.88 v1(204.52,75.82)
  BOTTOM w0.254: v1(204.52,75.82) 204.52,76.48 C3804.1 ; C3803.1 203.18,76.48 v1(203.18,75.82)
  vias: v1(203.91,75.82) v3(203.12,75.12)
P1V8S: length 310.4
  TOP w0.508: R514.1 v1(30.32,45.66)
  L5 w0.254: v1(207.34,73.93) 207.34,79.1 207.13,79.3 207.13,81.25 204.21,84.16 204.21,86.04 206.37,88.2 206.37,91.53 204.92,92.98 204.92,93 204.21,93.71 204.21,108.7 204.33,108.81 204.33,108.85 204.64,109.17 204.64,109.8 204.2,110.25 203.27,110.25 202.45,111.07 199.72,111.07 199.41,110.76 195.01,110.76 194.74,111.04 193.44,111.04 191.71,109.31 191.29,109.31 179.1,109.31 176.99,111.42 173.86,111.42 171.47,109.03 161.83,109.03 161.58,109.03 157.24,113.37 147.86,113.37 145.67,111.18 145.67,108.8 144.81,107.94 139.59,107.94 139.09,107.43 139.05,107.43 138.47,106.86 135.49,106.86 134.88,107.46 131.23,107.46 130.63,106.86 127.6,106.86 127.22,107.24 123.14,107.24 122.89,107.24 121.24,108.88 112.15,108.88 109.75,106.48 108.83,105.56 108.83,101.31 108.58,101.06 108.58,94.41 110.16,92.84 110.16,92.12 109.93,91.89 109.93,89.43 110.44,88.92 110.44,86.07 110.44,86.07 110.44,79.43 104.54,73.53 104.54,60.12 102.17,57.75 100.2,57.75 92.5,50.05 89.94,50.05 79.45,39.56 79.45,38.73 80.79,37.38 80.79,35.32 77.32,31.84 72.51,31.84 72.44,31.77 72.13,31.77 71.88,31.51 71.88,29.06 69.84,27.03 67.12,27.03 63.63,23.53 60.38,23.53 60.09,23.82 60.09,24.22 59.84,24.47 58.39,24.47 57.17,25.7 57.17,25.89 53.82,29.25 42.16,29.25 41.88,29.53
  L5 w0.508: 41.88,29.53 41.88,35.55 39.76,37.67 37.62,37.67 34.63,40.66 34.63,41.59 31.93,44.29 30.76,44.29 30.32,44.73 v1(30.32,45.66)
  BOTTOM w0.254: R7038.2 208.18,75.8 Q7154.2 207.38,75.81 207.38,75.5 207.34,75.45 v1(207.34,73.93) 207.36,73.9 R7413.1
P1V8S_AUDIO: length 6.6
  TOP w0.254: C502.1 26.67,41.44 26.28,41.05 U500.20
  TOP w0.305: v1(26.87,42.87) C503.1 26.85,42.18 C502.1 ; R514.2 27.23,45.31 v1(27.23,44.62)
  L5 w0.305: v1(27.23,44.62) 26.87,44.27 v1(26.87,42.87)
P1V8S_EN: length 4.4
  BOTTOM w0.102: 209.07,76.52 R7313.1 210.01,76.52 210.09,76.61 Q7306.6 ; 209.07,76.52 C7024.1 ; 209.07,76.52 209.07,77.63 v3(208.96,77.74) 208.6,78.1 Q7154.1
P1V8S_EN#: length 1.5
  BOTTOM w0.102: R7303.1 212.01,77.54 211.6,77.96 Q7306.3 Q7306.2
P2V5: length 82.8
  L3 w0.762: v5(167.71,12.23) 171.07,12.23 171.08,12.24 197.51,12.24 197.54,12.21 232.47,12.21 234.25,14 234.25,19.3 235.12,20.16 235.88,20.16 236.33,19.72 236.33,19.71 v5(236.33,18.58)
  BOTTOM w0.254: 236.83,18.59 CN4125.257 ; 236.83,18.59 v5(236.33,18.58) ; 236.83,18.59 237.07,18.59 237.33,18.84 CN4125.259 ; 206.54,6.67 v5(206.54,7.75)
  vias: v5(207.3,7.75)
P2V8S_FRONT_DMIC: length 6.8
  TOP w0.254: v1(61.64,43.14) 61.59,43.14 61.07,43.67 MIC9352.4 ; R9352.1 59.54,64.37 v1(59.75,64.58) C9360.1 ; v1(60.64,67.12) 61.01,67.12 C9353.1 61.27,66.11 C9357.1 ; v1(59.59,117.69) 60.22,117.06 MIC9350.4 ; C9354.1 v2(60.48,67.96)
  TOP w0.356: CN9354.6 59.77,51.55 v1(59.78,51.56)
P3V3_ANA: length 1.8
  TOP w0.254: v1(261.84,62.35) 261.51,62.02 U2700.E16
  BOTTOM w0.254: C2778.1 262.35,61.79 261.84,62.3 v1(261.84,62.35)
P3V3_ANA_PCIE: length 5.2
  TOP w0.254: v1(259.24,61.7) U2700.L16
  BOTTOM w0.254: v1(259.24,61.7) 260.65,60.29 260.65,60.18 260.96,59.87 262.01,59.87 v3(262.23,59.65) 262.64,59.65 C2779.1
P3V3_ANA_USB2: length 3.1
  TOP w0.203: U2700.H18 260.21,61.37 v1(260.54,61.7)
  BOTTOM w0.254: v1(260.54,61.7) 261.08,61.15 v3(262.23,61.15) 262.92,61.15 C2780.1
P3V3_LC: length 10.7
  TOP w0.254: v1(255.99,66.25) U2700.V6
  BOTTOM w0.254: R2745.1 R2743.1 R2744.1 R2746.1 251.49,61.44 v3(251.53,61.48) 251.73,61.68 252.66,61.68 253.08,62.1 C2777.1 253.47,63.01 254.23,63.77 254.23,64.5 255.98,66.25 v1(255.99,66.25)
P3V3_RTC: length 242
  TOP w0.203: v1(240.83,44.54) U300.L4
  TOP w0.254: v1(176.19,46.18) 176.19,44.15 175.84,43.8 175.84,42.51 175.82,42.48 175.82,41.83 178.81,38.83 189.68,38.83 190,38.52 212.32,38.52 218.08,32.76 218.08,26.57 220.76,23.89 233.99,23.89 234.46,23.41 234.46,20.68 234.9,20.25 239.89,20.25 243.06,17.08 243.06,13.52 v1(241.38,11.85) ; C312.1 C311.1 249.1,44.79 v1(249.26,44.63) ; v1(168.26,63.76) 168.11,63.91 C4541.1 C4542.1
  L3 w0.254: v1(221,53.08) 221,53 221.41,52.59 222.86,52.59 223.25,52.99 225.22,52.99 225.65,52.56 225.65,52.55 225.93,52.27 226.95,52.27 228.42,53.74 228.42,54.39 228.76,54.73 235.45,54.73 236.37,53.81 236.47,53.71 v2(237.72,53.71) ; v1(168.26,63.76) 168.22,63.8 167.27,63.8 166.79,63.33 166.79,62.62 166.81,62.6 166.81,60.23 166.37,59.74 166.37,56.85 166.08,56.56 166.08,55.85 166.59,55.34 166.87,55.34 167.71,54.5 167.71,53.31 170.9,50.13 173.92,50.13 175.71,48.34 175.71,46.59 176.12,46.18 v1(176.19,46.18) 176.62,45.74 176.62,45.34 176.9,45.06 177.94,45.06 178.51,45.63 179.21,45.63 179.79,45.05 197.56,45.05 198.64,46.13 205.65,46.13 205.69,46.17 209.88,46.17 211.25,44.79 v1(211.43,44.72) ; v1(258.85,8.29) 258.85,8.54 256.96,10.42 253.7,10.42 252.04,12.08 242.53,12.08 242.29,11.85 v1(241.38,11.85) ; v1(240.83,44.54) 241.09,44.28 245.4,44.28 246.02,44.9 248.82,44.9 248.97,44.74 249.15,44.74 v1(249.26,44.63)
  L5 w0.254: v1(214.14,46.22) 215.72,47.79 216.72,47.79 221,52.07 v1(221,53.08)
  L6 w0.254: v2(237.72,53.71) 237.92,53.2 237.92,51.64 238.08,51.47 238.33,51.22 238.59,51.22 240.23,49.58 240.23,49.18 239.65,48.6 239.65,48.17 240.66,47.16 240.66,46.82 240.7,46.78 240.7,45.96 240.71,45.96 240.71,45.17 240.83,45.05 v1(240.83,44.54)
  BOTTOM w0.2: U4555.BR23 168.29,63.67 168.29,63.74 168.26,63.76 v1(168.26,63.76)
  BOTTOM w0.254: R1008.1 262.96,8.47 262.71,8.72 259.27,8.72 v1(258.85,8.29) ; v1(214.14,46.22) 213.43,45.51 212.04,45.51 v1(211.43,44.72) ; v1(221,53.08) 221,54.64 D4750.3 222.72,55.02 222.98,54.77 C4766.1 223.08,53.81 R4834.1 R4845.1
P3V3_SVR: length 43.7
  TOP w0.152: U2700.G2 U2700.H2
  TOP w0.254: 264.45,74.64 C2751.1 264.13,74.32 ; 264.45,74.93 C2750.1 264.45,75.25 ; R2710.1 253.41,72.32 v1(253.41,72.79) ; U2700.L6 v1(259.24,66.25) ; R2711.1 250.64,68.87 250.67,68.85 250.77,68.85 v1(250.82,68.8) ; v1(261.83,66.89) U2700.E6 ; U2700.G1 v1(260.56,69.56) ; v1(247.16,72.81) R2712.1
  TOP w0.381: 264.7,78.75 C2754.1 264.3,79.2 ; 264.3,77.39 C2752.1 264.69,76.94 ; 264.7,77.84 C2755.1 264.3,77.39 ; 264.7,76.01 C2753.1 264.7,76.46
  L5 w0.254: v1(259.24,66.25) 259.89,66.25 260.53,66.89 v1(261.83,66.89) 261.38,67.34 261.38,68.74 v1(260.56,69.56)
  L6 w0.254: v1(260.56,69.56) 260.08,69.08 259.44,69.08 259.44,69.08 256.95,69.08 256.25,68.39 251.23,68.39 v1(250.82,68.8) 251,68.98 251,72.1 249.8,73.29 247.57,73.29 247.16,72.88 v1(247.16,72.81)
  BOTTOM w0.254: v1(247.16,72.81) 247.16,73.07 248.2,74.11 249.37,74.11 250.09,73.39 250.09,72.73 251.56,71.26 251.56,70.93 251.84,70.65 252.93,70.65 253.41,71.13 v1(253.41,72.79)
  vias: v3(264.23,73.9)
P3V3_SX: length 120.3
  TOP w0.203: v1(257.28,66.26) U2700.R6 ; v1(260.54,61.05) U2700.F18
  TOP w0.254: 246.66,70.27 245.68,69.29 R2752.2 245.68,63.19 246.12,62.75 246.12,61.28 248.07,59.33 248.07,56.6 247.63,56.15 C2747.1 R2751.2 245.47,55.35 CN2700.8 U2703.8 ; 246.66,70.27 245.95,70.98 245.64,70.98 245.5,71.13 245.5,71.64 245.51,71.66 245.51,73.09 245.96,73.54 U2701.5 ; 246.66,70.27 247.06,70.27 247.35,69.99 247.35,69.97 247.45,69.87 v1(247.45,69.79) R2760.1 ; R2725.1 v1(252.07,72.79) R2724.1 ; v1(253.11,77.13) 252.93,77.3 R2729.1 R2726.1 ; v1(250.82,67.65) R2728.1 R2730.1 ; R2775.1 249.57,73.47 249.47,73.57 C2746.1 249.45,73.62 249.45,74.11 U2702.6 249.38,74.56 v1(249.73,74.56) ; v1(270.99,71.21) 270.99,72.18 R2755.2 270.76,72.41 C2748.1 C2749.1 270.86,73.05 R2756.2 ; v1(242.24,67.27) 242.24,67.2 241.53,66.5 R2754.2 ; R2753.2 244.03,66.67 v1(243.43,67.27)
  L3 w0.254: v1(242.24,67.27) 242.34,67.38 242.34,68.69 242.62,68.98 246.87,68.98 247.44,69.55 v1(247.45,69.79) 249.19,69.79 250.34,68.64 250.34,68.14 v1(250.82,67.65) 251.74,67.65 252.47,68.39 252.99,68.39 253.27,68.67 253.27,71.2 252.07,72.4 v1(252.07,72.79) 252.52,72.79 254.02,74.29 254.02,74.69 253.74,74.97 253.48,74.97 253.06,75.4 253.06,77.08 v1(253.11,77.13)
  L5 w0.254: v1(257.28,66.26) 257.28,65.61 257.73,65.16 257.73,65.15 258.01,64.87 258.01,63.55 258.11,63.45 258.13,63.45 258.4,63.19 258.4,63.17 258.6,62.97 259.48,62.97 259.95,62.5 259.95,61.45 260.35,61.05 v1(260.54,61.05) 262.53,61.05 262.95,61.47 262.95,62.55 262.84,62.66 262.84,65.42 263.78,66.36 264.87,66.36 267.99,69.49 v1(267.99,70.91)
  BOTTOM w0.254: v1(253.11,77.13) 253.06,77.08 253.06,76.52 253.34,76.24 253.74,76.24 256.74,79.24 v3(258.21,79.24) 262.66,79.24 264.16,77.74 264.16,74.03 267.28,70.91 v1(267.99,70.91) 267.99,69.81 268.25,69.56 270.74,69.56 270.99,69.81 v1(270.99,71.21) ; v1(249.73,74.56) 250.75,73.55 250.75,72.61 251.03,72.33 251.61,72.33 v1(252.07,72.79) ; v1(242.24,67.27) v1(243.43,67.27)
P3V3A: length 807.5
  TOP w0.254: v1(183.49,98.3) 183.49,98.23 182.6,97.35 R61404.1 R61403.1 ; v1(212.67,46.22) 213,46.54 R4624.1 ; R4512.1 v1(187.02,73.97) ; v1(108.4,46.04) 108.4,45.7 R4925.1 ; v1(218.67,39.82) 218.34,39.82 R4792.1 ; v1(141.6,5.88) 141.58,5.91 R1002.1 ; v1(57.18,6.42) 57.18,10.09 56.92,10.35 54.34,10.35 52.8,11.89 52.8,13.9 53.98,15.08 59.05,15.08 60.58,16.6 60.84,16.6 62.46,18.22 62.46,26 v1(58.24,30.22) ; v1(208.33,70.01) 208.43,70.12 R4556.1 ; v1(208.33,70.01) 208.3,69.98 R4733.1 208.3,69.5 R4557.1 ; v1(208.33,70.01) 208.24,70.1 R4702.1 ; R4797.1 v1(214.02,70.68) ; v1(133.65,5.88) 133.65,6.95 134.36,7.66 134.36,8.06 134.21,8.22 134.21,8.22 133.86,8.57 R1021.2 ; R4678.1 190.26,70.99 v1(190.12,71.13) 190.15,71.16 R4771.1 189.82,72.02 R4772.1 ; R1300.1 189.07,70.85 v1(189.51,71.13) 189.23,71.41 R4768.1 ; v1(191.94,62.89) 192.47,63.43 v1(192.47,64.57) ; R4918.1 185.22,62.35 185.21,62.35 v1(184.47,62.35) ; v1(185.21,44.57) 185.21,43.45 R4623.1 185.29,42.82 185.65,42.46 R4525.1 188.64,40.38 190.25,40.38 190.62,40.02 207.15,40.02 207.87,40.74 208.45,40.74 208.64,40.92 209.32,40.92 210.92,39.33 213.66,39.33 v1(214.88,40.55) ; v1(249.48,71.13) 249.51,71.13 249.91,71.53 Q2701.2 ; R4914.1 185.83,60.27 185.62,60.48 185.62,60.78 185.38,61.02 R4353.2 185.21,61.03 R4550.1 ; R4914.1 186,59.94 R4620.1 ; R4914.1 R4915.1 186.9,60.27 187.25,60.62 187.52,60.62 188,61.1 v1(188,61.27) ; v1(217.65,37.78) 217.37,38.06 R4830.1 ; R1003.1 141.26,7.76 141.36,7.66 141.8,7.66 143.41,6.06 143.41,6.01 v1(143.58,5.83) ; v1(241.63,67.27) 240.92,67.27 240.1,66.45 240.1,58.3 240.1,58.3 v1(240.05,58.26) ; v1(185.95,62.65) 185.95,63.19 186.33,63.57 C4504.2 ; v1(251.33,42.56) 251.1,42.33 251.1,42.33 R4861.1 ; v1(213.41,72.58) 213.41,72.51 213.84,72.07 214.01,72.07 R4884.1
  L3 w0.254: v1(159.64,97.68) 159.74,97.68 165.73,103.67 166.77,103.67 167.88,104.78 167.88,104.78 v1(168.37,104.78) 168.77,104.78 168.77,104.78 171.23,102.33 175.05,102.33 177.99,99.39 178.24,99.39 180.98,99.39 181.59,98.78 183.08,98.78 183.49,98.38 v1(183.49,98.3) ; v1(213.41,72.58) 213.53,72.46 213.53,72.38 214.02,71.9 v1(214.02,70.68) ; v1(192.47,64.57) v1(193.08,64.57) ; v1(97.33,57.9) 97.58,57.65 102.41,57.65 104.06,59.3 v1(107.69,59.3) 108.15,58.84 108.15,58.29 107.87,58 107.35,58 107.34,58 102.88,53.54 102.88,52.73 102.62,52.47 102.62,50.73 104.38,48.97 105.47,48.97 v1(108.4,46.04) ; v1(143.58,5.83) 143.58,5.88 143.1,6.36 142.08,6.36 v1(141.6,5.88) 141.02,5.3 136.45,5.3 135.38,6.36 134.18,6.36 133.7,5.88 v1(133.65,5.88) 131.51,3.74 128.93,3.74 127.13,1.94 114.97,1.94 113.32,3.6 103.15,3.6 102.49,4.26 102.49,6.85 101.62,7.71 72.46,7.71 70.55,5.8 66.88,5.8 66.16,6.52 57.28,6.52 v1(57.18,6.42) ; v1(198.57,76.32) 197.42,77.47 196.58,77.47 195.89,78.17 v1(192.68,78.17) ; v1(191.94,62.89) 191.46,62.41 190.43,62.41 189.71,63.13 186.43,63.13 v1(185.95,62.65) ; v1(241.63,67.27) 241.63,68.52 242.46,69.36 245.75,69.36 246.66,70.27 248.61,70.27 v1(249.48,71.13) ; v1(220.82,56.18) 220.82,56.45 220.57,56.71 219.86,56.71 217.85,54.7 217.29,54.7 216.26,55.74 216.26,58.71 215.79,59.17 211.28,59.17 v1(209.35,61.1)
  L5 w0.254: v1(212.67,46.22) 212.06,46.22 210.77,44.92 210.77,43.98 214.2,40.55 v1(214.88,40.55) ; v1(249.48,71.13) 249.61,71.13 251.3,69.44 251.3,67.45 250.39,66.54 250.39,59.2 253.01,56.58 253.01,52.49 250.9,50.39 250.9,42.99 v1(251.33,42.56) ; v1(185.21,44.57) 185.21,51.77 184.47,52.51 v1(184.47,62.35) ; v1(187.02,73.97) 187.02,73.89 187.74,73.17 190.37,73.17 191.2,72.33 191.56,72.33 192.81,73.58 192.81,78.04 v1(192.68,78.17) 192.68,82.34 192.06,82.96 186.39,82.96 183.79,85.57 183.79,96.91 183.49,97.21 v1(183.49,98.3)
  L5 w0.381: v1(58.24,30.22) 57.1,31.36 57.1,35.6
  L5 w0.508: 57.1,35.6 60.98,35.6 61.24,35.85 63.06,35.85 64.87,34.05 66.44,34.05 70.3,37.91 73.81,39.16 76.83,39.16 88.87,51.2 90.17,51.2 96.06,57.09 96.49,57.09 97.3,57.9 v1(97.33,57.9)
  L5 w1.016: v1(97.33,57.9) 97.33,60.69 97.12,60.91 97.12,63.29 97.33,63.51 97.33,68.88 101.18,72.74 101.44,72.74 106.52,77.81 106.52,87.14 102.82,90.84 102.82,92.98 102.89,93.05 102.89,93.77 102.82,93.84 102.82,104.74 101.88,105.68 101.88,109.98 102.89,111 104.76,111 107.13,113.37 109.47,113.37 109.52,113.43 116.85,113.43 117.13,113.15 121.33,113.15 122.22,114.04 124.1,114.04 124.22,113.92 138.42,113.92 140.05,112.28 140.87,112.28 143.34,114.75 175.61,114.75 178.41,111.94 181.01,111.94 182.58,113.51 198.9,113.51 199.56,112.85 200.28,112.85 200.94,113.51 200.95,113.51 202.02,114.58 207.89,114.58 207.95,114.64 210.97,114.64 212.44,113.17 212.44,110.78 210.98,109.33 210.98,96.61 208.61,94.24 208.61,91.33 209.28,90.65 209.28,89.86 209.28,80.3 213.76,75.82 213.76,73.73
  L6 w0.254: v1(184.47,62.35) 184.77,62.65 v1(185.95,62.65) 186.85,61.75 187.57,61.75 188,61.32 v1(188,61.27) ; v1(212.67,46.22) 212.9,46.45 212.9,47.54 210.6,49.84 210.6,59.85 v1(209.35,61.1) 208.76,61.69 208.31,61.69 207.9,62.1 v1(207.9,63.51) ; v1(208.33,70.01) 208.91,70.6 213.94,70.6 v1(214.02,70.68)
  BOTTOM w0.178: v1(220.82,56.18) 220.88,56.12 223.04,56.12 223.33,56.41 223.33,58.81 222.91,59.23 222.91,60.63 223.19,60.91 R373.1
  BOTTOM w0.254: 190.12,71.06 v1(190.12,71.13) ; 190.12,71.06 190.53,70.65 192.14,70.65 192.73,71.23 192.73,78.13 v1(192.68,78.17) ; 190.12,71.06 190.12,70.97 189.8,70.65 189.31,70.65 189.24,70.72 R4856.1 ; v1(251.33,42.56) 251.46,42.56 254.12,45.22 CN4941.1 ; v1(159.64,97.68) 159.28,98.03 R7010.1 ; v1(214.88,40.55) 215.62,39.82 v1(218.67,39.82) 218.67,38.8 v1(217.65,37.78) ; v1(168.37,104.78) 168.37,105.18 167.77,105.77 R7424.2 ; R4536.1 191.87,62.96 v1(191.94,62.89) ; R373.1 225.61,60.91 225.78,60.75 226.18,60.75 226.26,60.82 227.63,60.82 229.21,59.25 239.06,59.25 v1(240.05,58.26) ; R4809.1 202.71,72.45 v1(202.79,72.37) 202.72,72.3 R4742.1 202.81,68.93 202.81,68.77 202.91,68.68 202.91,66.54 203.06,66.39 203.77,66.39 204.23,66.85 U4700.5 205.55,67.09 205.81,67.09 206.06,67.09 207.03,68.05 207.03,69 206.96,69.07 206.96,69.52 207.45,70.01 v1(208.33,70.01) ; v1(198.57,76.32) 199.41,75.48 R4545.1 ; v1(214.02,70.68) 214.35,70.35 215.59,70.35 216.18,70.93 R7427.1 216.3,71.57 R7425.1 ; v1(193.08,64.57) 193.08,65.33 193.34,65.58 R4700.1 R4839.1 R4734.1 ; v1(192.47,64.57) 192.47,65.55 v3(192.43,65.59) R4831.1 R4703.1 R4766.1 ; R61422.1 182.88,95.72 184.07,95.72 184.32,95.97 R7025.1 184.32,96.34 183.49,97.17 v1(183.49,98.3) ; R4763.1 207.94,63.47 v1(207.9,63.51) ; R60522.1 105.14,59 105.43,59.3 v1(107.69,59.3) ; v1(189.51,71.13) 189.32,71.33 R4535.1 R4856.1 ; R4856.1 R4827.1 ; v1(187.02,73.97) 187.11,74.08 R4754.1 ; v1(97.33,57.9) 100.3,57.9 R7007.1
  BOTTOM w0.381: v1(58.24,30.22) 58.46,29.99 R1307.1
  vias: v1(207.61,80.09) v1(207.61,79.5) v1(214.02,72.58)
P3V3A_EMMC: length 5.8
  TOP w0.254: U3800.F5 U3800.E6 205.52,80.44 v1(205.52,80.06) v1(206.04,79.54) 206.61,78.97 206.99,78.97 U3800.J10 U3800.K9
  BOTTOM w0.254: C3800.1 204.54,78.98 ; C3802.1 204.37,79.69
P3V3A_EN: length 3.5
  TOP w0.102: v1(213.71,85.08) 214.05,84.74 R7024.2 213.71,84.08 213.71,83.22 v3(213.99,82.95)
  BOTTOM w0.102: U7001.5 213.53,85.26 v1(213.71,85.08)
P3V3A_LDO: length 491.1
  TOP w0.254: v1(1.75,44.85) 1.75,45.81 TP2519.1 ; v1(213.2,79.61) 213,79.47 213,78.88 R7019.1 214.04,77.83 214.98,77.83 v1(217.52,75.29) ; R1001.2 236.62,26.03 236.75,26.16 R1012.1 237.97,25.36 R327.2 238.26,24.55 238.87,23.94 239.47,23.94 v1(240.52,24.99) ; v1(247.75,43.04) 247.85,42.94 R129.2 ; U1000.1 137.42,9.72 137.42,10.06 137.55,10.19 137.66,10.19 137.87,10.4 139.73,10.4 140.91,9.21 C1001.1 141.95,9.21 v1(142.57,8.6)
  L3 w0.254: v1(28.4,9.79) 28.4,9.73 29.7,8.42 31.73,8.42 32.46,9.15 47.24,9.15 49.53,11.44 49.53,13.02 50.39,13.88 59.66,13.88 62.34,11.21 84.03,11.21 85.67,9.56 86.64,9.56 86.97,9.89 86.97,10.13 87.37,10.53 88.33,10.53 90.16,8.7 101.47,8.7 101.47,8.7 102.03,8.7 105.01,5.73 106.21,5.73 106.26,5.68 110.16,5.68 113.88,9.4 128.69,9.4 129.64,10.34 134.49,10.34 135.28,9.56 135.46,9.38 141.79,9.38 v1(142.57,8.6) 142.57,8.65 142.69,8.78 142.69,8.8 142.98,9.08 144.85,9.08 145.32,8.61 145.49,8.44 150.1,8.44 150.91,8.44 151.85,9.38 157.61,9.38 157.98,9.74 159.05,9.74 159.48,9.32 159.73,9.32 159.73,9.32 162.33,9.32 162.42,9.22 162.78,8.87 162.93,8.71 162.93,8.71 163.37,8.71 163.37,8.71 164.34,8.71 164.56,8.93 169.04,8.93 169.22,9.11 177.05,9.11 177.3,9.36 190.66,9.36 191.92,9.36 192.53,8.75 213.96,8.75 215.73,6.97 219.41,6.97 220.53,5.86 221.76,5.86 222.68,4.94 226.56,4.94 229.74,8.12 229.74,8.52 231.42,10.2 236.37,10.2 241.87,15.7 241.87,21.37 242.1,21.6 242.1,23.42 v1(240.52,24.99) ; v1(215.54,99.99) 220.47,95.05 223.04,95.05 223.04,95.05 223.41,95.05 223.65,94.82 224.35,94.12 224.35,87.48 230.58,81.25 230.58,79.95 230.17,79.54 v1(230.1,79.54)
  L5 w0.254: 245.51,43.88 245.51,41.98 243.15,39.62 243.15,38.86 244.62,37.38 244.62,35.32 244.51,35.2 244.51,33.78 244.14,33.41 242.97,33.41 239.43,29.87 239.43,25.4 239.84,24.99 v1(240.52,24.99) ; 245.51,43.88 245.51,44.39 246.48,45.36 246.48,45.9 246.58,46 246.58,67.17 247.19,67.78 247.65,67.78 247.93,68.06 247.93,69.99 247.62,70.3 246.12,70.3 243.9,72.52 243.9,75.5 242.86,76.54 237.16,76.54 236.45,75.83 232.64,75.83 231.85,76.62 231.85,77.89 230.2,79.54 v1(230.1,79.54) ; 245.51,43.88 246.81,43.88 247.65,43.04 v1(247.75,43.04) ; v1(28.4,9.79) 28.08,10.11 26.9,10.11 26.64,10.36 26.64,15.53 26.35,15.83 24.56,15.83 24.5,15.89 20.09,15.89 19.43,16.55 19.43,22.01 19.61,22.19 19.61,30.67 19.35,30.93 10.44,30.93 9.7,31.66 9.7,33.88 9.14,34.44 9.14,35.98 8.33,36.79 6.04,36.79 4.57,38.27 4.57,40.6 3.68,41.49 2.59,41.49 1.75,42.33 v1(1.75,44.85) ; v1(215.54,99.99) 215.54,97.19 210.16,91.81 210.16,88.66 213.03,85.79 213.03,80.47 213.25,80.24 213.25,79.66 v1(213.2,79.61)
  L6 w0.254: v1(221.31,57.39) 221.38,57.39 221.79,57.8 221.79,60.17 219.35,62.61 219.35,65.22 218.54,66.03 218.54,66.73 218.28,66.99 216.99,68.28 216.99,70.1 218,71.11 218,74.81 v1(217.52,75.29)
  BOTTOM w0.254: CN2500.30 v1(1.75,44.85) ; R7005.1 213.11,79.52 v1(213.2,79.61) 213.25,79.66 213.83,79.66 215.23,78.27 215.23,77.91 214.66,77.35 214.66,76.42 215.01,76.08 215.01,74.6 214.68,74.27 213.64,74.27 R7410.1 ; C60191.1 230.58,79.04 230.58,79.13 230.3,79.41 230.22,79.41 v1(230.1,79.54) 230.04,79.6 U60100.6 ; v1(215.54,99.99) 215.54,99.97 215.58,99.92 215.58,98.85 214.84,98.11 R1017.2 214.72,97.81 215.18,97.36 U7000.5 ; v1(221.31,57.39) 222.06,57.39 D4750.2
P3V3A_LDO_DB: length 94.8
  TOP w0.254: v1(39.08,110.15) 39.08,112.58 39.85,113.35 v3(39.85,119.09) U9204.VDD ; D9205.1 v1(44.21,68.16)
  L3 w0.254: v1(44.21,68.16) 43.11,67.07 39.57,67.07 37.18,69.46 33.73,69.46 33.02,70.17 33.02,70.8 32.73,71.08 32.43,71.08 v1(32.33,71.19)
  L6 w0.254: v1(32.33,71.19) 32.33,71.08 32.05,70.8 32.05,70.4 32.51,69.94 32.63,69.94 33.34,69.23 37.85,69.23 39.39,70.77 39.39,74.28 39.11,74.56 38.73,74.56 34.05,79.24 34.05,90.04 36.76,92.74 36.76,96.23 35.26,97.73 35.26,101.61 34.73,102.14 33.54,102.14 33.28,102.39 33.28,105.11 33.54,105.36 36.57,105.36 38.93,107.72 38.93,110.01 v1(39.08,110.15) 40.23,109 40.23,107 42.97,104.26 v1(42.97,103.3)
  BOTTOM w0.254: C9229.1 42.52,102.85 v1(42.97,103.3) ; CN9202.1 32.75,71.73 32.33,71.31 v1(32.33,71.19)
P3V3A_PRIME: length 50
  TOP w0.254: C4546.2 173.88,64.51 ; 174.22,64.85 C4545.2 174.45,65.17 174.71,64.91 v1(174.71,64.64) ; v5(215.89,92.09) 216.91,92.09 R7001.2
  L3 w0.203: v1(171.5,62.96) 171.08,62.55 168.05,62.55 v1(167.6,62.99)
  L3 w0.254: v1(171.5,62.96) v1(173.45,62.96)
  L5 w0.254: v1(173.45,62.96) 173.65,62.76 173.65,62.76 173.93,62.48 173.93,62.48 174.22,62.2 174.22,61.58 174.79,61.01 177.17,61.01 177.26,60.91 179.88,60.91 v1(181.25,59.54)
  L6 w0.254: v1(173.45,67.16) 173.45,66.16 173.91,65.71 173.91,64.78 v1(174.04,64.65)
  BOTTOM w0.09: U4555.CP29 181.04,59.54
  BOTTOM w0.254: C7013.2 v5(215.89,92.09) ; v1(167.6,62.99) 167.92,63.26 U4555.BP23 ; U4555.CB16 173.45,67.26 v1(173.45,67.16) ; v1(171.5,62.96) 171.5,63.06 U4555.BW23 ; 181.04,59.54 v1(181.25,59.54)
  BOTTOM w1.016: v5(202.11,79.54) 202.11,85.18 204.93,87.99 204.93,91.44 206.49,93.01 215.51,93.01
  vias: v1(173.47,63.83) v1(174.13,62.96) v3(174.6,63.77)
P3V3A_PRIME_EN: length 8.9
  BOTTOM w0.254: C7012.1 213.83,90.94 Q7004.1 213.78,89.92 212.59,89.92 Q7003.6 212.49,90.31 212.99,90.82 212.99,90.95 R7029.2 212.88,90.97 212.48,91.37 212.48,91.63 212.07,92.04 v3(211.05,92.04) 210.64,92.04 210.23,91.63 210.23,91.23 210.51,90.95 R7040.1
P3V3A_PRIME_EN#: length 11.6
  TOP w0.102: v3(216.94,89.65) 216.63,89.96 Q7006.G 216.6,90.57 211.58,90.57 v1(210.72,91.43)
  BOTTOM w0.102: v1(210.72,91.43) 210.91,91.24 210.91,89.49 R7039.1 210.93,88.67 Q7003.3 Q7003.2
P3V3A_Q_WLAN: length 42.8
  TOP w0.254: R1304.1 55.31,23.96 54.79,24.49 51.58,24.49 50.97,25.1 50.27,25.1 v1(49.17,26.2)
  L3 w0.381: v1(49.17,26.2) 49.94,26.2 50.53,26.79 50.53,28.89 50.91,29.28 59.71,29.28 v1(60.6,30.16)
  L5 w0.254: v5(61.42,35) v5(62.16,35.02)
  L5 w0.381: v1(60.6,30.16) 60.6,32.78 61.42,33.6 v5(61.42,35)
  BOTTOM w0.254: 66.64,35.05 67.1,35.52 67.1,36.92 67.39,37.2 68.72,37.2 68.72,37.2 v3(73.51,37.2) R1302.1 ; C1301.1 47.84,25.14 ; C1304.1 61.36,18.1 ; 49.68,26.1 49.93,26.35 R1305.1 ; 47.84,25.77 C1305.1 ; C1302.1 61.24,18.73 ; C1307.1 48.36,24.44 C1306.1
  BOTTOM w0.381: R1306.1 60.81,29.96 v1(60.6,30.16) 60.43,30.34 R1346.1
P3V3A_SS2: length 2
  BOTTOM w0.254: U7001.10 210.43,85.26 210.35,85.18 209.95,85.18 209.85,85.28 C7041.1
P3V3AL_KBC: length 4.2
  TOP w0.254: R347.2 226.95,39.4 R405.2 228.09,39.84 v3(228.6,40.35) 229.05,39.9 C322.1 229.38,40.79 R379.1
P3V3AL_RTC_BAT: length 2.4
  TOP w0.254: v1(211.16,7.58) 210.73,8 TP4750.1 211.24,8.18 211.36,8.06 R4832.2
  BOTTOM w0.254: CN4750.1 v1(211.16,7.58)
P3V3AL_RTC_BAT_D4750: length 101.5
  TOP w0.254: v1(214.06,35.12) 214.01,35.07 214.01,34.49 217.41,31.1 217.41,26.37 220.27,23.51 233.83,23.51 234.08,23.25 234.08,12.51 233.83,12.26 216.83,12.26 213.93,9.36 v3(213.1,9.36) 213.05,9.31 212.38,9.31 R4832.1
  L3 w0.254: v1(223.91,37.95) 223.98,37.95 224.27,37.66 225.67,37.66 226.62,38.61 226.62,39.36 228.32,41.06 v1(228.32,41.57)
  L6 w0.254: v1(220.21,56.2) 219.92,56.2 219.64,55.92 219.64,49.91 222.04,47.51 222.48,47.51 228.32,41.67 v1(228.32,41.57)
  BOTTOM w0.254: v1(223.91,37.95) 223.59,38.27 222.75,38.27 222.24,38.77 220.51,38.77 218.2,36.46 215.41,36.46 v1(214.06,35.12) ; D4750.1 220.25,56.94 220.25,56.24 v1(220.21,56.2)
P3V3DS: length 733.3
  TOP w0.229: v1(208.51,63.51) 208.51,63.3 208.24,63.03 207.32,63.03 207.18,62.89 207.18,61.58 206.45,60.84 201.2,60.84 201.16,60.88 200.82,60.88 R1404.1
  TOP w0.254: C4531.2 169.08,63.33 169.09,63.33 169.37,63.61 169.37,63.62 v1(169.55,63.8) ; R352.2 240.65,33.81 241.15,34.31 v1(241.15,34.33) ; v1(180.31,44.57) 180.36,44.52 R4744.1 180.36,42.78 R4554.1 ; v1(45.84,23.59) 45.26,23.59 44.55,24.3 42.12,24.3 41.63,24.79 ; v1(247.37,23.74) 247.44,23.74 248.66,24.96 248.66,25.11 R2428.2 ; v1(187.63,104.38) 188.08,104.84 R60021.1 ; v1(247.75,42.43) 247.68,42.43 247.5,42.61 247.45,42.61 R315.2 ; v1(259.4,99.59) 258.65,98.84 R60053.2 257.69,98.33 Q60032.G ; v1(48.97,21.78) 49.78,20.97 49.78,17.84 49.37,17.43 v1(49.3,17.43) 49.26,17.39 46.87,17.39 46.64,17.62 46.64,17.62 v1(45.74,17.62) ; v1(104.19,39.13) 103.69,39.13 103.15,38.59 U4920.5 ; v1(209.47,116.14) 209.02,116.59 206.81,116.59 v1(206.5,116.89) ; v1(30.22,19.27) 32.36,21.4 37.54,21.4 40.93,24.79 41.63,24.79 ; v1(268.05,22.03) 267.55,22.03 R2418.2 ; v1(251.74,32.5) 252.16,32.92 R2634.2 ; R384.1 248.54,37.48 R309.2 248.54,36.57 248.28,36.32 247.36,36.32 247.21,36.46 247.21,36.55 247.19,36.57 247.19,36.59 246.81,36.97 v1(246.71,36.97) ; v1(204.92,85.03) 204.19,84.29 200.96,84.29 200.58,83.91 199.02,83.91 197.32,85.61 195.65,85.61 195.42,85.38 193.8,85.38 193.54,85.13 193.54,78.62 194.61,77.56 194.61,77.16 194.33,76.87 193.12,76.87 192.73,76.48 192.73,74.31 R3825.1 ; v1(257.27,32.31) 257.12,32.31 R2633.2 ; v1(241.68,50.04) 241.73,49.99 R324.2 ; R397.2 231.14,38.26 231.04,38.36 v1(231.04,39.13) 231.44,39.13 R306.2 231.58,39.61 R307.2 ; 99.59,39.13 v1(102.51,39.13) 102.5,39.15 U4920.3 102.21,40.69 C4920.1 102.21,43.19 104.39,45.36 105.21,45.36 106.19,44.38 R4934.1 ; 99.59,39.13 99.19,39.13 98.94,39.38 U4921.3 98.94,41.62 C4921.1 ; 99.59,39.13 U4921.5 ; v1(222.12,41.21) R406.2 R326.2 ; v1(177.1,45.54) 177.1,43.9 176.68,43.47 R4743.1 ; v1(42.34,26.3) 42.27,26.3 41.63,25.67 41.63,24.79 ; Q1000.G v1(241.39,26.21) ; v1(208.51,63.51) 208.58,63.51 208.99,63.92 208.99,64.18 209.6,64.78 212.16,64.78 212.19,64.81 v1(212.39,64.81) ; R1403.2 217.52,61.93 217.78,61.67 v5(217.78,59.93) ; v1(25.93,23.39) R3015.1 24.82,22.91 23.88,22.91 23.26,22.29 U3001.5 ; R385.2 240.95,28.75 v1(240.9,28.8) R320.2 R103.1 R101.1 ; R317.2 250.56,46.72 R325.2 250.01,46.17 250.01,46.01 249.86,45.86 249.55,45.86 249.27,45.58 v1(249.27,45.51) ; R311.2 232.91,49.75 R310.2 231.8,49.75 R391.2 R394.2 231.19,50.94 v1(231.77,51.52) ; v1(249.75,28.13) 249.13,27.5 R2424.2 ; C7622.1 237.21,28.67 R449.1 236.99,28.99 236.39,28.99 235.95,29.43 235.93,29.43 R375.2 235.91,29.94 v1(235.89,29.96) 235.89,30.49 236.29,30.89 R356.2 R378.2 ; R405.1 228.83,37.6 229.08,37.85 v1(229.08,38.87) ; v1(278.5,51.26) 274.2,51.26 272.88,49.94 v1(268.59,49.94) ; v1(204.96,53.65) 205.25,53.36 R1408.1 205.68,52.47 214.99,52.47 215.52,51.93 R4835.1 216.51,53.51 v1(216.53,53.53) ; R4579.1 R4717.1 196.66,50.6 196.79,50.46 199.03,50.46 200.24,51.67 202.24,51.67 v1(202.29,51.62) 202.34,51.57 202.34,49.85 202.09,49.6 198.19,49.6 197.93,49.34 R4947.1 197.94,48.7 200.38,48.7 200.68,49 201.44,49 201.95,48.5 v1(201.95,46.84) ; v1(208.51,56.99) 209.06,56.99 209.38,56.67 R1410.1 ; v5(267.33,78.12) 266.98,77.76 R2758.1 ; v5(53.72,26.07) 53.11,26.68 v5(53.11,33.49) ; 55.81,25.34 C7621.1
  TOP w0.33: R2756.1 272.26,73.12 273.36,74.22 273.36,76.03 270.4,79 267.95,79 267.33,78.38 v5(267.33,78.12)
  TOP w0.508: v1(262.56,52.97) 263.95,52.97 264.41,52.52 266.01,52.52 v1(268.59,49.94) ; v5(263.75,17.39) 262.67,18.47 R2456.1
  L3 w0.254: v1(169.55,63.8) 169.55,63.79 169.05,63.29 167.97,63.29 167.8,63.46 167.41,63.46 167.13,63.19 167.13,62.8 167.19,62.74 167.19,60.08 166.92,59.78 166.75,59.6 166.75,56.69 166.46,56.41 166.46,56.01 166.75,55.72 167.02,55.72 169,53.75 169,53.67 172.16,50.51 174.09,50.51 175.61,48.98 176.19,48.98 177.55,47.62 177.55,45.95 177.14,45.54 v1(177.1,45.54) ; v5(263.75,17.39) 263.75,12.95 260.42,9.62 260.42,8.9 259.05,7.53 259.05,6.72 ; v5(217.78,59.93) 217.73,59.98 212.04,59.98 v1(208.51,63.51) ; 259.05,6.72 v1(259.05,6.54) ; 259.05,6.72 256.08,9.69 241.58,9.69 238.43,6.54 238.43,6.14 238.89,5.68 v1(238.91,5.68) ; v1(262.95,99.59) 262.9,99.52 262.49,99.11 259.65,99.11 259.4,99.36 v1(259.4,99.59) ; v1(268.59,49.94) 268.59,51.16 269.06,51.63 269.26,51.63 269.73,52.09 269.73,52.1 269.73,68.35 267.36,70.72 267.36,78.09 v5(267.33,78.12) ; v1(268.05,22.03) 261.76,22.03 261.63,22.16 260.45,23.34 260.45,23.93 261.38,24.87 261.54,24.87 261.82,25.15 261.82,26.51 262.07,26.76 262.07,28.53 262.25,28.71 v1(262.25,31.21)
  L5 w0.254: v1(251.74,32.5) 251.93,32.31 v1(257.27,32.31) 257.27,31.83 257.54,31.55 261.91,31.55 v1(262.25,31.21) ; v1(249.75,28.13) 249.75,26.05 247.44,23.74 v1(247.37,23.74) 247.29,23.74 244.77,26.26 v1(241.39,26.21) ; v1(216.53,53.53) 217.82,53.53 219.43,55.13 219.43,59.81 v5(219.3,59.93) ; v1(208.51,56.99) 207.92,57.57 207.06,57.57 206.37,56.89 206.37,54.75 205.27,53.65 v1(204.96,53.65) 202.83,51.62 v1(202.29,51.62) ; v1(255.99,46.1) 257.18,46.1 257.45,46.37 258.47,46.37 259.76,47.66 259.76,51.93 v1(259,52.69) ; v1(182.97,116.34) 182.97,115.75 184.44,114.28 200.63,114.28 201.7,115.34 204.95,115.34 v1(206.5,116.89) ; v1(214.86,103.44) 214.4,103.9 214.4,106.97 213.2,108.16 213.2,113.48 210.54,116.14 210.54,116.14 v1(209.47,116.14) ; v1(30.22,19.27) 30.22,20.89 27.73,23.39 v1(25.93,23.39)
  L5 w0.508: v5(263.75,17.39) 263.75,17.49 266.19,19.93 266.19,21.52 266.7,22.03 v1(268.05,22.03) ; 259.03,54.47 258.75,54.47 258.49,54.73 255.58,54.73 251.58,58.72 251.58,67.02 251.81,67.24 251.81,67.9 252.17,68.26 252.54,68.26 252.54,68.26 253.04,68.26 253.4,68.62 253.4,71.94 252.8,72.53 252.8,73.6 252.17,74.23 252.17,82.3 253.14,83.26 254.21,83.26 254.63,82.84 254.63,82.08 255.03,81.68 255.6,81.68 257.25,83.33 264.25,83.33 265.93,81.64 265.93,79.52 v5(267.33,78.12)
  L6 w0.254: v5(267.33,78.12) 265.15,80.3 265.15,89.56 265.32,89.73 265.32,93.75 264.06,95.01 264.06,98.49 v1(262.95,99.59) ; v1(204.92,85.03) 204.92,86.05 205.76,86.88 v5(214.53,86.88) ; v1(42.34,26.3) 44.91,26.3 46.1,27.5 52.29,27.5 53.71,26.07 v5(53.72,26.07) ; v1(180.31,44.57) 180.79,45.05 185.41,45.05 186.38,44.08 199.19,44.08 v1(201.95,46.84) ; v1(45.84,23.59) 45.46,23.2 45.46,21.81 45.74,21.53 v1(45.74,17.62)
  BOTTOM w0.2: U4555.BT23 v1(169.55,63.8)
  BOTTOM w0.254: R4411.2 182.94,116.3 v1(182.97,116.34) 182.97,116.61 182.59,116.99 U4412.4 ; R423.2 259.97,3.2 259.67,3.49 259.65,3.49 259.08,4.06 259.08,4.4 259.08,4.4 259.08,5.15 259.46,5.53 259.46,6.14 v1(259.05,6.54) ; R403.1 49.29,22.11 v1(48.97,21.78) ; v1(278.5,51.26) 278.84,51.6 278.91,51.6 279.61,52.3 D1451.1 ; v5(220.65,91) 221.04,90.6 221.04,90.37 221.43,89.98 PAD61710.1 ; v1(177.1,45.54) 177.2,45.63 179.24,45.63 v1(180.31,44.57) ; v1(212.39,64.81) 212.39,65.01 212.7,65.32 212.7,65.33 212.82,65.45 213.46,65.45 213.79,65.12 U1401.5 213.79,64.36 214.12,64.03 214.76,64.03 214.91,64.18 214.91,64.5 C1410.1 ; v1(262.25,31.21) 261.91,31.55 261.91,31.68 261.13,32.45 261.13,34.73 260.8,35.06 CN375.22 ; v1(206.5,116.89) 206.3,117.09 Q68120.2 205.87,116.39 205.87,114.46 Q68121.2 ; v1(45.84,23.59) 45.7,23.73 RS300.10 ; U7001.2 213.35,86.46 213.51,86.63 213.91,86.63 214.19,86.35 214.19,85.95 213.91,85.66 U7001.4 ; U302.5 242.69,52.46 R341.2 243.48,51.89 243.48,51.53 242.82,50.87 R303.2 242.64,50.64 242.46,50.46 242.24,50.46 241.83,50.04 v1(241.68,50.04) 241.2,49.56 240.54,49.56 R354.2 R322.2 ; 212.49,87.37 C7000.1 ; v1(187.63,104.38) 187.98,104.03 194.7,104.03 195.72,105.05 202.89,105.05 205.13,102.81 205.8,102.81 210.02,102.81 212.11,104.91 214.6,104.91 214.86,104.65 v1(214.86,103.44) 214.86,103.25 214.92,103.19 214.92,103.09 R1014.2 215.99,102.72 216.25,102.47 216.25,101.29 216.25,97.08 R7017.1 ; v1(238.91,5.68) 238.58,5.35 238.58,3.65 238.32,3.39 217.59,3.39 R445.1 ; R362.1 48.26,17.14 R372.2 49.26,17.47 v1(49.3,17.43) 49.34,17.47 C300.1 R343.1 ; R393.1 44.76,17.2 45.19,17.2 45.62,17.62 v1(45.74,17.62) 46.09,17.62 R389.2 R376.2 ; v1(202.29,51.62) 202.34,51.57 202.34,50.99 202.16,50.8 202.16,50.52 201.46,49.82 198.38,49.82 197.76,50.45 R1400.1 ; U4555.BT23 168.57,62.73 U4555.BR24 ; 51.51,35.14 C1309.1 50.19,35.54 R1342.1 ; v1(209.47,116.14) 209.47,115.94 Q68000.1 ; C7002.2 212.86,83.75 U7001.7 ; v1(247.75,42.43) 247.62,42.56 247.55,42.56 247.27,42.84 247.27,44.49 247.55,44.77 248.61,44.77 249.27,45.43 v1(249.27,45.51) ; CN4941.7 257.12,46.77 256.45,46.1 v1(255.99,46.1) 255.82,46.1 255.12,46.8 CN4941.3 ; v1(42.34,26.3) 42.48,26.44 RS300.5
  BOTTOM w0.508: v1(249.27,45.51) 249.27,54.27 249.73,54.73 258.49,54.73 259.05,54.17 ; v1(262.56,52.97) 259.64,52.97
  vias: v1(225.57,63.21) v1(226.39,63.21) v5(51.58,33.49) v5(52.35,33.49) v5(54.48,26.07) v5(55.24,26.07) v5(214.91,86.22) v5(215.29,86.88) v5(215.67,86.22) v5(216.05,86.88) v5(218.54,59.93) v5(224.89,63.11) v5(225.23,62.45) v5(225.97,62.46) v5(226.75,62.45)
