# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Library data of the parts (continued)
R1400 R1408 R1410 R1452 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet67
R1401 = RSC_0201: part number: RSC_0201-20K_5%_1,6013B0110499,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,20K,5%,1/20W,0201,TR; signal model: R2_6013B0110499_20K_5%_1; room: Sheet67
R1402 R1407 R1409 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet67
R1403 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet67
R1404 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet67
R1405 R1406 = RSC_0201: part number: RSC_0201-10_5%_1,6013B0110483,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10,5%,1/20W,0201,TR; signal model: R2_6013B0110483_10_5%_1; room: Sheet67
R1411 R1413 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet67
R1412 R1414 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet67
R1417 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet67
R1451 = RSC_0201: part number: RSC_0201-47K_5%_1,6013B0110484,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,47K,5%,1/20W,0201,TR; signal model: R2_6013B0110484_47K_5%_1; room: Sheet67
R1952 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet60
R1953 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet60
R1954 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet60
R2200 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet61
R2401 R2402 R2626 R2655-R2658 R2660 R2684 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet52
R2418 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet52
R2420 R2427 R2449 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet52
R2421-R2425 R2428 R2633 R2634 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet52
R2441 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet52
R2456 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet52
R2457 R2458 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet52
R2463 = RSC_0402: part number: RSC_0402-51K_1%_2,6013A0018501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51K-1%-1/16W-0402-TAP; signal model: R2_6013A0018501_51K_1%_2; room: Sheet52
R2464 = RSC_0402: part number: RSC_0402-357K_1%_2,6013A0088903,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-357K-1%-1/16-0402-TAP; signal model: R2_6013A0088903_357K_1%_2; room: Sheet52
R2465 = RSC_0402: part number: RSC_0402-76.8K_1%_2,6013B0104901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,76.8K,+/-1%,1/16W,0402,TR; signal model: R2_6013B0104901_76_8K_1%_2; room: Sheet52
R2466 = RSC_0402: part number: RSC_0402-127K_1%,6013A008870F,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-127K-1%-1/16-0402-TAP; signal model: R2_6013A008870F_127K_1%; room: Sheet52
R2469 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet52
R2500 = RSC_0402: part number: RSC_0402-17.8K_1%_2,6013A008840H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,17.8KOHM,1%,1/16W,0402,TAPMM; signal model: R2_6013A008840H_17_8K_1%_2; room: Sheet57
R2501 = RSC_0402: part number: RSC_0402-33.2K_1%_2,6013A0024701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0024701_33_2K_1%_2; room: Sheet57
R2502 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet57
R2503 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet57
R2600 R2621 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet54
R2601 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet54
R2602 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet54
R2603 = RSC_0402: part number: RSC_0402-14.3K_1%_2,6013A0088408,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-14.3K-1%-1/16W-0402-TAP; signal model: R2_6013A0088408_14_3K_1%_2; room: Sheet56
R2604 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet56
R2605 R2616 R2622 R2624 R2629-R2632 = RSC_0201: part number: RSC_0201-220K_1%_1,6013B0325301,RSC_060X030X026_2,0.41MM,RSC_0201,RESISTOR-CHIP,220K,1%,1/20W,0201,TR; signal model: R2_6013B0325301_220K_1%_1; room: Sheet55
R2606 = RSC_0402: part number: RSC_0402-300K_5%_2,60130B30400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-300K-5%-1/16W-0402-TAP; signal model: R2_60130B30400Y_300K_5%_2; room: Sheet54
R2607-R2609 R2623 R2640-R2643 = RSC_0201: part number: RSC_0201-220K_1%_1,6013B0325301,RSC_060X030X026_2,0.41MM,RSC_0201,RESISTOR-CHIP,220K,1%,1/20W,0201,TR; signal model: R2_6013B0325301_220K_1%_1; room: Sheet53
R2610 R2612 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet56
R2611 = RSC_0402: part number: RSC_0402-20K_1%_2,6013A0015301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_20K_1%_2; room: Sheet56
R2613 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet56
R2614 = RSC_0402: part number: RSC_0402-300K_5%_2,60130B30400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-300K-5%-1/16W-0402-TAP; signal model: R2_60130B30400Y_300K_5%_2; room: Sheet56
R2615 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet56
R2617 = RSC_0402: part number: RSC_0402-14.3K_1%_2,6013A0088408,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-14.3K-1%-1/16W-0402-TAP; signal model: R2_6013A0088408_14_3K_1%_2; room: Sheet54
R2618 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet56
R2619 = RSC_0402: part number: RSC_0402-20K_1%_2,6013A0015301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_20K_1%_2; room: Sheet54
R2620 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet54
R2625 R2669 R2671 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50_NSP,SHORT_0805_50_NSP,RSC_200X125X115_2_50_SHORT_NSP,0.0003MM,RSC_SHORT,SHORT_0805_50_NSP; signal model: R2_Short_0805_50_NSP_Short_0805_50_NSP; room: Sheet54
R2627 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet54
R2628 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet54
R2635 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet56
R2638 R2639 R2647 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50_NSP,SHORT_0805_50_NSP,RSC_200X125X115_2_50_SHORT_NSP,0.0003MM,RSC_SHORT,SHORT_0805_50_NSP; signal model: R2_Short_0805_50_NSP_Short_0805_50_NSP; room: Sheet56
R2700 = RSC_0201: part number: RSC_0201-100_1%_1,6013B0110426,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100,1%,1/20W,0201,TR; signal model: R2_6013B0110426_100_1%_1; room: Sheet50
R2701 R2706 R2731-R2741 R2749 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet50
R2702 R2704 R2742 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet50
R2703 R2705 R2759 R2761-R2764 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet50
R2708 = RSC_0201: part number: RSC_0201-3.01K_1%_1,6013B0272401,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,3.01K,1%,1/20W,0201,TR; signal model: R2_6013B0272401_3_01K_1%_1; room: Sheet50
R2709 R2722 R2727 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet50
R2710-R2712 R2726 R2728-R2730 R2743-R2746 R2760 R2775 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet50
R2713-R2720 R2765-R2772 = RSC_0201: part number: RSC_0201-2.2_1%_1,6013B0677001,RSC_060X030X026_2,0.36MM,RSC_0201,RESISTOR-CHIP,2.2,1%,1/20W,0201,TR; signal model: R2_6013B0677001_2_2_1%_1; room: Sheet50
R2721 R2723 = RSC_0201: part number: RSC_0201-200_1%_1,6013B0110413,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200,1%,1/20W,0201,TR; signal model: R2_6013B0110413_200_1%_1; room: Sheet50
R2724 R2725 = RSC_0201: part number: RSC_0201-2.2K_5%_1,6013B0110418,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,2.2K,5%,1/20W,0201,TR; signal model: R2_6013B0110418_2_2K_5%_1; room: Sheet50
R2747 R2748 = RSC_0201: part number: RSC_0201-47_5%_1,6013B0110456,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,47,5%,1/20W,0201,TR; signal model: R2_6013B0110456_47_5%_1; room: Sheet50
R2750 = RSC_0201: part number: RSC_0201-4.75K_0.5%_1,6013B0467101,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP-4.75K-0.5%-1/20W-0201-TAP; signal model: R2_6013B0467101_4_75K_0_5%_1; room: Sheet50
R2751 R2754 = RSC_0402: part number: RSC_0402-3.3K_5%_2,6013A0051001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.3K-5%-1/16W-0402-TAP; signal model: R2_6013A0051001_3_3K_5%_2; room: Sheet50
R2752 R2753 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet50
R2755 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet51
R2756 R2773 R2774 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet51
R2757 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet51
R2758 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet51
R3000 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet58
R3001 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet59
R3002 R3004 R3017 R3020 R3024 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet58
R3003 R3008 R3021 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet58
R3005 R3030 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet58
R3006 R4510 R4559 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet40
R3007 R3033 = RSC_0201: part number: RSC_0201-220K_5%_1,6013B0110434,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,220K,5%,1/20W,0201,TR; signal model: R2_6013B0110434_220K_5%_1; room: Sheet59
R3009 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet58
R3010 R3013 R4927 R4928 = RSC_0201: part number: RSC_0201-2.2K_5%_1,6013B0110418,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,2.2K,5%,1/20W,0201,TR; signal model: R2_6013B0110418_2_2K_5%_1; room: Sheet58
R3012 R3023 R3035 R3036 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet59
R3014 R3016 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet59
R3015 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet58
R3018 R4930 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet58
R3022 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet58
R3026 = RSC_0402: part number: RSC_0402-470K_5%_2,60130B47400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-5%-1/16W-0402-TAP; signal model: R2_60130B47400Z_470K_5%_2; room: Sheet58
R3027 R3028 R4554 R4555 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet36
R3029 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet58
R3031 = RSC_0402: part number: RSC_0402-150_1%_2,60130B15009Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-1%-1/16W-0402-TAP; signal model: R2_60130B15009Y_150_1%_2; room: Sheet58
R3034 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet59
R3150 R3151 = RSC_0402: part number: RSC_0402-2K_5%_2,60130B2020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-5%-1/16W-0402-TAP; signal model: R2_60130B2020ZT_2K_5%_2; room: Sheet49
R3300 R3301 R3303 R3305 R3309-R3312 R3319 R3320 R3322 R3323 R3339-R3342 R3355 R3356 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet48
R3302 R3304 R3306 R3307 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet48
R3308 R3314 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet48
R3324 = RSC_0402: part number: RSC_0402-5.1K_1%_2,6013A0082001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-5.1K-1%-1/16W-0402-TAP; signal model: R2_6013A0082001_5_1K_1%_2; room: Sheet48
R3501 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet65; signal model: R2_60130B0000ZT_DY_0_5%_2_DY
R3502 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet65; signal model: R2_60130B0000ZT_DY_0_5%_2_DY
R3503 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet65
R3504 R3505 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet65
R3516 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet65; signal model: R2_60130B0000ZT_DY_0_5%_2_DY
R3517 = RSC_0201: part number: RSC_0201-150K_1%,6013B0186701,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP,150K,1%,1/20W,0201,TR; signal model: R2_6013B0186701_150K_1%; room: Sheet65
R3541 R3542 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet65
R3543 = RSC_0201: part number: RSC_0201-51K_1%_1,6013B01104AA,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,51K,1%,1/20W,0201,TR; signal model: R2_6013B01104AA_51K_1%_1; room: Sheet65
R3800 R3801 R3813-R3820 R3823 = RSC_0201: part number: RSC_0201-20K_5%_1,6013B0110499,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,20K,5%,1/20W,0201,TR; signal model: R2_6013B0110499_20K_5%_1; room: Sheet73
R3802-R3811 R3822 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet73
R3824 R3827 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet73
R3825 R3826 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet73
R4100 R4101 R4103 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet46
R4106 R4122 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet46
R4111 R4136 = RSC_0402: part number: RSC_0402-24.9_1%_2,6013A008740P,RSC_100X050X035_2,0.5MM,RSC_0402,0402,RES-CHIP-24.9-1%-1/16W-0402-TAP; signal model: R2_6013A008740P_24_9_1%_2; room: Sheet38
R4112 R4503 = RSC_0402: part number: RSC_0402-2_1%_2,6013B0172801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2,1%,1/16W,0402,TR; signal model: R2_6013B0172801_2_1%_2; room: Sheet38
R4125 R4126 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet47
R4131 R4132 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet47
R4200 = RSC_0402: part number: RSC_0402-240_1%_2,6013B0072701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,240,1%,1/16W,0402,TR; signal model: R2_6013B0072701_240_1%_2; room: Sheet47
R4201 = RSC_0402: part number: RSC_0402-240_1%_2,6013B0072701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,240,1%,1/16W,0402,TR; signal model: R2_6013B0072701_240_1%_2; room: Sheet46
R4301 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet30
R4302 = RSC_0201: part number: RSC_0201-22_5%_1,6013B01104AH,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,22,5%,1/20W,0201,TR; signal model: R2_6013B01104AH_22_5%_1; room: Sheet30
R4303 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet30
R4350 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet68
R4352 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet68
R4353 = RSC_0201: part number: RSC_0201-1M_5%_1,6013B0110474,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1M,5%,1/20W,0201,TR; signal model: R2_6013B0110474_1M_5%_1; room: Sheet68
R4354 R4355 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet68
R4411 R4414 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet29
R4412 R4413 R4416 = RSC_0201: part number: RSC_0201-2.2K_5%_1,6013B0110418,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,2.2K,5%,1/20W,0201,TR; signal model: R2_6013B0110418_2_2K_5%_1; room: Sheet29
R4415 = RSC_0402: part number: RSC_0402-33K_1%_2,6013A0049501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33K-1%-1/16W-0402-TAP; signal model: R2_6013A0049501_33K_1%_2; room: Sheet29
R4417 = RSC_0402: part number: RSC_0402-150_1%_2,60130B15009Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-1%-1/16W-0402-TAP; signal model: R2_60130B15009Y_150_1%_2; room: Sheet29
R4460 R4538 R4620 R4621 R4761 R4762 R4803-R4805 R4811 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet36
R4500 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet33
R4501 R4612-R4615 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet31
R4502 R4823 R4888 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet31
R4504 R4505 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet39
R4507-R4509 R4589 R4886 R4891 = RSC_0402: part number: RSC_0402-51_5%_2,60130B5100ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_51_5%_2; room: Sheet33
R4511 R4552 R4808 R4946 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet34
R4512 R4571-R4578 R4748 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet39
R4513 R4532 R4546 R4551 R4869 R4901 R4903 R4910 = RSC_0201: part number: RSC_0201-33_5%_1,6013B0110459,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,33,5%,1/20W,0201,TR; signal model: R2_6013B0110459_33_5%_1; room: Sheet40
R4514 R4523 R4534 = RSC_0201: part number: RSC_0201-1K_1%_1,6013B0110482,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,1%,1/20W,0201,TR; signal model: R2_6013B0110482_1K_1%_1; room: Sheet41
R4515 = RSC_0402: part number: RSC_0402-499_1%_2,6013A0076801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-499-1%-1/16W-0402-TAP; signal model: R2_6013A0076801_499_1%_2; room: Sheet33
R4516 R4521 R4941 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet34
R4517 R4605 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet33
R4518 = RSC_0201: part number: RSC_0201-121_1%_1,6013B0282401,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,121,1%,1/20W,0201,TR; signal model: R2_6013B0282401_121_1%_1; room: Sheet38
R4519 R4566 R4597 = RSC_0201: part number: RSC_0201-49.9_1%_1,6013B0110432,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,49.9,1%,1/20W,0201,TR; signal model: R2_6013B0110432_49_9_1%_1; room: Sheet41
R4520 R4537 R4623 R4624 R4742 R4743 R4914 R4915 R4945 R4961 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet34
R4522 R4524 R4528-R4531 = RSC_0201: part number: RSC_0201-100_1%_1,6013B0110426,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100,1%,1/20W,0201,TR; signal model: R2_6013B0110426_100_1%_1; room: Sheet44
R4525 = RSC_0402: part number: RSC_0402-150K_5%_2,60130B15400T,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150K-5%-1/16W-0402-TAP; signal model: R2_60130B15400T_150K_5%_2; room: Sheet34
R4526 R4933 = RSC_0402: part number: RSC_0402-51_5%_2,60130B5100ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_51_5%_2; room: Sheet31
R4527 R4816 R4947 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet34
R4535 R4549 R4565 R4619 R4628 R4629 R4650 R4678 R4700 R4707 R4714 R4715 R4765 R4769 R4831 R4837 R4839 R4950 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet35
R4536 R4563 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet36
R4540 = RSC_0201: part number: RSC_0201-100_1%_1,6013B0110426,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100,1%,1/20W,0201,TR; signal model: R2_6013B0110426_100_1%_1; room: Sheet38
R4541 = RSC_0201: part number: RSC_0201-80.6_1%_1,6013B0110435,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,80.6,1%,1/20W,0201,TR; signal model: R2_6013B0110435_80_6_1%_1; room: Sheet38
R4542 = RSC_0201: part number: RSC_0201-200K_5%_1,6013B0110463,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200K,5%,1/20W,0201,TR; signal model: R2_6013B0110463_200K_5%_1; room: Sheet35
R4544 = RSC_0402: part number: RSC_0402-24.9_1%_2,6013A008740P,RSC_100X050X035_2,0.5MM,RSC_0402,0402,RES-CHIP-24.9-1%-1/16W-0402-TAP; signal model: R2_6013A008740P_24_9_1%_2; room: Sheet37
R4545 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet37
R4547 R4548 = RES: part number: RES-27,5%,6013B0171501,RSC_060X030X025_2,0.4MM,,RESISTOR-CHIP,27,+/-5%,1/20W,0201,TR; room: Sheet41
R4550 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet36
R4553 = RSC_0402: part number: RSC_0402-470_5%_2,60130B4710ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470-5%-1/16W-0402-TAP; signal model: R2_60130B4710ZT_470_5%_2; room: Sheet33
R4556 R4557 R4560 R4561 R4590 R4591 R4802 R4825 = RSC_0201: part number: RSC_0201-2.2K_5%_1,6013B0110418,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,2.2K,5%,1/20W,0201,TR; signal model: R2_6013B0110418_2_2K_5%_1; room: Sheet35
R4558 = RSC_0402: part number: RSC_0402-1.5K_5%_2,6013A0003101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1.5K-5%-1/16W-0402-TAP; signal model: R2_6013A0003101_1_5K_5%_2; room: Sheet41
R4564 R4806 R4842 R4851 R4858-R4860 R4863 R4864 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet34
R4567-R4570 R4592 R4611 = RSC_0201: part number: RSC_0201-4.7_5%_1,6013B0110403,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7,5%,1/20W,0201,TR; signal model: R2_6013B0110403_4_7_5%_1; room: Sheet34
R4579 R4582 R4702 R4733 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet34
R4580 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet36
R4583 R4585 R4609 R4610 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet42
R4584 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet35
R4587 R4588 = RSC_0201: part number: RSC_0201-49.9_1%_1,6013B0110432,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,49.9,1%,1/20W,0201,TR; signal model: R2_6013B0110432_49_9_1%_1; room: Sheet33
R4593 R4598 = RSC_0201: part number: RSC_0201-100_1%_1,6013B0110426,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100,1%,1/20W,0201,TR; signal model: R2_6013B0110426_100_1%_1; room: Sheet43
R4594 = RSC_0402: part number: RSC_0402-56_5%_2,60130B5600ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-56-5%-1/16W-0402-TAP; signal model: R2_60130B5600ZT_56_5%_2; room: Sheet43
R4595 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet43
R4596 = RSC_0402: part number: RSC_0402-220_1%_2,60130B22009T,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,220,1%,1/16W,0402,TR; signal model: R2_60130B22009T_220_1%_2; room: Sheet43
R4603 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet40
R4604 = RSC_0402: part number: RSC_0402-49.9_1%_2,6013A0076901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9-1%-1/16W-0402-TAP; signal model: R2_6013A0076901_49_9_1%_2; room: Sheet33
R4606 = RSC_0402: part number: RSC_0402-330_1%_2,60130B33009Z,RSC_100X050X035_2,0.45MM,RSC_0402,0402,RES-CHIP-330-1%-1/16W-0402-TAP; signal model: R2_60130B33009Z_330_1%_2; room: Sheet33
R4608 = RSC_0201: part number: RSC_0201-100_1%_1,6013B0110426,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100,1%,1/20W,0201,TR; signal model: R2_6013B0110426_100_1%_1; room: Sheet39
R4622 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet40
R4625 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet35
R4626 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet34
R4705 R4711 R4718 R4721 R4725 R4798 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet41
R4708 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet33
R4713 = RSC_0201: part number: RSC_0201-20K_5%_1,6013B0110499,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,20K,5%,1/20W,0201,TR; signal model: R2_6013B0110499_20K_5%_1; room: Sheet34
R4717 R4734 R4744 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet34
R4722 = RSC_0402: part number: RSC_0402-60.4_1%_2,6013A0077001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-60.4-1%-1/16W-0402-TAP; signal model: R2_6013A0077001_60_4_1%_2; room: Sheet34
R4729 = RSC_0201: part number: RSC_0201-200K_5%_1,6013B0110463,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200K,5%,1/20W,0201,TR; signal model: R2_6013B0110463_200K_5%_1; room: Sheet33
R4739 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet34
R4749 R4899 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet40
R4756 = RSC_0201: part number: RSC_0201-113_1%_1,6013B01104BM,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP-113_1%_1/20W-0201-TAP; signal model: R2_6013B01104BM_113_1%_1; room: Sheet39
R4758 R4759 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet37
R4782 = RSC_0201: part number: RSC_0201-1M_5%_1,6013B0110474,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1M,5%,1/20W,0201,TR; signal model: R2_6013B0110474_1M_5%_1; room: Sheet37
R4786 R4787 R4854 R4870 = RSC_0201: part number: RSC_0201-2.2K_5%_1,6013B0110418,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,2.2K,5%,1/20W,0201,TR; signal model: R2_6013B0110418_2_2K_5%_1; room: Sheet37
R4792 R4827 R4828 R4830 R4856 R4913 = RSC_0201: part number: RSC_0201-2.2K_5%_1,6013B0110418,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,2.2K,5%,1/20W,0201,TR; signal model: R2_6013B0110418_2_2K_5%_1; room: Sheet34
R4797 R4884 = RSC_0201: part number: RSC_0201-499_1%_1,6013B0277901,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,499,1%,1/20W,0201,TR; signal model: R2_6013B0277901_499_1%_1; room: Sheet34
R4800 R4821 R4855 R7026 R7112 R7113 R7119 R7124 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet24
R4807 R4920 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet33
R4812 = RSC_0201: part number: RSC_0201-200_1%_1,6013B0110413,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200,1%,1/20W,0201,TR; signal model: R2_6013B0110413_200_1%_1; room: Sheet36
R4819 = RSC_0201: part number: RSC_0201-200_1%_1,6013B0110413,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200,1%,1/20W,0201,TR; signal model: R2_6013B0110413_200_1%_1; room: Sheet40
R4822 R4922 R4926 R4932 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet31
R4832 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet41
R4834 R4845 = RSC_0201: part number: RSC_0201-27K_5%_1,6013B0173501,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,27K,5%,1/20W,0201,TR; signal model: R2_6013B0173501_27K_5%_1; room: Sheet41
R4835 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet34
R4846-R4849 = RSC_0201: part number: RSC_0201-15_5%_1,6013B0395401,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,15,5%,1/20W,0201,TR; signal model: R2_6013B0395401_15_5%_1; room: Sheet34
R4850 = RSC_0201: part number: RSC_0201-33_5%_1,6013B0110459,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,33,5%,1/20W,0201,TR; signal model: R2_6013B0110459_33_5%_1; room: Sheet34
R4861 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet40
R4862 = RSC_0201: part number: RSC_0201-10M_5%_1,6013B0110473,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10M,5%,1/20W,0201,TR; signal model: R2_6013B0110473_10M_5%_1; room: Sheet41
R4865 R4866 = RSC_0201: part number: RSC_0201-49.9K_1%_1,6013B01104BG,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,49.9K,1%,1/20W,0201,TR; signal model: R2_6013B01104BG_49_9K_1%_1; room: Sheet32
R4889 R4890 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet42
R4893 = RSC_0201: part number: RSC_0201-60.4_1%_1,6013B0498201,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,60.4_1%,1/20W,0201,TR; signal model: R2_6013B0498201_60_4_1%_1; room: Sheet41
R4898 = RSC_0201: part number: RSC_0201-200K_1%_1,6013B0110466,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200K,1%,1/20W,0201,TR; signal model: R2_6013B0110466_200K_1%_1; room: Sheet41
R4900 = RSC_0402: part number: RSC_0402-150_1%_2,60130B15009Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-1%-1/16W-0402-TAP; signal model: R2_60130B15009Y_150_1%_2; room: Sheet36
R4921 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15_NSP,SHORT_0402_15_NSP,RSC_100X050X040_2_15_NSP_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15_NSP; signal model: R2_short_0402_15_nsp_short_0402_15_nsp; room: Sheet31
R4924 = RSC_0201: part number: RSC_0201-10K_5%_1_NP,6013B0110476_NP,RSC_060X030X030_2_NP,0.0003MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_NP_10K_5%_1_NP; room: Sheet31
R4925 = RSC_0201: part number: RSC_0201-100K_5%_1_NP,6013B0110475_NP,RSC_060X030X030_2_NP,0.0003MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_NP_100K_5%_1_NP; room: Sheet31
R4929 R4931 = RSC_0402: part number: RSC_0402-1.5K_5%_2,6013A0003101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1.5K-5%-1/16W-0402-TAP; signal model: R2_6013A0003101_1_5K_5%_2; room: Sheet31
R4934 = RSC_0201: part number: RSC_0201-1K_5%_1_NP,6013B0110477_NP,RSC_060X030X030_2_NP,0.0003MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_NP_1K_5%_1_NP; room: Sheet31
R4936 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet34; signal model: R2_60130B0000ZT_DY_0_5%_2_DY
R4940 = RSC_0402: part number: RSC_0402-150_5%_2,60130B15100Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-5%-1/16W-0402-TAP; signal model: R2_60130B15100Y_150_5%_2; room: Sheet31
R4970 = RSC_0402: part number: RSC_0402-75K_1%_2,6013A008860M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75K-1%-1/16W-0402-TAP; signal model: R2_6013A008860M_75K_1%_2; room: Sheet40
R6050 R6051 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet25
R6052 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet25
R7000 = RSC_0201: part number: RSC_0201-10_5%_1,6013B0110483,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10,5%,1/20W,0201,TR; signal model: R2_6013B0110483_10_5%_1; room: Sheet27
R7001 R7014 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet26
R7002 R7006 R7155 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet27
R7003 = RSC_0201: part number: RSC_0201-20K_5%_1,6013B0110499,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,20K,5%,1/20W,0201,TR; signal model: R2_6013B0110499_20K_5%_1; room: Sheet27
R7004 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet27
R7005 R7019 = RSC_0201: part number: RSC_0201-200K_5%_1,6013B0110463,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200K,5%,1/20W,0201,TR; signal model: R2_6013B0110463_200K_5%_1; room: Sheet26
R7007 R7008 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet26
R7009 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet26
R7010 R7017 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet27
R7011 R7012 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet26
R7013 = RSC_0603: part number: RSC_0603-100_5%_3,60130B10100Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-100-5%-1/10W-0603-TAP; signal model: R2_60130B10100Z_100_5%_3; room: Sheet27
R7015 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet26
R7016 R7020 R7023 R7024 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet26
R7018 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet26
R7025 R7424 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet24
R7028 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet27
R7029 R7039 = RSC_0402: part number: RSC_0402-470K_5%_2,60130B47400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-5%-1/16W-0402-TAP; signal model: R2_60130B47400Z_470K_5%_2; room: Sheet26
R7038 = RSC_0402: part number: RSC_0402-22_5%_2,60130B2200ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22-5%-1/16W-0402-TAP; signal model: R2_60130B2200ZT_22_5%_2; room: Sheet27
R7040 = RSC_0402: part number: RSC_0402-330K_5%_2,60130B33400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330K-5%-1/16W-0402-TAP; signal model: R2_60130B33400Z_330K_5%_2; room: Sheet26
R7156 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet27
R7301 R7303 R7313 = RSC_0201: part number: RSC_0201-220K_5%_1,6013B0110434,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,220K,5%,1/20W,0201,TR; signal model: R2_6013B0110434_220K_5%_1; room: Sheet27
R7304 R7306 R7311 = RSC_0201: part number: RSC_0201-110K_5%_1,6013B0497701,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,110K_5%,1/20W,0201,TR; signal model: R2_6013B0497701_110k_5%_1; room: Sheet27
R7401 R7418 = RSC_0201: part number: RSC_0201-18.7K_1%_1,6013B0498301,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP,18.7K_1%,1/20W,0201,TR; signal model: R2_6013B0498301_18_7K_1%_1; room: Sheet28
R7404 R7427 = RSC_0201: part number: RSC_0201-20K_5%_1,6013B0110499,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,20K,5%,1/20W,0201,TR; signal model: R2_6013B0110499_20K_5%_1; room: Sheet28
R7405 = RSC_0201: part number: RSC_0201-115K_1%_1,6013B0497901,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,115K_1%,1/20W,0201,TR; signal model: R2_6013B0497901_115K_1%_1; room: Sheet28
R7406 R7407 = RSC_0201: part number: RSC_0201-1M_5%_1,6013B0110474,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1M,5%,1/20W,0201,TR; signal model: R2_6013B0110474_1M_5%_1; room: Sheet28
R7408 R7409 R7422 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet28
R7410 = RSC_0201: part number: RSC_0201-57.6K_1%_1,6013B0498501,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP,57.6K_1%,1/20W,0201,TR; signal model: R2_6013B0498501_57_6K_1%_1; room: Sheet28
R7411 = RSC_0201: part number: RSC_0201-76.8K_1%_1,6013B0486501,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP,76.8K,1%,1/20W,0201,TR; signal model: R2_6013B0486501_76_8K_1%_1; room: Sheet28
R7412 = RSC_0201: part number: RSC_0201-31.6K_1%_1,6013B0253401,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,31.6K,1%,1/20W,0201,TR; signal model: R2_6013B0253401_31_6K_1%_1; room: Sheet28
R7413 = RSC_0201: part number: RSC_0201-41.2K_1%_1,6013B01104AC,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,41.2K,1%,1/20W,0201,TR; signal model: R2_6013B01104AC_41_2K_1%_1; room: Sheet28
R7414 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet28
R7415 R7416 = RSC_0201: part number: RSC_0201-3.3K_5%_1,6013B0154401,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP-3.3K_5%_1-1/20W-0201-TAP; signal model: R2_6013B0154401_3_3K_5%_1; room: Sheet28
R7420 R7429 = RSC_0201: part number: RSC_0201-3.3K_1%_1,6013B0325201,RSC_060X030X026_2,0.41MM,RSC_0201,RESISTOR-CHIP,3.3K,1%,1/20W,0201,TR; signal model: R2_6013B0325201_3_3K_1%_1; room: Sheet28
R7425 = RSC_0201: part number: RSC_0201-49.9K_1%_1,6013B01104BG,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,49.9K,1%,1/20W,0201,TR; signal model: R2_6013B01104BG_49_9K_1%_1; room: Sheet28
R7428 = RSC_0201: part number: RSC_0201-27K_1%_1,6013B0110494,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,27K,1%,1/20W,0201,TR; signal model: R2_6013B0110494_27K_1%_1; room: Sheet28
R7500 = RSC_0805: part number: RSC_0805-0_5%_5,60130BA0003T,RSC_200X125X060_2,0.7MM,RSC_0805,0805,RES-CHIP-0-5%-1/8W-0805-TAP; signal model: R2_60130BA0003T_0_5%_5; room: Sheet66
R7600 = RSC_0201: part number: RSC_0201-33_5%_1,6013B0110459,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,33,5%,1/20W,0201,TR; signal model: R2_6013B0110459_33_5%_1; room: Sheet76
R9200 R9201 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet82
R9202 = RSC_0402: part number: RSC_0402-4.99K_1%_2,6013A0015201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.99K-1%-1/16W-0402-TAP; signal model: R2_6013A0015201_4_99K_1%_2; room: Sheet80
R9203 R9207 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet80
R9204 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet80
