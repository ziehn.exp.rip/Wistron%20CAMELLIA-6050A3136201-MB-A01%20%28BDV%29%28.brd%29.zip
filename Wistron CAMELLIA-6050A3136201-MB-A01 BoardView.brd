# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R4886  51_5%_2  [RSC_100X050X040_2]  136.06 85.4 90 bottom
R4888  0_5%_2  [RSC_100X050X040_2]  125.4 69.43 180 top
R4889  0_5%_1  [RSC_060X030X030_2]  183.16 41.47 0 top
R4890  0_5%_1  [RSC_060X030X030_2]  183.16 42.1 0 top
R4891  51_5%_2  [RSC_100X050X040_2]  138.73 85.4 90 bottom
R4893  60.4_1%_1  [RSC_060X030X030_2]  179.09 84.65 90 bottom
R4898  200K_1%_1  [RSC_060X030X030_2]  188.04 75.62 270 bottom
R4899  10K_5%_1  [RSC_060X030X030_2]  39.52 36.77 0 bottom
R4900  150_1%_2  [RSC_100X050X040_2]  187.09 56.45 180 bottom
R4901  33_5%_1  [RSC_060X030X030_2]  173.25 44 90 top
R4903  33_5%_1  [RSC_060X030X030_2]  173.89 44 90 top
R4905  20K_5%_1  [RSC_060X030X030_2]  59.81 22.34 180 bottom
R4908  20K_5%_1  [RSC_060X030X030_2]  59.97 24.37 270 bottom
R4910  33_5%_1  [RSC_060X030X030_2]  174.74 43.65 270 top
R4913  2.2K_5%_1  [RSC_060X030X030_2]  220.8 38.55 0 top
R4914  100K_5%_1  [RSC_060X030X030_2]  186 60.52 90 top
R4915  100K_5%_1  [RSC_060X030X030_2]  186.61 60.52 90 top
R4918  100K_5%_1  [RSC_060X030X030_2]  185.24 62.62 90 top
R4920  100_5%_2  [RSC_100X050X040_2]  140.5 85.4 270 bottom
R4921  short_0402_15_nsp  [RSC_100X050X040_2_15_NSP_SHORT]  104.92 40.2 270 top
R4922  1K_5%_2  [RSC_100X050X040_2]  113.71 73.59 0 top
R4924  10K_5%_1_NP  [RSC_060X030X030_2_NP]  106.83 42.86 270 top
R4925  100K_5%_1_NP  [RSC_060X030X030_2_NP]  107.97 45.02 270 top
R4926  1K_5%_2  [RSC_100X050X040_2]  125.77 68.51 180 top
R4927  2.2K_5%_1  [RSC_060X030X030_2]  23.9 16.14 180 top
R4928  2.2K_5%_1  [RSC_060X030X030_2]  23.98 13.54 0 top
R4929  1.5K_5%_2  [RSC_100X050X040_2]  191.16 41.85 90 top
R4930  10K_5%_1  [RSC_060X030X030_2]  22.63 12.64 90 top
R4931  1.5K_5%_2  [RSC_100X050X040_2]  126.15 72.77 270 top
R4932  1K_5%_2  [RSC_100X050X040_2]  125.88 60.64 180 top
R4933  51_5%_2  [RSC_100X050X040_2]  125.88 61.53 180 top
R4934  1K_5%_1_NP  [RSC_060X030X030_2_NP]  106.83 44.13 270 top
R4936  short_0201_5  [RSC_060X030X030_2_5_SHORT]  170.08 42.18 90 top
R4940  150_5%_2  [RSC_100X050X040_2]  125.32 71.21 0 top
R4941  0_5%_1  [RSC_060X030X030_2]  195.6 47.03 0 top
R4945  100K_5%_1  [RSC_060X030X030_2]  170.08 44.13 270 top
R4946  short_0201_5  [RSC_060X030X030_2_5_SHORT]  199.67 47.69 90 top
R4947  10K_5%_2  [RSC_100X050X040_2]  197.51 48.71 180 top
R4950  10K_5%_1  [RSC_060X030X030_2]  196.49 51.65 180 top
R4961  100K_5%_1  [RSC_060X030X030_2]  196.49 54.93 180 top
R4970  75K_1%_2  [RSC_100X050X040_2]  190.01 60.14 270 top
R6050  100_5%_2  [RSC_100X050X040_2]  86.97 29.63 270 bottom
R6051  100_5%_2  [RSC_100X050X040_2]  86.08 29.63 270 bottom
R6052  1K_5%_2  [RSC_100X050X040_2]  80.58 26.45 270 bottom
R7000  10_5%_1  [RSC_060X030X030_2]  216.03 94.99 270 bottom
R7001  100_5%_2  [RSC_100X050X040_2]  217.57 91 90 top
R7002  short_0402_15  [RSC_100X050X040_2_15_SHORT]  199.97 69.18 180 bottom
R7003  20K_5%_1  [RSC_060X030X030_2]  200.91 65.57 270 bottom
R7004  10K_5%_1  [RSC_060X030X030_2]  201.55 65.06 90 bottom
R7005  200K_5%_1  [RSC_060X030X030_2]  212.04 79.77 90 bottom
R7006  short_0402_15  [RSC_100X050X040_2_15_SHORT]  158.9 96.97 180 bottom
R7007  100K_5%_1  [RSC_060X030X030_2]  100.48 57.47 270 bottom
R7008  100K_5%_1  [RSC_060X030X030_2]  101.09 57.47 270 bottom
R7009  10K_5%_2  [RSC_100X050X040_2]  200.94 88.58 90 bottom
R7010  100K_5%_1  [RSC_060X030X030_2]  159.28 98.67 90 bottom
R7011  short_0805_50  [RSC_200X125X115_2_50_SHORT]  207.57 87.07 180 bottom
R7012  short_0805_50  [RSC_200X125X115_2_50_SHORT]  208.81 82.74 180 bottom
R7013  100_5%_3  [RSC_160X080X055_2]  160.17 95.19 270 bottom
R7014  100_5%_2  [RSC_100X050X040_2]  197.13 94.25 0 bottom
R7015  20K_5%_2  [RSC_100X050X040_2]  196.52 90.06 0 bottom
R7016  short_0402_15  [RSC_100X050X040_2_15_SHORT]  215.8 84.52 90 top
R7017  100K_5%_1  [RSC_060X030X030_2]  216.03 96.62 270 bottom
R7018  0_5%_2  [RSC_100X050X040_2]  212.19 82.49 180 bottom
R7019  200K_5%_1  [RSC_060X030X030_2]  214.02 77.61 270 top
R7020  short_0402_15  [RSC_100X050X040_2_15_SHORT]  211.78 81.6 180 bottom
R7023  short_0402_15  [RSC_100X050X040_2_15_SHORT]  196.77 95.52 270 bottom
R7024  short_0402_15  [RSC_100X050X040_2_15_SHORT]  214.47 84.42 180 top
R7025  10K_5%_2  [RSC_100X050X040_2]  183.89 96.26 180 bottom
R7026  short_0402_15  [RSC_100X050X040_2_15_SHORT]  167.66 103.7 270 bottom
R7028  short_0201_10  [RSC_060X030X030_2_10_SHORT]  212.98 78.04 270 bottom
R7029  470K_5%_2  [RSC_100X050X040_2]  213.01 91.39 270 bottom
R7038  22_5%_2  [RSC_100X050X040_2]  208.86 75.38 90 bottom
R7039  470K_5%_2  [RSC_100X050X040_2]  210.08 89.09 180 bottom
R7040  330K_5%_2  [RSC_100X050X040_2]  210.08 89.98 180 bottom
R7112  short_0402_15  [RSC_100X050X040_2_15_SHORT]  224.3 82.49 0 bottom
R7113  short_0402_15  [RSC_100X050X040_2_15_SHORT]  195.5 99.99 270 bottom
R7119  short_0402_15  [RSC_100X050X040_2_15_SHORT]  155.85 2.73 90 bottom
R7124  short_0402_15  [RSC_100X050X040_2_15_SHORT]  222.15 92.39 270 bottom
R7155  short_0402_15  [RSC_100X050X040_2_15_SHORT]  181.76 95.19 180 bottom
R7156  0_5%_2  [RSC_100X050X040_2]  183.41 95.19 0 bottom
R7301  220K_5%_1  [RSC_060X030X030_2]  158.21 89.09 270 bottom
R7303  220K_5%_1  [RSC_060X030X030_2]  212.35 77.79 90 bottom
R7304  110k_5%_1  [RSC_060X030X030_2]  198.52 69.28 90 bottom
R7306  110k_5%_1  [RSC_060X030X030_2]  197.79 68.8 90 bottom
R7311  110k_5%_1  [RSC_060X030X030_2]  159.1 87.42 180 bottom
R7313  220K_5%_1  [RSC_060X030X030_2]  209.39 76.77 90 bottom
R7401  18.7K_1%_1  [RSC_060X030X026_2]  216.3 73.85 0 bottom
R7404  20K_5%_1  [RSC_060X030X030_2]  209.06 71.62 0 bottom
R7405  115K_1%_1  [RSC_060X030X030_2]  203.35 99.38 0 bottom
R7406  1M_5%_1  [RSC_060X030X030_2]  215.97 72.96 270 bottom
R7407  1M_5%_1  [RSC_060X030X030_2]  209.5 72.23 180 bottom
R7408  10K_5%_1  [RSC_060X030X030_2]  216.82 73.19 180 bottom
R7409  10K_5%_1  [RSC_060X030X030_2]  209.5 72.84 0 bottom
R7410  57.6K_1%_1  [RSC_060X030X026_2]  213.1 74.56 180 bottom
R7411  76.8K_1%_1  [RSC_060X030X026_2]  208.63 72.48 90 bottom
R7412  31.6K_1%_1  [RSC_060X030X030_2]  211.63 74.82 270 bottom
R7413  41.2K_1%_1  [RSC_060X030X030_2]  207.36 73.14 270 bottom
R7414  1K_5%_1  [RSC_060X030X030_2]  213.13 68.77 180 bottom
R7415  3.3K_5%_1  [RSC_060X030X026_2]  213.13 69.41 180 bottom
R7416  3.3K_5%_1  [RSC_060X030X026_2]  207.97 72.48 90 bottom
R7418  18.7K_1%_1  [RSC_060X030X026_2]  208.63 73.6 90 bottom
R7420  3.3K_1%_1  [RSC_060X030X026_2]  216.3 75.63 270 bottom
R7422  10K_5%_1  [RSC_060X030X030_2]  101.06 50.81 90 bottom
R7424  10K_5%_2  [RSC_100X050X040_2]  167.66 105.35 90 bottom
R7425  49.9K_1%_1  [RSC_060X030X030_2]  216.81 72.33 90 bottom
R7427  20K_5%_1  [RSC_060X030X030_2]  216.18 71.82 90 bottom
R7428  27K_1%_1  [RSC_060X030X030_2]  217.45 72.33 90 bottom
R7429  3.3K_1%_1  [RSC_060X030X026_2]  216.94 75.63 270 bottom
R7500  0_5%_5  [RSC_200X125X060_2]  54.89 35.37 0 bottom
R7600  33_5%_1  [RSC_060X030X030_2]  24.56 34.38 270 top
R9200  short_0402_15  [RSC_100X050X040_2_15_SHORT]  32.03 73.88 270 top
R9201  short_0402_15  [RSC_100X050X040_2_15_SHORT]  30.76 72.71 180 top
R9202  4.99K_1%_2  [RSC_100X050X040_2]  42.69 102.3 90 top
R9203  0_5%_2  [RSC_100X050X040_2]  43.58 102.3 90 top
R9204  4.7K_5%_1  [RSC_060X030X030_2]  42.57 100.14 180 top
R9205  4.7K_5%_2  [RSC_100X050X040_2]  48.03 81.35 180 top
R9207  0_5%_2  [RSC_100X050X040_2]  35.58 97.78 180 top
R9208  4.7K_5%_2  [RSC_100X050X040_2]  35.58 99.89 0 top
R9210  4.7K_5%_2  [RSC_100X050X040_2]  35.58 98.74 0 top
R9211  4.7K_5%_2  [RSC_100X050X040_2]  43.2 97.6 180 top
R9212  4.7K_5%_2  [RSC_100X050X040_2]  43.2 98.49 180 top
R9213  4.7K_5%_2  [RSC_100X050X040_2]  43.2 99.38 180 top
R9214  4.7K_5%_2  [RSC_100X050X040_2]  43.58 100.65 90 top
R9215  4.7K_5%_2  [RSC_100X050X040_2]  42.44 96.71 0 top
R9217  short_0603_25  [RSC_160X080X080_2_25_SHORT]  28.62 73.88 0 top
R9219  4.99K_1%_2  [RSC_100X050X040_2]  44.98 82.74 0 top
R9220  0_5%_2  [RSC_100X050X040_2]  46.38 81.85 0 top
R9221  4.7K_5%_2  [RSC_100X050X040_2]  37.49 79.82 0 top
R9222  4.7K_5%_2  [RSC_100X050X040_2]  37.49 78.93 0 top
R9223  4.7K_5%_2  [RSC_100X050X040_2]  37.16 80.71 0 top
R9224  0_5%_2  [RSC_100X050X040_2]  37.49 78.04 180 top
R9225  4.7K_5%_2  [RSC_100X050X040_2]  45.02 79 270 top
R9226  4.7K_5%_2  [RSC_100X050X040_2]  46.03 79 90 top
R9227  4.7K_5%_2  [RSC_100X050X040_2]  47 79.01 90 top
R9228  4.7K_5%_2  [RSC_100X050X040_2]  46.38 80.71 180 top
R9229  4.7K_5%_2  [RSC_100X050X040_2]  48 82.23 180 top
R9230  30_5%_2  [RSC_100X050X040_2]  34.21 74.11 180 top
R9231  30_5%_2  [RSC_100X050X040_2]  33.3 73.22 180 top
R9300  0_5%_1  [RSC_060X030X030_2]  77.14 107.69 0 top
R9301  0_5%_1  [RSC_060X030X030_2]  77.14 107.08 0 top
R9302  0_5%_1  [RSC_060X030X030_2]  77.75 105.15 270 top
R9303  0_5%_1  [RSC_060X030X030_2]  77.14 105.15 270 top
R9304  0_5%_1_NSP  [RSC_060X030X030_2_NSP]  74.19 78.45 0 top
R9305  0_5%_1  [RSC_060X030X030_2]  75.34 78.45 180 top
R9350  10K_5%_2  [RSC_100X050X040_2]  59.97 111.32 180 top
R9352  10K_5%_2  [RSC_100X050X040_2]  59.97 63.82 0 top
R60000  0.01_1%_6  [RSC_320X160X089_4_P2]  184.68 106.36 180 bottom
R60001  0.005_1%_6  [RSC_320X160X085_4]  116.48 112.21 180 bottom
R60002  200K_5%_2  [RSC_100X050X040_2]  177.57 111.06 90 top
R60003  4.7_5%_3  [REBORN-60130B4R700T-002]  183.03 109.16 270 top
R60004  RSC_0402  [RSC_100X050X040_2]  184.78 107.48 180 top
R60005  10_1%_3  [RSC_160X080X080_2]  190.29 112.54 270 top
R60009  10_5%_5  [RSC_200X125X060_2]  202.08 111.57 180 bottom
R60011  short_0402_15  [RSC_100X050X040_2_15_SHORT]  193.44 98.87 270 top
R60012  10K_5%_2  [RSC_100X050X040_2]  188.62 103.95 0 top
R60013  0_5%_2  [RSC_100X050X040_2]  195.6 98.87 180 top
R60014  2.74K_1%_2  [RSC_100X050X035_2]  186.43 106.24 0 top
R60015  0_5%_3  [RSC_160X080X055_2]  193.57 111.95 270 top
R60016  RSC_0603  [RSC_160X080X080_2]  173.1 115.79 180 bottom
R60017  100K_5%_2  [RSC_100X050X040_2]  184.83 106.59 180 top
R60018  short_0402_15  [RSC_100X050X040_2_15_SHORT]  197.76 113.63 180 top
R60019  short_0402_15  [RSC_100X050X040_2_15_SHORT]  81.18 24.98 180 bottom
R60020  2.2_5%_2  [RSC_100X050X040_2]  200.81 112.71 90 top
R60021  10K_5%_2  [RSC_100X050X040_2]  188.62 104.84 0 top
R60022  6.04K_1%_1/16W_2  [RSC_100X050X040_2]  194.33 98.87 270 top
R60024  1K_5%_2  [RSC_100X050X040_2]  192.2 98.46 180 top
R60025  0_5%_3  [RSC_160X080X055_2]  197.33 109.01 180 top
R60026  RSC_0603  [RSC_160X080X080_2]  160.17 116.4 0 top
R60027  1K_5%_2  [RSC_100X050X040_2]  187.52 101.28 0 top
R60028  short_0402_15  [RSC_100X050X040_2_15_SHORT]  184.93 108.78 270 top
R60032  100K_5%_2  [RSC_100X050X040_2]  244.62 97.58 90 top
R60038  short_0402_15  [RSC_100X050X040_2_15_SHORT]  187.98 113.63 180 top
R60039  2.2_5%_2  [RSC_100X050X040_2]  187.98 112.74 180 top
R60045  220K_5%_2  [RSC_100X050X040_2]  246.4 97.58 270 top
R60048  4.7_5%_6  [RSC_320X160X145_2]  238.55 81.31 0 bottom
R60050  20K_5%_2  [RSC_100X050X040_2]  253.83 98.93 0 top
R60051  100K_5%_2  [RSC_100X050X040_2]  190.67 108.85 0 bottom
R60052  20K_5%_2  [RSC_100X050X040_2]  184.68 114.49 90 top
R60053  100K_5%_2  [RSC_100X050X040_2]  258.21 99.27 270 top
R60054  100K_5%_2  [RSC_100X050X040_2]  181.25 110.73 0 top
R60061  10K_5%_2  [RSC_100X050X040_2]  254.59 97.95 0 top
R60092  10_1%_3  [RSC_160X080X080_2]  191.44 112.54 90 top
R60094  0_5%_2  [RSC_100X050X040_2]  192.48 112.18 90 top
R60110  RSC_0402  [RSC_100X050X040_2]  224.3 81.6 0 bottom
R60115  3.3_5%_3  [RSC_160X080X055_2]  224.3 78.93 180 bottom
R60116  RSC_0603  [RSC_160X080X080_2]  231.39 77.21 270 bottom
R60199  short_0402_15  [RSC_100X050X040_2_15_SHORT]  222.98 80.3 270 bottom
R60200  RSC_0402  [RSC_100X050X040_2]  242.64 76.57 90 bottom
R60201  RSC_0402  [RSC_100X050X040_2]  241.8 75.33 180 bottom
R60202  short_0402_15  [RSC_100X050X040_2_15_SHORT]  231.54 73.47 270 bottom
R60204  RSC_0402  [RSC_100X050X040_2]  232.43 73.47 270 bottom
R60205  short_0402_5  [RSC_100X050X040_2_SHORT]  240.51 76.7 180 bottom
R60206  1M_5%_2  [RSC_100X050X040_2]  231.54 71.87 270 bottom
R60215  0_5%_3  [RSC_160X080X055_2]  234.62 72.76 180 bottom
R60216  RSC_0603  [RSC_160X080X080_2]  234.97 70.93 270 bottom
R60217  short_0402_15  [RSC_100X050X040_2_15_SHORT]  241.8 74.44 0 bottom
R60218  1K_5%_2  [RSC_100X050X040_2]  242.19 77.84 0 bottom
R60253  short_0402_15  [RSC_100X050X040_2_15_SHORT]  194.07 97.86 0 bottom
R60254  short_0402_5  [RSC_100X050X040_2_SHORT]  193.32 99.99 90 bottom
R60255  1M_5%_2  [RSC_100X050X040_2]  196.39 99.99 270 bottom
R60265  0_5%_3  [RSC_160X080X055_2]  186 97.35 180 bottom
R60266  RSC_0603  [RSC_160X080X080_2]  184.43 93.28 270 bottom
R60289  1K_5%_2  [RSC_100X050X040_2]  195.32 98.36 270 bottom
R60300  10.2K_1%_2  [RSC_100X050X040_2]  159.01 2.57 0 bottom
R60301  10K_1%_2  [RSC_100X050X040_2]  158.39 3.46 0 bottom
R60302  short_0402_5  [RSC_100X050X040_2_SHORT]  157.63 2.1 90 bottom
R60315  0_5%_3  [RSC_160X080X055_2]  160.55 3.37 270 bottom
R60316  RSC_0603  [RSC_160X080X080_2]  163.99 8.21 0 bottom
R60346  short_0402_5  [RSC_100X050X040_2_SHORT]  156.74 2.1 90 bottom
R60349  short_0402_15  [RSC_100X050X040_2_15_SHORT]  156.36 9.84 90 top
R60400  324K_1%_2  [RSC_100X050X040_2]  195.27 7.69 270 bottom
R60401  100K_1%_2  [RSC_100X050X040_2]  193.49 7.69 90 bottom
R60505  RSC_0402  [RSC_100X050X040_2]  103.98 50.13 0 bottom
R60506  2.2_5%_2  [RSC_100X050X040_2]  103.98 51.02 0 bottom
R60515  2.2_5%_3  [RSC_160X080X080_2]  105.74 50.79 270 bottom
R60516  RSC_0603  [RSC_160X080X080_2]  108.56 57.66 0 bottom
R60520  short_0402_5  [RSC_100X050X040_2_SHORT]  106.03 58.19 270 bottom
R60522  100K_5%_2  [RSC_100X050X040_2]  105.14 58.19 270 bottom
R60523  RSC_0402  [RSC_100X050X040_2]  103.88 57.7 180 bottom
R60524  RSC_0402  [RSC_100X050X040_2]  102.64 57.7 90 bottom
R60525  RSC_0402  [RSC_100X050X040_2]  99.34 57.37 180 bottom
R60526  short_0402_15  [RSC_100X050X040_2_15_SHORT]  101.83 50.56 270 bottom
R60529  short_0402_5  [RSC_100X050X040_2_SHORT]  106.65 56.35 270 bottom
R60600  102K_1%_2  [RSC_100X050X040_2]  110.26 104.08 135 bottom
R60601  49.9K_1%_2  [RSC_100X050X040_2]  109.12 105.98 45 bottom
R60605  RSC_0402  [RSC_100X050X040_2]  108.48 106.62 45 bottom
R60615  0_5%_3  [RSC_160X080X055_2]  105.81 98.87 225 bottom
R60616  RSC_0603  [RSC_160X080X080_2]  108.48 94.43 315 bottom
R60620  1K_5%_2  [RSC_100X050X040_2]  110.89 104.71 315 bottom
R60630  4.7_5%_2  [RSC_100X050X040_2]  111.53 103.57 225 bottom
R60900  102K_1%_2  [RSC_100X050X040_2]  170.79 101.49 180 bottom
R60901  133K_1%_2  [RSC_100X050X040_2]  169.9 100.57 0 bottom
R60903  RSC_0402  [RSC_100X050X040_2]  169.06 104.84 270 bottom
R60905  RSC_0402  [RSC_100X050X040_2]  169.9 103.24 0 bottom
R60915  0_5%_3  [RSC_160X080X055_2]  162.3 99.63 180 bottom
R60916  RSC_0603  [RSC_160X080X080_2]  162.46 96.97 270 bottom
R60920  1K_5%_2  [RSC_100X050X040_2]  172.39 101.49 180 bottom
R60930  4.7_5%_2  [RSC_100X050X040_2]  171.52 98.85 180 bottom
R61400  short_0402_15  [RSC_100X050X040_2_15_SHORT]  173.38 99.13 0 bottom
R61401  RSC_0402  [RSC_100X050X040_2]  175.46 98.36 90 bottom
R61403  RSC_0402  [RSC_100X050X040_2]  181.86 98.24 180 top
R61404  RSC_0402  [RSC_100X050X040_2]  181.86 97.35 180 top
R61405  RSC_0402  [RSC_100X050X040_2]  172.87 96.46 180 bottom
R61406  2.2_5%_2  [RSC_100X050X040_2]  173.66 97.35 180 bottom
R61415  2.2_5%_3  [RSC_160X080X080_2]  174.97 95.27 180 bottom
R61416  RSC_0603  [RSC_160X080X080_2]  183.03 93.28 270 bottom
R61421  RSC_0402  [RSC_100X050X040_2]  181.58 97.35 90 bottom
R61422  RSC_0402  [RSC_100X050X040_2]  182.09 96.08 180 bottom
R61424  RSC_0402  [RSC_100X050X040_2]  181.91 98.67 0 bottom
R61428  short_0402_15  [RSC_100X050X040_2_15_SHORT]  173.89 98.24 180 bottom
R61700  15.4K_1%_2  [RSC_100X050X040_2]  225.4 92.04 180 bottom
R61701  10K_1%_2  [RSC_100X050X040_2]  223.8 92.04 180 bottom
R66000  short_0402_5  [RSC_100X050X040_2_SHORT]  105.56 94.81 180 top
R66001  75_5%_2  [RSC_100X050X040_2]  99.97 92.27 90 top
R66002  10K_5%_2  [RSC_100X050X040_2]  99.08 92.27 90 top
R66003  short_0402_5  [RSC_100X050X040_2_SHORT]  100.83 92.27 90 bottom
R66004  short_0402_5  [RSC_100X050X040_2_SHORT]  101.74 92.27 90 bottom
R66016  RSC_0603  [RSC_160X080X080_2]  142.26 100.54 90 bottom
R66026  RSC_0603  [RSC_160X080X080_2]  117.8 98.03 225 bottom
R66036  RSC_0603  [RSC_160X080X080_2]  135.53 100.85 90 bottom
R66100  100_5%_2  [RSC_100X050X040_2]  98.04 90.95 90 top
R66101  45.3_1%_2  [RSC_100X050X040_2]  97.15 90.95 90 top
R66102  49.9_1%_2  [RSC_100X050X040_2]  97.3 92.98 90 top
R66103  10_5%_2  [RSC_100X050X040_2]  98.19 92.98 90 top
R66104  RSC_0402  [RSC_100X050X040_2]  99.97 90.31 90 top
R66105  10K_5%_2  [RSC_100X050X040_2]  102.66 92.27 90 top
R66106  short_0402_5  [RSC_100X050X040_2_SHORT]  103.72 92.51 90 top
R66107  120K_1%_2  [RSC_100X050X040_2]  94.89 95 180 top
R66108  4.7K_5%_2  [RSC_100X050X040_2]  101.77 92.27 270 top
R66109  4.7K_5%_2  [RSC_100X050X040_2]  100.89 92.27 270 top
R66110  4.7_5%_2  [RSC_100X050X040_2]  106.19 96.71 90 top
R66111  RSC_0402  [RSC_100X050X040_2]  95.88 91.54 180 top
R66112  short_0402_15  [RSC_100X050X040_2_15_SHORT]  95.32 90.3 270 top
R66113  73.2K_1%_2  [RSC_100X050X040_2]  94.42 91.56 270 top
R66114  RSC_0402  [RSC_100X050X040_2]  104.54 90.69 90 top
R66115  100K_5%_2  [RSC_100X050X040_2]  104.97 92.89 0 top
R66154  1.5K_1%_2  [RSC_100X050X040_2]  101.93 107.3 90 top
R66155  1.5K_1%_2  [RSC_100X050X040_2]  103.88 107.3 90 top
R66160  49.9K_1%_2  [RSC_100X050X040_2]  105.31 98.36 270 top
R66161  short_0402_5  [RSC_100X050X040_2_SHORT]  107.08 98.36 90 top
R66171  2.43K_1%_2  [RSC_100X050X040_2]  97.71 107.23 180 top
R66172  RSC_0402  [RSC_100X050X040_2]  97.71 108.12 0 top
R66195  short_0402_15  [RSC_100X050X040_2_15_SHORT]  107.46 100.52 180 top
R66197  14.3K_1%_2  [RSC_100X050X040_2]  106.19 100.01 270 top
R66198  133K_1%_2  [RSC_100X050X040_2]  107.67 103.19 90 top
R66199  2M_5%_2  [RSC_100X050X040_2]  108 104.81 270 top
R66316  RSC_0603  [RSC_160X080X080_2]  111.07 65.98 0 bottom
R66407  43.2K_1%_2  [RSC_100X050X040_2]  94.73 97.7 0 top
R66454  1.5K_1%_2  [RSC_100X050X040_2]  102.05 105.45 90 top
R66455  1.5K_1%_2  [RSC_100X050X040_2]  102.94 105.45 90 top
R66471  1.43K_1%_2  [RSC_100X050X040_2]  99.99 104.9 180 top
R66472  RSC_0402  [RSC_100X050X040_2]  99.99 105.82 0 top
R66607  620K_1%_2  [RSC_100X050X040_2]  94.5 93.73 270 top
R66616  RSC_0603  [RSC_160X080X080_2]  151.15 99.51 180 bottom
R66654  1.5K_1%_2  [RSC_100X050X040_2]  107.08 106.14 90 top
R66671  8.06K_1%_2  [RSC_100X050X040_2]  96.14 100.83 225 top
R66672  RSC_0402  [RSC_100X050X040_2]  95.4 100.65 0 bottom
R66680  short_0402_5  [RSC_100X050X040_2_SHORT]  95.32 99.49 180 top
R66681  short_0402_5  [RSC_100X050X040_2_SHORT]  95.32 98.61 180 top
R66819  short_0402_5  [RSC_100X050X040_2_SHORT]  96.46 107.77 90 top
R66821  short_0402_5  [RSC_100X050X040_2_SHORT]  95.57 107.77 90 top
R66829  short_0402_5  [RSC_100X050X040_2_SHORT]  98.75 104.93 90 top
R66831  short_0402_5  [RSC_100X050X040_2_SHORT]  97.86 104.93 90 top
R68004  9.09K_1%_2  [RSC_100X050X040_2]  212.47 115.74 90 bottom
R68009  3.32K_1%  [RSC_100X050X040_2]  213.51 115.86 90 bottom
R68054  short_0402_15  [RSC_100X050X040_2_15_SHORT]  182.65 107 270 top
R68055  short_0402_15  [RSC_100X050X040_2_15_SHORT]  183.54 107 90 top
R68065  32.4K_1%_2  [RSC_100X050X040_2]  212.49 114.07 270 bottom
R68067  1.87K_1%_2  [RSC_100X050X040_2]  213.5 114.26 270 bottom
R68068  9.09K_1%_2  [RSC_100X050X040_2]  211.17 114.8 0 bottom
R68086  1.87K_1%_2  [RSC_100X050X040_2]  213.51 112.64 270 bottom
R68094  49.9K_1%_2  [RSC_100X050X040_2]  245.51 25.26 180 top
R68095  301K_1%_2  [RSC_100X050X040_2]  247.34 26.3 270 top
R68096  49.9K_1%_2  [RSC_100X050X040_2]  247.75 27.6 180 top
R68099  100K_5%_2  [RSC_100X050X040_2]  212.49 109.41 180 top
R68100  47K_5%_2  [RSC_100X050X040_2]  252.93 48.07 90 top
R68101  470K_5%_2  [RSC_100X050X040_2]  249.53 30.24 0 top
R68102  47K_5%_2  [RSC_100X050X040_2]  244.17 26.51 270 top
R68103  470K_5%_2  [RSC_100X050X040_2]  243.28 26.51 270 top
R68104  47K_5%_2  [RSC_100X050X040_2]  242.85 24.96 0 top
R68105  47K_5%_2  [RSC_100X050X040_2]  256.16 42.08 270 top
R68106  470K_5%_2  [RSC_100X050X040_2]  254.05 47.36 90 top
R68107  47K_5%_2  [RSC_100X050X040_2]  260.17 88.2 180 top
R68108  470K_5%_2  [RSC_100X050X040_2]  258.11 85.64 180 top
R68109  47K_5%_2  [RSC_100X050X040_2]  264.82 80.68 270 top
R68120  1M_1%_2  [RSC_100X050X040_2]  204.11 113.7 270 bottom
R68121  100K_5%_2  [RSC_100X050X040_2]  208.25 112.59 90 bottom
R68122  220K_5%_2  [RSC_100X050X040_2]  207.46 114.21 270 bottom
R68123  549K_1%_2  [RSC_100X050X040_2]  204.11 116.98 270 bottom
R68124  76.8K_1%_2  [RSC_100X050X040_2]  204.11 115.36 270 bottom
R68125  33K_1%_2  [RSC_100X050X040_2]  204.11 112.08 270 bottom
RS300  10k_5%  [RSC_368X216X050_10_064]  44.09 25.08 90 bottom
S5  -  [SCREW300X420_860_1P]  279.5 111.75 90 top
S6  -  [SCREW250_600_500_1P]  278 86.25 0 top
S7  -  [SCREW250_600_1P]  279 71.55 0 top
S8  -  [SCREW250_600_1P]  277 58.3 0 top
S9  -  [SCREW250_600_1P]  282 34.25 0 top
S12  -  [SCREW250_700_1P]  218 113.5 0 top
S13  -  [SCREW450_700_1P]  187 4.7 0 top
S14  -  [SCREW450_700_1P]  179.11 4.7 0 top
S15  -  [SCREW500_700_NP_1P]  137 110.5 270 bottom
S16  -  [SCREW450_700_1P]  129.12 110.5 270 bottom
S17  -  [SCREW450_700_1P]  124 4.7 0 top
S18  -  [SCREW450_700_1P]  116.12 4.7 0 top
S19  -  [SCREW250_700_1P]  100 113.5 180 bottom
S20  -  [SCREW400_700_1P]  100 62.1 0 top
S21  -  [SCREW400_700_1P]  68 8.5 0 top
S22  -  [SCREW370_700_1P]  32 40.5 180 bottom
S30  -  [SCREW330_600_500_1P]  189.69 80.8 180 bottom
S31  -  [SCREW330_600_500_1P]  189.69 52.8 180 bottom
S32  -  [SCREW330_600_500_1P]  121.69 52.8 180 bottom
S33  -  [SCREW330_600_500_1P]  121.69 80.8 180 bottom
S9201  -  [SCREW250_700_1P]  23.55 59.7 0 top
S9202  -  [SCREW250_500_1P]  26.39 93.65 180 bottom
S9203  -  [SCREW260_460_1P]  19.15 113.4 0 top
ST1300  STANDOFF_3.2_6.0  [STD_R_FF45021_D30007_M20275_SN]  37.45 26 90 bottom
ST1400  STANDOFF_3.2_6.0  [STD_R_FF45021_D30007_M20275_SN]  208 97.85 270 bottom
ST1950  STANDOFF_3.2_6.0  [STD_R_FF45021_D30007_M20275_SN]  257.4 95.55 180 bottom
SW1000  DIPTRONICS_T3C2QR_2P_NSP  [SWCH-TACT_DIP_2_SMD_V_060_NSP]  80.24 8.6 180 bottom
SW1001  MISAKI_NDTP016_G1A_AAET_4P  [SWCH-DETECT_MISKI_4_SMD_V_380_NSP]  21.05 8.7 180 bottom
SW1002  MISAKI_NDTP016_G1A_AAET_4P  [SWCH-DETECT_MISKI_4_SMD_V_380_NSP]  260.15 4.5 180 bottom
TP300  -  [TP24_NP]  46.76 10.48 0 top
TP302  -  [TP24]  230.48 47.66 0 top
TP303  -  [TP24]  237.26 31.05 0 top
TP304  -  [TP24_NP]  40.28 10.48 0 top
TP305  -  [TP24_NP]  41.68 10.48 0 top
TP307  -  [TP24]  240.36 50.48 0 top
TP308  -  [TP24]  224.86 39.92 0 top
TP309  -  [TP24]  245.54 43.75 0 top
TP375  -  [TP24]  249.81 34.1 0 bottom
TP501  -  [TP24_NP]  28.5 34.71 270 top
TP502  -  [TP24_NP]  27.76 33.59 270 top
TP503  -  [TP24_NP]  28.52 32.58 270 top
TP504  -  [TP24_NP]  26.67 34.28 270 top
TP505  -  [TP24]  19.26 45.64 270 top
TP506  -  [TP24]  11.5 46.09 270 top
TP508  -  [TP24]  22.6 44.88 270 top
TP509  -  [TP24]  17.68 35.83 270 top
TP513  -  [TP24]  23.72 35.3 0 top
TP515  -  [TP24_NP]  25.6 33.54 0 top
TP850  -  [TP24]  56.74 10.81 180 bottom
TP851  -  [TP24]  58.09 10.89 180 bottom
TP852  -  [TP24]  59.36 11.11 180 bottom
TP853  -  [TP24]  58.52 12.11 180 bottom
TP854  -  [TP24]  62.38 9.72 180 bottom
TP855  -  [TP24]  60.63 11.11 180 bottom
TP1301  -  [TP24]  59.08 32.7 0 bottom
TP1302  -  [TP24]  60.35 32.2 90 bottom
TP1303  -  [TP24]  61.62 32.2 270 bottom
TP1411  -  [TP24]  211.99 54.17 270 top
TP1412  -  [TP24]  213.26 53.02 270 top
TP1413  -  [TP24]  214.53 54.17 270 top
TP1951  -  [TP30]  261.97 11.98 0 top
TP1952  -  [TP24]  247.29 14.42 0 top
TP2500  -  [TP24]  20.17 30.2 0 top
TP2501  -  [TP24]  76.6 33.97 180 bottom
TP2502  -  [TP24]  40.54 37.53 180 bottom
TP2503  -  [TP24_NP]  15.13 41.96 180 bottom
TP2504  -  [TP24_NP]  13.86 41.96 180 bottom
TP2505  -  [TP24_NP]  13.63 40.44 180 bottom
TP2506  -  [TP24_NP]  12.36 40.44 180 bottom
TP2507  -  [TP24_NP]  12.13 41.96 180 bottom
TP2508  -  [TP24_NP]  10.86 41.96 180 bottom
TP2509  -  [TP24_NP]  10.63 40.57 180 bottom
TP2510  -  [TP24_NP]  9.36 40.57 180 bottom
TP2511  -  [TP24_NP]  10.16 38.88 180 bottom
TP2512  -  [TP24_NP]  8.96 38.42 180 bottom
TP2515  -  [TP24]  5.74 45.9 0 top
TP2516  -  [TP24]  3.2 45.91 0 top
TP2517  -  [TP24]  4.47 45.91 0 top
TP2518  -  [TP24_NP]  3.86 43.96 0 top
TP2519  -  [TP24_NP]  1.84 45.9 0 top
TP2521  -  [TP24]  5.61 42.23 0 top
TP2522  -  [TP24]  8.61 42.66 0 top
TP2600  -  [TP24]  268.09 25.2 0 top
TP2601  -  [TP24]  272.56 86.04 0 top
TP2602  -  [TP24]  254.96 27.17 0 top
TP2603  -  [TP24]  255.54 34.04 0 top
TP2700  -  [TP24]  254.4 59.76 270 bottom
TP2701  -  [TP24]  253.26 60.39 270 bottom
TP2703  -  [TP24]  253.26 58.99 270 bottom
TP2704  -  [TP24]  254.02 61.53 180 bottom
TP3301  -  [TP24]  241.96 95.92 270 top
TP3303  -  [TP24]  235.43 83.12 90 top
TP3800  -  [TP24]  203.73 81.47 0 bottom
TP4300  -  [TP24]  81.28 33.34 180 bottom
TP4301  -  [TP24]  82.55 33.34 180 bottom
TP4302  -  [TP24]  83.08 28.77 180 bottom
TP4303  -  [TP24]  86.15 34.22 180 bottom
TP4500  -  [TP24]  154.92 72.09 0 top
TP4501  -  [TP24]  191.36 59.45 180 bottom
TP4502  -  [TP24]  193.82 43.25 0 top
TP4503  -  [TP24]  168.98 62.37 0 top
TP4504  -  [TP24_NP]  173.75 61.13 0 top
TP4505  -  [TP24]  180.24 40.71 0 top
TP4506  -  [TP24_NP]  174.24 62.31 0 top
TP4507  -  [TP24]  169.99 61 0 top
TP4508  -  [TP24]  191.11 60.77 0 top
TP4509  -  [TP24_NP]  183.79 53.91 180 bottom
TP4510  -  [TP24]  178.63 90.82 0 top
TP4511  -  [TP24]  129.69 85.79 180 bottom
TP4512  -  [TP24]  140.23 56.83 0 top
TP4513  -  [TP24]  139.6 55.69 0 top
TP4514  -  [TP24]  179.85 90.36 0 top
TP4515  -  [TP24_NP]  183.79 52.61 180 bottom
TP4516  -  [TP24]  128.85 84.65 180 bottom
TP4517  -  [TP24]  116.48 76.14 180 bottom
TP4518  -  [TP24]  185.34 73.42 0 top
TP4519  -  [TP24]  184.06 73.42 0 top
TP4520  -  [TP24]  189.3 74.54 0 top
TP4521  -  [TP24]  188.29 73.75 0 top
TP4522  -  [TP24]  188.44 64.69 180 bottom
TP4523  -  [TP24]  189.55 65.33 180 bottom
TP4524  -  [TP24]  199.96 64.96 180 bottom
TP4525  -  [TP24]  195.6 66.32 180 bottom
TP4526  -  [TP24]  181.21 85.33 180 bottom
TP4750  -  [TP24]  210.73 8.18 0 top
TP4751  -  [TP24]  209.46 8.18 0 top
TP6001  -  [TP24]  210.21 115.76 0 top
TP6002  -  [TP24]  242.39 81.93 0 bottom
TP6050  -  [TP24]  85.95 26.84 0 bottom
TP6051  -  [TP24]  87.22 26.84 0 bottom
TP6052  -  [TP24]  78.05 26.58 180 bottom
TP6053  -  [TP24]  83.84 25.21 180 bottom
TP6054  -  [TP24]  79.5 26.91 180 bottom
TP9200  -  [TP30]  43.08 91.12 0 top
TP9201  -  [TP30_NP]  43.08 93.16 0 top
TP9202  -  [TP30]  43.08 95.19 90 top
TP9203  -  [TP30]  37.65 68.92 0 top
TP9204  -  [TP30]  38.3 71.29 0 top
TP9205  -  [TP30]  47.52 72.07 0 top
TP60000  -  [TP24]  146.71 116.78 270 bottom
TP60100  -  [TP24]  224.02 63.29 90 bottom
TP60101  -  [TP24]  224.56 81.09 90 top
TP60102  -  [TP24]  225.57 81.88 0 top
TP60200  -  [TP24]  229.77 64.2 270 bottom
TP60202  -  [TP24]  232.38 75.5 180 bottom
TP60204  -  [TP24]  233.96 74.49 0 top
TP60250  -  [TP24]  196.62 88.84 90 bottom
TP60251  -  [TP24]  194.41 99.84 90 bottom
TP60300  -  [TP24]  170.07 9.65 45 top
TP60301  -  [TP24_NP]  157.12 2.86 180 top
TP60350  -  [TP24]  162.33 6.54 180 top
TP60351  -  [TP24_NP]  157.25 4.51 270 top
TP60400  -  [TP24]  206.35 4.84 90 bottom
TP60410  -  [TP24]  196.92 7.51 180 bottom
TP60500  -  [TP24]  116.93 50.57 0 bottom
TP60501  -  [TP24]  103.96 59.5 180 bottom
TP60600  -  [TP24]  118.51 89.32 180 bottom
TP60601  -  [TP24]  107.46 104.71 180 bottom
TP60900  -  [TP24]  168.42 86.5 0 bottom
TP60901  -  [TP24]  168.55 103.32 0 bottom
TP61400  -  [TP24]  174.52 85.16 270 bottom
TP61401  -  [TP24]  182.67 97.17 270 bottom
TP61700  -  [TP24]  245.21 93.28 180 top
TP61701  -  [TP24]  221 92.27 180 bottom
TP66000  -  [TP24]  128.17 90.11 180 bottom
TP66001  -  [TP24]  104.04 94.81 90 top
TP66300  -  [TP24]  120.16 73.47 90 bottom
TP66600  -  [TP24]  165.63 61.91 90 top
U300  NUVOTON_NPCX797HA1BX_VFBGA_144P  [VFBGA_800X800X095_144_065_P2]  238.88 41.29 0 top
U302  OSRAM_NL27WZ07DFT2G_SC88_6P  [TSSC88_200X125X110_6_065]  240.98 52.46 90 bottom
U366  WINBOND_W25Q128JVPIQ_WSON_8P  [WSON_500X600X080_8_127_T2]  223.84 29.32 45 top
U367  WINBOND_W25Q256JVEIN_WSON_8P  [WSON_600X800X080_8_127_T1]  231.76 55.44 270 bottom
U500  REA_ALC3292_CG_MQFN_48P  [MQFN_600X600X100_48_040_T1]  22.05 40.45 0 top
U1000  DIALOG_SLG4T43296VTR_STQFN_12P  [STQFN_160X160X060_12_040_P2]  137.99 8.98 270 top
U1300  NXP_74LVC1G08GW_TSOT353_5P  [TSOT353_205X125X110_5_065]  54.56 24.07 90 bottom
U1400  GEMALTO_WSTM056_WLCSP_11P  [WLCSP_254X274X060_11_065]  210.16 63.43 0 bottom
U1401  TI_SN74AUP1G97DCKR_SC70_6P  [SC70_200X125X110_6_065_P2]  213.79 63.64 180 bottom
U2403  CYPRESS_CYPD5225_96BZXIT_BGA_96P  [BGA_600X600X100_96_050_P2]  261.07 26.83 0 top
U2500  GMT_G524B1T11U_SOT23_5P  [TSOT23_290X160X125_5_095]  79.02 31.07 0 bottom
U2501  TEXAS_TPS2546RTER_QFN_16P  [QFN_300X300X080_16_050_T1]  23.96 29.9 90 top
U2600  NXP_NX5P3290AU_WLCSP_16P  [WLCSP_220X220X060_16_050]  267.65 95.16 270 top
U2602  NXP_NX5P3290AU_WLCSP_16P  [WLCSP_220X220X060_16_050]  263.5 40.38 180 top
U2700  INTEL_TITAN_RIDGE_DP_BGA_337P  [BGA_1070X1070X089_337]  258.26 63.97 90 top
U2701  NXP_74LVC1G08GW_TSOT353_5P  [TSOT353_205X125X110_5_065]  245.26 72.89 270 top
U2702  NXP_74LVC1G17GM_TSOT886_6P  [TSOT886_145X100X050_6_050]  248.54 74.74 180 top
U2703  WINBOND_W25Q80DVZPIG_WSON_8P  [WSON_600X500X080_8_127_T1P2]  243.71 59.64 180 top
U3000  NUVO_NCT3521U_SOT23_5P  [TSSOT23_290X160X135_5_095]  52.73 9.82 180 bottom
U3001  NXP_74LVC1G3157GM_TSOT886_6P  [TSOT886_145X100X050_6_050]  23.26 21.53 0 top
U3002  NXP_74LVC1G3157GM_TSOT886_6P  [TSOT886_145X100X050_6_050]  220.21 99.38 180 bottom
U3003  NXP_74LVC1G3157GM_TSOT886_6P  [TSOT886_145X100X050_6_050]  219.99 96.46 180 bottom
U3150  GMT_G524B1T11U_SOT23_5P  [TSOT23_290X160X125_5_095]  272.96 91.32 270 bottom
U3300  PARADE_PS8339AQFN56GTR2_A1_QFN_56P  [QFN_700X700X090_56_040_T6]  240.44 91.12 270 top
U3500  INFINEON_SLB9670VQ2_0_FW_7_85_VQFN_32P  [VQFN_500X500X090_32_050_T1]  225.24 57.64 180 top
U3800  SANDISK_SDINBDA4_32G_V_TFBGA_153P  [CAMELLIA-6019B1806501-001]  205.91 79.56 180 top
U4411  GMT_G788P81U_MSOP_8P  [MSOP_300X300X110_8_065_P3]  121.31 85.96 90 bottom
U4412  NUVO_NCT7717U_SOT23_5P  [TSSOT23_290X160X135_5_095]  183.54 115.91 180 bottom
U4413  GMT_G708T1U_SOT23_5P  [TSOT23_290X160X130_5_095]  105.43 108.78 270 bottom
U4555  INTEL_J92043_BGA_1528P  [CPU_INTEL_CLU_6C_B_4600X2400]  158.14 65.85 90 bottom
U4700  74LVC1G17GW  [TSSC88A_200X125X110_5_065]  204.37 67.5 90 bottom
U4920  TI_SN74AUP1G97DCKR_SC70_6P_NP  [SC70_200X125X110_6_065_NP]  103.15 39.31 180 top
U4921  TI_SN74AUP1G97DCKR_SC70_6P_NP  [SC70_200X125X110_6_065_NP]  99.59 39.31 180 top
U7000  NXP_74LVC1G07GW_TSSOP_5P  [TSSOP_205X125X110_5_065]  214.53 95.82 180 bottom
U7001  GMT_G2898KD1U_TDFN_15P  [TDFN_300X200X080_14_040_T4]  211.86 85.66 270 bottom
U7400  ON_LMV393DMR2G_SOP_8P  [MICRO_300X300X110_8_065]  212.87 72.58 90 bottom
U9201  PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P  [TQFN_400X400X080_24_050_T6]  39.01 99.25 90 top
U9203  PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P  [TQFN_400X400X080_24_050_T6]  41.93 80.58 90 top
U9204  MST_MH255ESP_PSOT23_3P  [IC-HALL_MST_3_SMD_105]  40.8 121.5 0 top
U9300  CAPELLA_CM32181E_OPLGA_6P  [CAMELLIA-6019B1265501-002]  79.2 109.14 90 top
U9301  CAPELLA_CM32181E_OPLGA_6P  [CAMELLIA-6019B1265501-002]  79.2 105.14 90 top
U9302  CAPELLA_CM32181E_OPLGA_6P  [CAMELLIA-6019B1265501-002]  74.36 80.6 180 top
U60000  INTERSIL_ISL9241HRTZ_TQFN_32P  [TQFN_400X400X075_32_040_T2]  192.35 107.06 90 top
U60100  MPS_NB680AGD_Z_QFN_12P  [QFN_300X200X100_12_050]  227.88 80.35 0 bottom
U60200  SILERGY_SYV127CTMC_QFN_13P  [QFN_300X400X085_13]  238.2 74.6 90 bottom
U60250  SILERGY_SYV128CRAC_QFN_20P  [QFN_300X300X090_20_045_T2]  190.27 98.24 90 bottom
U60300  MPS_NB685AGQ_Z_QFN_16P  [QFN_300X300X100_16_050_P1]  158.26 6.16 90 bottom
U60400  RICHTEK_RT8097ALGE_TSOT23_6P  [TSOT23_290X160X130_6_095]  196.21 5.27 270 bottom
U60500  MPS_NB692GD_QFN_13P  [QFN_300X200X100_13_050]  103.96 54.4 90 bottom
U60600  SILERGY_SY8386RHC_QFN_16P  [QFN_250X250X065_16_045_T1]  107.68 101.51 135 bottom
U60900  SILERGY_SY8386RHC_QFN_16P  [QFN_250X250X065_16_045_T1]  166.27 100.65 90 bottom
U61400  MPS_NB692GD_QFN_13P  [QFN_300X200X100_13_050]  178.33 96.96 0 bottom
U61700  SILERGY_SY8088A1AAC_SOT23_5P  [TSOT23_295X160X130_5_095]  225.45 89.96 270 bottom
U66000  MPS_MP2979AGQKT_0180_Z_TQFN_48P  [TQFN_600X600X080_48_040_T3]  100.17 98.1 180 top
U66010  MPS_MP86948GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  144.64 103.71 180 bottom
U66020  MPS_MP86948GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  117.82 102.31 225 bottom
U66030  MPS_MP86948GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  128.48 101.96 225 bottom
U66310  MPS_MP86948GQVT_Z_TQFN_21P  [TQFN_500X300X080_21_040]  104.69 67.49 180 bottom
U66610  MPS_MP86901_AGQT_TQFN_13P  [TQFN_300X300X080_13_040]  152.95 102.14 180 bottom
X2700  TXC_7M25000153_CRYSTAL_25M_20PF_4P  [XTAL_320X250X080_4_220]  266.65 55.26 270 bottom
X4750  32.768KHZ_12.5PF  [XTAL_670X140X140_4_630]  209.14 50.28 0 bottom
X4751  TXC_24MHZ_12PF  [XTAL_320X250X080_4_220]  190.54 75.31 270 bottom

## Library data of the parts
C100 C302 C305 C306 C311 C7406 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet62
C131 C303 C308 C310 C312-C317 C321 C324 C325 C366 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet62
C300 C326 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet64
C301 C304 C309 C320 = CSC0201: part number: CSC0201-2200PF_16V_1,6010B0058110,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,2200PF,16V,K,X7R,0201,TR; signal model: C2_6010B0058110_2200pF_16V_1; room: Sheet62
C307 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164601,CSC_100X050X065_2,0.8MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164601_4_7UF_6_3V_2; room: Sheet62
C318 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet62
C319 = CSC0201: part number: CSC0201-2.2UF_6.3V_1,6010B0290004,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0201,TR,; signal model: C2_6010B0290004_2_2UF_6_3V_1; room: Sheet62
C322 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet62
C323 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet64
C327 = CSC0402: part number: CSC0402-10PF_50V_2,6010A0025401,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_10pF_50V_2; room: Sheet63
C500 C509 = CSC0603: part number: CSC0603-2.2UF_6.3V_3,6010B0392401,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,2.2UF,6.3V,K,X5R,0603,TR,0.8MM; signal model: C2_6010B0392401_2_2UF_6_3V_3; room: Sheet70
C501 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet70
C502 C505 C511 C512 C518 C520 C522 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet70
C503 C504 C506 C508 C513 C517 C519 C521 C523 C526 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet70
C507 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet70; signal model: C2_6010A0036403_0_1uF_16V_2
C510 = CSC0402: part number: CSC0402-4.7UF_6.3V_2,6010B0164602,CSC_100X050X065_2,0.75MM,CSC0402,0402,X5R,CAPACITOR-CHIP,4.7UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0164602_4_7UF_6_3V_2; room: Sheet70
C514 C527 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet70
C515 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet70
C516 C524 C525 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet70
C640-C643 = CSC0201: part number: CSC0201-100PF_50V_1,6010B0058101,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,100PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058101_100pF_50V_1; room: Sheet71
C1000 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet72
C1001 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet72
C1002 = CSC0201: part number: CSC0201-0.01UF_25V_1,6010B0334301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,0.01UF,25V,K,X5R,0201,TR; signal model: C2_6010B0334301_0_01UF_25V_1; room: Sheet72
C1300 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet66
C1301 C1304 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet66
C1302 C1305 = CSC0201: part number: CSC0201-0.01UF_25V_1,6010B0334301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,0.01UF,25V,K,X5R,0201,TR; signal model: C2_6010B0334301_0_01UF_25V_1; room: Sheet66
C1303 C1306 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet66
C1307 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet66
C1309 = CSC0201: part number: CSC0201-0.047UF_6.3V_1,6010B0058111,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.047UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0058111_0_047uF_6_3V_1; room: Sheet66
C1400 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet67
C1401 = CSC0402: part number: CSC0402-33PF_50V_2,6010A0028901,CSC_100X050X040_2,0.56MM,CSC0402,0402,,CAP-CHIP-33PF-J,50V-TAP(0402); signal model: C2_6010A0028901_33pF_50V_2; room: Sheet67
C1402 = CSC0201: part number: CSC0201-4.7PF_50V_1,6010B0595801,CSC_060X030X033_2,0.43MM,CSC0201,CAPACITOR-CHIP,4.7PF,50V,C,C0G,0201,TR,0.3MM; signal model: C2_6010B0595801_4_7pF_50V_1; room: Sheet67
C1403-C1405 C1453 = CSC0201: part number: CSC0201-18PF_50V_1,6010B0058106,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,18PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058106_18pF_50V_1; room: Sheet67
C1406 = CSC0201: part number: CSC0201-100PF_50V_1,6010B0058101,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,100PF,50V,J,C0G,0201,TR; signal model: C2_6010B0058101_100pF_50V_1; room: Sheet67
C1407 = CSC0402: part number: CSC0402-82PF_50V_2,6010A003610G,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-82PF-50V-J-NPO-0402-TAP; signal model: C2_6010A003610G_82pF_50V_2; room: Sheet67
C1408 = CSC0402: part number: CSC0402-68PF_50V_2,60100768020T,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP-680-J,50V-TAP(0402); signal model: C2_60100768020T_68pF_50V_2; room: Sheet67
C1409 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet67
C1410 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0392101,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0392101_1uF_6_3V_2; room: Sheet67
C1411 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet67
C1413 = CSC0201: part number: CSC0201-0.01UF_25V_1,6010B0334301,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,0.01UF,25V,K,X5R,0201,TR; signal model: C2_6010B0334301_0_01UF_25V_1; room: Sheet67
C1414 C1451 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet67
C1415 C1452 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet67
C1956 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet60
C2200 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet61
C2201 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet61
C2250 C2255 = CSC0201: part number: CSC0201-0.1UF_10V_1,6010B0068501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,10V,K,X5R,0201,TR; signal model: C2_6010B0068501_0_1uF_10V_1; room: Sheet59
C2251 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059302,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059302_2_2UF_6_3V_2; room: Sheet59
C2256 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet59
C2257 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet59
C2258 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009906,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009906_4_7uF_6_3V_3; room: Sheet59
C2410 C2424 C2425 C2432 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet52
C2411 C2423 C2427 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet52
C2419-C2422 = CSC0402: part number: CSC0402-390PF_50V_2,6010A0024801,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-391-K,50V-X7R-0402-TAP; signal model: C2_6010A0024801_390pF_50V_2; room: Sheet52
C2500 C2508 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902-001,RANGERS-6010B0044902-001,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902-001_10uF_6_3V_3; room: Sheet57
C2501 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet57
C2502 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219002-001,CLOONEY-6010B0219002-001,1.10MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,M,X5R,0603,TR,0.8MM; signal model: C2_6010B0219002-001_22uF_6_3V_3; room: Sheet57
C2503 C2506 C2507 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet57
C2504 C2505 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet57
C2600 = CSC0603: part number: CSC0603-10UF_25V_3,6010B0366801,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,25V,M,X5R,0603,TR; signal model: C2_6010B0366801_10uF_25V_3; room: Sheet56
C2601 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet56
C2602 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet56
C2603-C2605 C2615 C2616 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet56
C2606 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet54
C2607 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet54
C2608 = CSC0402: part number: CSC0402-1UF_25V_2,6010B0455901,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,25V,K,X5R,0402,TR,0.5MM; signal model: C2_6010B0455901_1UF_25V_2; room: Sheet56
C2609 = CSC0402: part number: CSC0402-1UF_25V_2,6010B0455901,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAPACITOR-CHIP,1UF,25V,K,X5R,0402,TR,0.5MM; signal model: C2_6010B0455901_1UF_25V_2; room: Sheet54
C2610 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet54
C2611 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet56
C2612 C2614 C2630 C2633 C2634 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044902,CSC_160X080X095_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044902_10uF_6_3V_3; room: Sheet54
C2613 = CSC0201: part number: CSC0201-1000PF_25V_1,6010B0058109,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,1000PF,25V,K,X7R,0201,TR; signal model: C2_6010B0058109_1000pF_25V_1; room: Sheet54
C2617 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X055_2,0.65MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet56
C2620 = CSC0603: part number: CSC0603-10UF_25V_3,6010B0366801,CSC_160X080X090_2,1.00MM,CSC0603,0603,,CAPACITOR-CHIP,10UF,25V,M,X5R,0603,TR; signal model: C2_6010B0366801_10uF_25V_3; room: Sheet54
C2700-C2727 = CSC0201: part number: CSC0201-0.22UF_6.3V_1,6010B0058114,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.22UF,6.3V,M,X5R,0201,TR; signal model: C2_6010B0058114_0_22uF_6_3V_1; room: Sheet50
C2728 C2729 C2732 C2733 C2736 C2737 C2742 C2743 = CSC0201: part number: CSC0201-0.33UF_25V_1,6010B0536901,CSC_060X030X039_2,0.49MM,CSC0201,CAPACITOR-CHIP,0.33UF,25V,K,X5R,0201,TR; signal model: C2_6010B0536901_0_33uF_25V_1; room: Sheet50
C2730 C2731 C2734 C2735 C2738-C2741 = CSC0201: part number: CSC0201-0.22UF_25V_1,6010B0536801,CSC_060X030X033_2,0.43MM,CSC0201,CAPACITOR-CHIP,0.22UF,25V,K,X5R,0201,TR; signal model: C2_6010B0536801_0_22uF_25V_1; room: Sheet50
C2744 C2745 = CSC0402: part number: CSC0402-22PF_50V_2,6010072202AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAPACITOR-CHIP,22PF,50V,J,C0G,0402,TR; signal model: C2_6010072202AT_22pF_50V_2; room: Sheet50
C2746 = CSC0201: part number: CSC0201-0.1UF_6.3V_1,6010B0092501,CSC_060X030X030_2,0.45MM,CSC0201,CAP-CHIP,0.1UF,6.3V,K,X5R,0201,TR; signal model: C2_6010B0092501_0_1uF_6_3V_1; room: Sheet50
C2747 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet50
C2748-C2751 C2775-C2781 = CSC0201: part number: CSC0201-1UF_6.3V_1,6010B0187301,CSC_060X030X035_2,0.5MM,CSC0201,CAPACITOR-CHIP,1UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0187301_1uF_6_3V_1; room: Sheet51
C2752-C2755 C2773 C2774 = CSC0402: part number: CSC0402-10UF_6.3V_2,6010B0187202,CSC_100X050X070_2,0.80MM,CSC0402,0402,X5R,CAPACITOR-CHIP,10UF,6.3V,M,X5R,0402,TR,0.5MM; signal model: C2_6010B0187202_10uF_6_3V_2; room: Sheet51
C2756-C2761 C2765-C2771 C2782-C2786 = CSC0201: part number: CSC0201-2.2UF_6.3V_1,6010B0329101,CSC_060X030X033_2,0.48MM,CSC0201,CAPACITOR-CHIP,2.2UF,6.3V,M,X5R,0201,TR,0.3MM; signal model: C2_6010B0329101_2_2UF_6_3V_1; room: Sheet51
