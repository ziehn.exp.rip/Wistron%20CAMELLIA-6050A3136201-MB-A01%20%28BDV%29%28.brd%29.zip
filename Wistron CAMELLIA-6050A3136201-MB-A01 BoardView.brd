# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Library data of the parts (continued)
CN2500 = CN_30_2G: part number: CN_30_2G-HIROSE_FH34SRJ_30S_0_5SH_50_30P,6012B1039001-001,CAMELLIA-6012B1039001-001,1.25MM,,FH34SRJ_30S_0_5SH_30P; room: Sheet57
CN2501 = CN_06_2G: part number: CN_06_2G-ACES_50224_00601_001_6P,6012B1170201,WTB_ACES_6_100_SMD_R_M_295_2,3.45MM,,CONNECTOR,W TO B,2.9MM,FL,BLK,1X6,1.0MM,STR,SMD,TR,G/F; room: Sheet57
CN2700 = 50961_0084B_001: part number: 50961_0084B_001-ACES_50951_0084N_001_8P,6026B0270301-004,OLYMPIA-6026B0270301-004,3.20MM,,SOCKET,SPI FLASH,8P,1.27MM,5U,2.95MM,STR,SMD,TR; room: Sheet50
CN2701 = CN_15_2G: part number: CN_15_2G-ACES_51614_01501_002_15P,6012B1168501,FPC_ACES_15_050_R_100_2,1.25MM,,CONNECTOR,FPC,BACK FLIP,1.8MM,FL,NTU,1X15,0.5MM,90D,SMD,TR,LCP,G/F; room: Sheet51
CN2800 = 020090HB024M51UZL: part number: 020090HB024M51UZL-SUYIN_020090HB024M51UZL_24P,6012B1010901,USB31_SYN_24_SMD_S_158_341,3.71MM,,CONNECTOR,USB3.1 , 9.58MMX8.20MM ,24P,DIP,TR; room: Sheet55
CN2900 = 020090HB024M51UZL: part number: 020090HB024M51UZL-SUYIN_020090HB024M51UZL_24P,6012B1010901,USB31_SYN_24_SMD_S_158_341,3.71MM,,CONNECTOR,USB3.1 , 9.58MMX8.20MM ,24P,DIP,TR; room: Sheet53
CN3000 = CN_40_5G: part number: CN_40_5G-ACES_51398_0407T_001_40P,6012B0773101-009,CAMELLIA-6012B0773101-009,1.75MM,,CONNECTOR,W TO B,FL,BLK,1X40,0.5MM,STR,SMD,TR; room: Sheet58
CN3001 = 50406_02071_001: part number: 50406_02071_001-ACES_50406_02001_Q01_20P,6012B0344102,WTB_ACES_20_050_SMD_V_F_140,1.75MM,,CONNECTOR,W TO B,1.4MM,FL,BLK,1X20,0.5MM,STR,SMD,TR,G/F; room: Sheet59
CN3150 = CN_19_4G_HDMI: part number: CN_19_4G_HDMI-T_CONN_16_A3940_1A03_A_19P,6012B0916701,HDMI_TCONN_19_RS_225_261,3MM,,CONNECTOR,HDMI,A TYPE,-2.25/2.6MM,BLK,19P,90D,DIP,TR,LCP,G/F; room: Sheet49
CN4100 = AS0A821_H2SB_7H: part number: AS0A821_H2SB_7H-ARGOSY_D4AR0_26010_1P40_260P,6026B0328101-004,SAGE12-6026B0328101-004,4.65MM,,SOCKET, DDR4, 260P, 0.5MM, GOLD, 10U, 4.0MM, 30D, SMD, REVERSE, TR; room: Sheet46
CN4125 = AS0A821_H2SB_7H: part number: AS0A821_H2SB_7H-ARGOSY_D4AR0_26010_1P40_260P,6026B0328101-004,SAGE12-6026B0328101-004,4.65MM,,SOCKET, DDR4, 260P, 0.5MM, GOLD, 10U, 4.0MM, 30D, SMD, REVERSE, TR; room: Sheet47
CN4300 = CN_04_2G: part number: CN_04_2G-ENTERY_3802K_Q04N_07L_4P,6012B0446101-002,LADYLUCK-6012B0446101-002,3.45MM,,CONNECTOR,W TO B,3.3MM,ML,1X4,1.25MM,90D,SMD,TR,MATT TIN,100-160U; room: Sheet30
CN4350 = CN_15_2G: part number: CN_15_2G-HIROSE_FH52_15S_0_5SH_15P,6012B0882601,FPC_HRS_15_050_R_175,2.1MM,,CONNECTOR,FPC,2MM,FL,1X15,0.5MM,90D,SMD,TR,G/F; room: Sheet68
CN4750 = CN_02_2G: part number: CN_02_2G-ENTERY_3703K_Q02N_11L_2P,6012B0111314,WTB_ENTRY_2_100_SMD_R_M_295,3.23MM,,CONNECTOR,W TO B,2.95MM,ML,NTU,1X2,1.0MM,90D,SMD,TR,MATT TIN,100-160U; room: Sheet41
CN4920 = BSH_030_01_L_D_A_TR: part number: BSH_030_01_L_D_A_TR-SAMTEC_BSH_030_01_L_D_A_TR_60P,6012A0109001,BTB_SAM_60_050_F_325,3.3MM,CONN-FL-2X30-0.5MM-SMD-B TO B; room: Sheet31
CN4941 = CN_18_2G: part number: CN_18_2G-JOINT_F0504WRA_S_18PNLNK1G00L_18P,6012B0622401-002,BALOS-6012B0622401-002,1.13MM,,CONNECTOR,FPC,0.9MM,FL,0.5A,1X18,0.5MM,90D,SMD,TR,HI TEMP PLASTIC,MATT TIN; room: Sheet31
CN6000 = CN_07_2G: part number: CN_07_2G-ACES_50224_00701_001_7P,6012B1176701,WTB_ACES_7_100_SMD_R_M_295_2,3.45MM,,CONNECTOR,W TO B,FL,1X6,90D,SMD,TR; room: Sheet25
CN6050 = CN_09_2G: part number: CN_09_2G-ACES_50279_0090T_Q01_9P,6012B0618507,WTB_ACES_9_125_SMD_R_M_215,2.35MM,,CONNECTOR,WTB,BATTERY,FL,1X9,1.25MM,SMD,TR; room: Sheet25
CN9200 = CN_09_4G_USB30: part number: CN_09_4G_USB30-SINGATRON_2UB1757_000111F_9P,6012B1133401,USB3_SIGAT_9_DIP_RS_S_210_271,3.06MM,,CONNECTOR,USB 3.0,-2.1/2.71MM,BLK,9P,90D,DIP,TR,PA9T,GOLD,30U; room: Sheet80
CN9201 = CN_09_4G_USB30: part number: CN_09_4G_USB30-SINGATRON_2UB1757_000111F_9P,6012B1133401,USB3_SIGAT_9_DIP_RS_S_210_271,3.06MM,,CONNECTOR,USB 3.0,-2.1/2.71MM,BLK,9P,90D,DIP,TR,PA9T,GOLD,30U; room: Sheet81
CN9202 = CN_30_2G: part number: CN_30_2G-HIROSE_FH34SRJ_30S_0_5SH_50_30P,6012B1039001-001,CAMELLIA-6012B1039001-001,1.25MM,,FH34SRJ_30S_0_5SH_30P; room: Sheet79
CN9203 = CN_06_2G: part number: CN_06_2G-ACES_50224_00601_001_6P,6012B1170201,WTB_ACES_6_100_SMD_R_M_295_2,3.45MM,,CONNECTOR,W TO B,2.9MM,FL,BLK,1X6,1.0MM,STR,SMD,TR,G/F; room: Sheet79
CN9300 CN9301 = CN_06_2G: part number: CN_06_2G-ACES_50696_0060M_002_6P,6012B0856401-001,CAMELLIA-6012B0856401-001,1.4MM,,CONNECTOR,FPC,6P; room: Sheet85
CN9302 = CN_06_2G: part number: CN_06_2G-ACES_50696_0060M_002_6P,6012B0856401-001,CAMELLIA-6012B0856401-001,1.4MM,,CONNECTOR,FPC,6P; room: Sheet84
CN9354 = CN_12_2G: part number: CN_12_2G-ACES_50696_0120M_002_12P,6012B0430404-001,CAMELLIA-6012B0430404-001,1.4MM,,CONNECTOR,FPC,BLK,1X102,1.0MM; room: Sheet83
CP1-CP8 CP10-CP13 CP17-CP23 = COPPER_1PIN: part number: COPPER_1PIN-EMI_STOP_SUL_15A8M_1P,6053B1063701,FGR_SOLDERING_560X134X151X015,1.76MM,COPPER_1PIN,CLIP,WIFI,PMU,SUS304 1/2H,MEM; room: Sheet75
D300 = LED_DUAL_2IN_2OUT_A: part number: LED_DUAL_2IN_2OUT_A-LITEON_LTW_C195DSKS_5A_4P,6011B0209701,LED_LITON_V_150X160X055_S_YW,0.75MM,,DIODE-LED,YEL/WHT,1615,180/71MCD,130D,20/30MA,SMD,4P,TR; room: Sheet69
D301 = SCH_DUAL_1IN_2OUT: part number: SCH_DUAL_1IN_2OUT-BAT54A,6011A0003101,DSOT23_290X130X110_3_095_P2,1.25MM,SCH_DUAL_1IN_2OUT,DIODE-SCH-BAT54A-SOT23-TAP-PHP; room: Sheet64
D302-D304 = BAW56S: part number: BAW56S-PANJIT_BAW56DW_SOT363_6P,6011B0174301,DSSOT363_200X125X110_6_065,1.25MM,DIODE,DUAL SCH,75V,150MA,4NS,SMD,SOT363,TR; room: Sheet64
D500 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P,6011B0131701,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet70
D1000 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A,6011B0155101,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet72
D1300 D1302 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet66
D1400 = SWCH_SINGLE: part number: SWCH_SINGLE-1N4148WS,6011B0157401,DSOD323_185X125X095_2_231,1.05MM,SWCH_SINGLE,,,DIODE,SWCH,100V,200MA,250MW,4NS,SMD,SOD323,TR; room: Sheet67
D1401 D1402 D1404 D1405 = ESD: part number: ESD-AMAZING_AZ5B75_01B_R7G_2P,6011B0277601,DS_060X030X030_2_040,0.4MM,,DIODE,ESD,5V,SMD,CSP0603P2Y,TR; room: Sheet67
D1410 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet67
D1451 = D_DUAL_SERIES_A: part number: D_DUAL_SERIES_A-BAV99,60110GA0450T,DSSOT23_290X130X110_3_095-2,1.25MM,D_DUAL_SERIES_A,DIODE-BAV99-3P-SOT23-TAP-PHP CPQ; room: Sheet67
D2201 D2202 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P,6011B0131701,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet61
D2603 D2615 D2618 D2619 = ESD: part number: ESD-SEMTECH_RCLAMP2451ZATFT_2P,6011B0328301,DS_060X030X025_2_043,0.35MM,,DIODE,ESD,24V,3A,60W,0.45PF,SMD,RCLAMP2451ZATFT,TR; room: Sheet53
D2604 D2605 D2806 D2807 = ESD: part number: ESD-SEMTECH_RCLAMP2451ZATFT_2P,6011B0328301,DS_060X030X025_2_043,0.35MM,,DIODE,ESD,24V,3A,60W,0.45PF,SMD,RCLAMP2451ZATFT,TR; room: Sheet55
D2606 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1143_04F_R7G_10P,6011B0276801,DS_250X100X055_10_050_P2,0.65MM,,DIODE-ESD,12V,0.45PF,16K/18K,DFN2510P10E,SMD,TR; signal model: D10_6011B0276801_AMAZING_AZ1143_04F_R7G_10P; room: Sheet55
D2611 = DIODE_SCH: part number: DIODE_SCH-SS3040HE,6011B0157601,DSSOD123_280X180X100_2,1.15MM,DIODE_SCH,DIODE,40V,3A,1.4W,SMD,SOD-123HE,TR; room: Sheet54
D2612 = DIODE_SCH: part number: DIODE_SCH-SS3040HE,6011B0157601,DSSOD123_280X180X100_2,1.15MM,DIODE_SCH,DIODE,40V,3A,1.4W,SMD,SOD-123HE,TR; room: Sheet56
D2614 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1143_04F_R7G_10P,6011B0276801,DS_250X100X055_10_050_P2,0.65MM,,DIODE-ESD,12V,0.45PF,16K/18K,DFN2510P10E,SMD,TR; signal model: D10_6011B0276801_AMAZING_AZ1143_04F_R7G_10P; room: Sheet53
D2700 = SWCH_SINGLE: part number: SWCH_SINGLE-1N4148WS,6011B0157401,DSOD323_185X125X095_2_231,1.05MM,SWCH_SINGLE,,,DIODE,SWCH,100V,200MA,250MW,4NS,SMD,SOD323,TR; room: Sheet50
D2813-D2820 = ESD: part number: ESD-AMAZING_AZ5B8S_01F_R7G_2P,6011B0335001,DESD_060X030X032_2_040,0.42MM,,DIODE-ESD,5.5V,0.18PF,15K/12K,DFN0603P2Y,SMD,TR; room: Sheet55
D2900-D2907 = ESD: part number: ESD-AMAZING_AZ5B8S_01F_R7G_2P,6011B0335001,DESD_060X030X032_2_040,0.42MM,,DIODE-ESD,5.5V,0.18PF,15K/12K,DFN0603P2Y,SMD,TR; room: Sheet53
D3001 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A,6011B0155101,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet58
D4300 D4301 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P,6011B0131701,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet30
D4702 = SCH_DUAL_1IN_2OUT: part number: SCH_DUAL_1IN_2OUT-BAT54A,6011A0003101,DSOT23_290X130X110_3_095_P2,1.25MM,SCH_DUAL_1IN_2OUT,DIODE-SCH-BAT54A-SOT23-TAP-PHP; room: Sheet27
D4750 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A,6011B0155101,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet41
D4920 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP_NP,60110GA0367T_NP,DSOT23_290X130X110_3_095_NP,0.0003MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet31
D6035 = AZ4012_02S: part number: AZ4012_02S-AMC_AZ4024_02S_3P,6011B0157001,DSOT23_290X130X115_3_095,1.30MM,,DIODE,ESD,24V,5.5A,SMD,SOT-23,TR; room: Sheet25
D7002 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP,60110GA0367T,DSOT23_290X130X110_3_095_P3,1.2MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet27
D7400 = SCH_DUAL_1IN_2OUT: part number: SCH_DUAL_1IN_2OUT-BAT54A,6011A0003101,DSOT23_290X130X110_3_095_P2,1.25MM,SCH_DUAL_1IN_2OUT,DIODE-SCH-BAT54A-SOT23-TAP-PHP; room: Sheet28
D7500 D7504 D7505 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P,6011B0131701,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet25
D9200 D9201 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1143_04F_R7G_10P,6011B0276801,DS_250X100X055_10_050_P2,0.65MM,,DIODE-ESD,12V,0.45PF,16K/18K,DFN2510P10E,SMD,TR; signal model: D10_6011B0276801_AMAZING_AZ1143_04F_R7G_10P; room: Sheet80
D9202 D9203 = AZ1045_04F_R7G: part number: AZ1045_04F_R7G-AMAZING_AZ1143_04F_R7G_10P,6011B0276801,DS_250X100X055_10_050_P2,0.65MM,,DIODE-ESD,12V,0.45PF,16K/18K,DFN2510P10E,SMD,TR; signal model: D10_6011B0276801_AMAZING_AZ1143_04F_R7G_10P; room: Sheet81
D9204-D9206 = AZ5125_01H: part number: AZ5125_01H-AMC_AZ5125_01H_SOD523_2P,6011B0131701,DSOD523_120X080X070_2_150_P2,0.8MM,,DIODE,ESD,5V,SMD,SOD523,TR; room: Sheet82
D60031 D60097 D60098 = SWCH_SINGLE: part number: SWCH_SINGLE-1N4148WS,6011B0157401,DSOD323_185X125X095_2_231,1.05MM,SWCH_SINGLE,,,DIODE,SWCH,100V,200MA,250MW,4NS,SMD,SOD323,TR; room: Sheet7
D60099 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C_30V_0_6A,6011B0155101,DS_292X130X110_3_190,1.25MM,SCH_DUAL_2IN_1OUT_A,,,DIODE,SCH,30V,0.6A,225MW,DIP,SOT-23,TR; room: Sheet7
D68200 = DIODE_ZN: part number: DIODE_ZN-PANJIT_PDZ5.1B,6011B0197701-001,CHROMIA-6011B0197701-001,1.05MM,,DIODE-ZNR,5.1V,400MW,SMD,SOD323,TR; room: Sheet8
F300 = POLY_SWCH: part number: POLY_SWCH-LITTELFUSE_0805L110ULYR,6036B0139401,FUSE_210X135X075_2_220,0.85MM,POLY_SWCH,FUSE,POLYMER,1.1A,6V,SMD,2.2X1.50,TR; room: Sheet64
F2200 = POLY_SWCH: part number: POLY_SWCH-LITTELFUSE_0805L110ULYR,6036B0139401,FUSE_210X135X075_2_220,0.85MM,POLY_SWCH,FUSE,POLYMER,1.1A,6V,SMD,2.2X1.50,TR; room: Sheet61
F2500 = POLY_SWCH: part number: POLY_SWCH-LITTELFUSE_0805L110ULYR,6036B0139401,FUSE_210X135X075_2_220,0.85MM,POLY_SWCH,FUSE,POLYMER,1.1A,6V,SMD,2.2X1.50,TR; room: Sheet57
F3000 F3001 = POLY_SWCH: part number: POLY_SWCH-LITTELFUSE_0805L110ULYR,6036B0139401,FUSE_210X135X075_2_220,0.85MM,POLY_SWCH,FUSE,POLYMER,1.1A,6V,SMD,2.2X1.50,TR; room: Sheet59
F3002 = POLY_SWCH: part number: POLY_SWCH-LITTELFUSE_0805L110ULYR,6036B0139401,FUSE_210X135X075_2_220,0.85MM,POLY_SWCH,FUSE,POLYMER,1.1A,6V,SMD,2.2X1.50,TR; room: Sheet58
F3003 = POLY_SWCH: part number: POLY_SWCH-1.1A_24V,6036B0188001-002,ALOE20-6036B0188001-002,1.17MM,POLY_SWCH,FUSE-POLYMER-1.1A-24V-SMD-4.47X3.41-TAP; room: Sheet58
F4350 = POLY_SWCH: part number: POLY_SWCH-LITTELFUSE_0805L110ULYR,6036B0139401,FUSE_210X135X075_2_220,0.85MM,POLY_SWCH,FUSE,POLYMER,1.1A,6V,SMD,2.2X1.50,TR; room: Sheet68
FIX1-FIX8 = FIX_MASK: part number: FIX_MASK-FIX_MASK_0.8,FIX_MASK_0.8,FIX_MASK_080,0.127MM,FIX_MASK,FIX_MASK_0.8; room: Sheet74
FIX9200-FIX9207 = FIX_MASK: part number: FIX_MASK-FIX_MASK_0.8,FIX_MASK_0.8,FIX_MASK_080,0.127MM,FIX_MASK,FIX_MASK_0.8; room: Sheet79
FIX9350 FIX9351 = FIX_MASK: part number: FIX_MASK-FIX_MASK_0.8,FIX_MASK_0.8,FIX_MASK_080,0.127MM,FIX_MASK,FIX_MASK_0.8; room: Sheet83
JACK9200 = 2SJ3166_026111F: part number: 2SJ3166_026111F-SINGATRON_2SJ3166_026111F_6P,6026B0471301,AUDIO_SIGAT_6_R_140_390_1,4.2MM,,JACK,AUDIO,GRAY,0.7MM,PA4T,6P,1.4/3.9MM,GOLD FLASH,NONTAB,DIP,TR; room: Sheet82
L2700 = CHOKE_4PIN: part number: CHOKE_4PIN-DLM0QSN900HY2D,6014B0381501,LS_065X050X035_4_050,0.45MM,CHOKE_4PIN,,,,CHOKE, 90OHM ,25%, 50MA, 0201, 4OHM, 100MHZ, 4P, TR; signal model: L4_6014B0381501_DLM0QSN900HY2D; room: Sheet50
L2701 = CHOKE_2PIN: part number: CHOKE_2PIN-CYNTEC_CMMB041B_R68MS,6014B0372101,LS_440X420X120_2_370,1.30MM,CHOKE_2PIN,,,,COIL, 0.68UH, 20%, 100KHZ, 6.5A, TR, 4.75X4.45X1.2MM; signal model: L2_6014B0372101_CYNTEC_CMMB041B_R68MS; room: Sheet51
L3000 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF08062G900_T,6014B0378101-001,TRYPTICO-6014B0378101-001,0.55MM,CHOKE_4PIN_C,CHOKE, 90OHM ,20%, 100MA, 0302, 5 OHM, 100MHZ, 4P, TR; signal model: L4_6014B0378101-001_MCF08062G900_T; room: Sheet59
L4555 = CHOKE_4PIN: part number: CHOKE_4PIN-DLM0QSN900HY2D,6014B0381501,LS_065X050X035_4_050,0.45MM,CHOKE_4PIN,,,,CHOKE, 90OHM ,25%, 50MA, 0201, 4OHM, 100MHZ, 4P, TR; signal model: L4_6014B0381501_DLM0QSN900HY2D; room: Sheet41
L6035 L6036 = BEAD_SINGLE: part number: BEAD_SINGLE-120OHM_25%_3A,6014B0172701,LS_160X080X095_2,1.1MM,BEAD_SINGLE,,,,BEAD,120OHM,25%,3A,0.04OHM,0603INCH,100MHZ,C,TR; signal model: L2_6014B0172701_120OHM_25%_3A; room: Sheet25
L7500-L7503 = RFL11T2SA2AR: part number: RFL11T2SA2AR-RFL11T2SA2AR,TMP171013002,LS_100X125X090_6,1MM,,RADIO-FREQUENCY COMMON-MODE FILTER 6P; room: Sheet58
L9200 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF08062G900_T,6014B0378101-002,SILVERBE-6014B0378101-002,0.55MM,CHOKE_4PIN_C,CHOKE, 90OHM ,20%, 100MA, 0302, 5 OHM, 100MHZ, 4P, TR; signal model: L4_6014B0378101-002_MCF08062G900_T; room: Sheet80
L9201 = CHOKE_4PIN_C: part number: CHOKE_4PIN_C-MCF08062G900_T,6014B0378101-002,SILVERBE-6014B0378101-002,0.55MM,CHOKE_4PIN_C,CHOKE, 90OHM ,20%, 100MA, 0302, 5 OHM, 100MHZ, 4P, TR; signal model: L4_6014B0378101-002_MCF08062G900_T; room: Sheet81
L60000 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-PCMB103T_1R0MS,6014B0127301,LS_1000X1000X300_4_P2,3.10MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,1.0UH,20%,100KHZ,13A,10.85X10X2.8MM,SMD,TR; signal model: L4_6014B0127301_PCMB103T_1R0MS; room: Sheet7
L60100 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T-1R5MN,6014B0026101-007,LADYLUCK-6014B0026101-007,3.15MM,IDUT_SINGLE,,,,INDUCTOR,1.5UH,20%,100KHZ,9A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026101-007_PCMC063T-1R5MN; room: Sheet12
L60200 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T-1R5MN,6014B0026101-007,LADYLUCK-6014B0026101-007,3.15MM,IDUT_SINGLE,,,,INDUCTOR,1.5UH,20%,100KHZ,9A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026101-007_PCMC063T-1R5MN; room: Sheet10
L60250 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T_2R2MN,6014B0026106,LS_700X660X300_2_555,3.1MM,IDUT_SINGLE,,,,INDUCTOR,2.2UH,20%,100KHZ,8A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026106_PCMC063T_2R2MN; room: Sheet11
L60300 = IDUT_4PIN: part number: IDUT_4PIN-CYN_PCMC063T_R68MN_4P,6014B0026107,LS_660X660X300_4_P3,3.1MM,IDUT_4PIN,,,,INDUCTOR,0.68UH,20%,100KHZ,15.5A,7.3X6.6X3.0MM,SMD,TR; signal model: L4_6014B0026107_CYN_PCMC063T_R68MN_4P; room: Sheet13
L60400 = INDUCTOR: part number: INDUCTOR-TAI_TECH_HPC4018B_2R2M,6014B0271901,LS_400X400X180_2_280,1.95MM,,,,,INDUCTOR,2.2UH,+/-20%,100KHZ,2.2A,4.0X4.0X1.8MM,SMD,TR; signal model: L2_6014B0271901_TAI_TECH_HPC4018B_2R2M; room: Sheet14
L60500 = IDUT_4PIN: part number: IDUT_4PIN-CYN_PCMC063T_R68MN_4P,6014B0026107,LS_660X660X300_4_P3,3.1MM,IDUT_4PIN,,,,INDUCTOR,0.68UH,20%,100KHZ,15.5A,7.3X6.6X3.0MM,SMD,TR; signal model: L4_6014B0026107_CYN_PCMC063T_R68MN_4P; room: Sheet18
L60600 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T-1R5MN,6014B0026101-007,LADYLUCK-6014B0026101-007,3.15MM,IDUT_SINGLE,,,,INDUCTOR,1.5UH,20%,100KHZ,9A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026101-007_PCMC063T-1R5MN; room: Sheet15
L60900 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T-1R5MN,6014B0026101-007,LADYLUCK-6014B0026101-007,3.15MM,IDUT_SINGLE,,,,INDUCTOR,1.5UH,20%,100KHZ,9A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026101-007_PCMC063T-1R5MN; room: Sheet17
L61400 = IDUT_4PIN: part number: IDUT_4PIN-CYN_PCMC063T_R68MN_4P,6014B0026107,LS_660X660X300_4_P3,3.1MM,IDUT_4PIN,,,,INDUCTOR,0.68UH,20%,100KHZ,15.5A,7.3X6.6X3.0MM,SMD,TR; signal model: L4_6014B0026107_CYN_PCMC063T_R68MN_4P; room: Sheet19
L61700 = INDUCTOR: part number: INDUCTOR-TAI_TECH_HPC4018B_2R2M,6014B0271901,LS_400X400X180_2_280,1.95MM,,,,,INDUCTOR,2.2UH,+/-20%,100KHZ,2.2A,4.0X4.0X1.8MM,SMD,TR; signal model: L2_6014B0271901_TAI_TECH_HPC4018B_2R2M; room: Sheet16
L66010 L66020 L66030 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-MAGIC_SRPG0603_R15M_AD_D98E,6014B0444501,LS_730X680X300_4,3.1MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.15UH,+-20%,100KHZ,32A,7.6X7.1X3.0MM,SMD,TR; signal model: L4_6014B0444501_MAGIC_SRPG0603_R15M_AD_D98E; room: Sheet21
L66310 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-MAGIC_SRPG0603_R15M_AD_D98E,6014B0444501,LS_730X680X300_4,3.1MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.15UH,+-20%,100KHZ,32A,7.6X7.1X3.0MM,SMD,TR; signal model: L4_6014B0444501_MAGIC_SRPG0603_R15M_AD_D98E; room: Sheet22
L66610 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-CYN_PCMB063T_R33MS_4P,6014B0151507,LS_660X660X300_4_P3,3.1MM,CHOKE_4PIN_2PIN,,,,INDUCTOR,0.33UH,20%,100KHZ,21A,6.95X6.6X2.8MM; signal model: L4_6014B0151507_CYN_PCMB063T_R33MS_4P; room: Sheet23
MIC9350 MIC9352 = SPK0838HT4H_B: part number: SPK0838HT4H_B-KNOWLES_SPK0838HT4H_1_8P,6039B0094401,MICP_KNOW_8_100_2,1.25MM,,MIC,MODULE,4*3*1MM,8PIN; room: Sheet83
PAD300 PAD310 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet62
PAD60000 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet7
PAD60100 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet12
PAD60110 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet12
PAD60200 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet10
PAD60210 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet10
PAD60250 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet11
PAD60260 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet11
PAD60300 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet13
PAD60310 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet13
PAD60350 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet13
PAD60400 PAD60410 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet14
PAD60500 PAD60510 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet18
PAD60600 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet15
PAD60610 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet15
PAD60900 = POWERPAD_4_0610: part number: POWERPAD_4_0610-POWERPAD_4_0610,POWERPAD_4_0610,POWERPAD_4_0610_SHORT,0.127MM,POWERPAD_4,POWERPAD_4_0610; room: Sheet17
PAD60910 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet17
PAD61410 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet19
PAD61499 = POWERPAD_2: part number: POWERPAD_2-POWERPAD2X2M,POWERPAD2X2M,POWERPAD2X2M,0.559MM,POWERPAD_2,POWERPAD2X2M; room: Sheet19
PAD61710 PAD61799 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet16
PAD66010 PAD66020 PAD66030 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0805,POWERPAD_2_0805,POWERPAD_2_0805,0.45MM,POWERPAD_2,POWERPAD_2_0805; room: Sheet21
PAD66310 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0805,POWERPAD_2_0805,POWERPAD_2_0805,0.45MM,POWERPAD_2,POWERPAD_2_0805; room: Sheet22
PAD66610 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0805,POWERPAD_2_0805,POWERPAD_2_0805,0.45MM,POWERPAD_2,POWERPAD_2_0805; room: Sheet23
Q300 = PMOS_A: part number: PMOS_A-PM513BA,6015B0145801,TSOT23_292X130X120_3_095,1.35MM,,TRANSISTOR-FET,PEMOS,20V,3A,SOT23,3P,TR; room: Sheet64
Q301 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet64
Q302 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet62
Q303 Q305 Q307 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet64
Q500 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet70
Q1000 Q1003 Q1004 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet72
Q1001 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet72
Q1002 Q7000 Q7300 Q7306 Q7307 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet27
Q1300 Q1302 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet66
Q1301 Q1304 = NMOS_C: part number: NMOS_C-L2N7002SWT1G,6015B0205901,SC70_200X125X100_3_065,1.1MM,NMOS_C,TRANSISTOR-FET,NEMOS,60V,380MA,SC-70,3P,TR; room: Sheet66
Q1307 = FDC638APZ: part number: FDC638APZ-DIODES_DMP2035UVT_7_TSOT26_6P,6015B0146601,TSOT26_290X160X100_6_095,1.15MM,TRANSISTOR-FET,PEMOS,20V,6A,TSOT26,6P,TR; room: Sheet66
Q1400 Q1401 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet67
Q1951 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet60
Q2600 = PMOS_4D3S: part number: PMOS_4D3S-SYNNEX_SM3303PSQG,6015B0205301,MOSFET_300X300X100_8_065,1.1MM,PMOS_4D3S,,,TRANSISTOR-FET,PEMOS,-30V,-17.1A,DFN,8P,TR; room: Sheet56
Q2601 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet54
Q2602 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet56
Q2603 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet56
Q2605 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet56
Q2607 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet54
Q2609 = PMOS_4D3S: part number: PMOS_4D3S-SYNNEX_SM3303PSQG,6015B0205301,MOSFET_300X300X100_8_065,1.1MM,PMOS_4D3S,,,TRANSISTOR-FET,PEMOS,-30V,-17.1A,DFN,8P,TR; room: Sheet54
Q2613 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet54
Q2620 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet65
Q2701 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet50
Q3000 = PMOS_A: part number: PMOS_A-PM513BA,6015B0145801,TSOT23_292X130X120_3_095,1.35MM,,TRANSISTOR-FET,PEMOS,20V,3A,SOT23,3P,TR; room: Sheet58
Q3001 Q3005 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet58
Q3003 Q3004 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet58
Q3800 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet73
Q4300 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet30
Q4411 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet29
Q4412 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet29
Q4750 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet35
Q4751 Q4752 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet34
Q4754 Q4755 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet40
Q4756 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet40
Q4921 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P_NP,6015B0163301_NP,SOT723_120X080X055_3_040_NP,0.0003MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet31
Q7001 = FDC638APZ: part number: FDC638APZ-PJS6416_6P,6015B0185601,SOT23_290X160X115_6_095,1.25MM,TRANSISTOR-FET,PMOS,20V,5.2A,SOT-23,6P,TR; room: Sheet26
Q7002 Q7003 Q7005 = NMOS_2D2S_DIODE: part number: NMOS_2D2S_DIODE-PJX138K,6015B0170401,SOT563_160X120X060_6_050_P3,0.7MM,,TRANSISTOR-FET,NEMOS,50V,350MA,SOT-563,6P,TR; room: Sheet26
Q7004 = NMOS: part number: NMOS-LN2312LT1G,6015B0143801,SOT23_290X130X110_3_095_P2,1.25MM,NMOS,,,TRANSISTOR-FET,NEMOS,20V,4.9A,SOT-23,3P,TR; room: Sheet26
Q7006 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet26
Q7011 = NMOS_C: part number: NMOS_C-TOSHIBA_SSM3K15AMFV_3P,6015B0163301,SOT723_120X080X055_3_040_P3,0.65MM,NMOS_C,TRANSISTOR-FET,NEMOS,30V,100MA,SOT-723,3P; room: Sheet27
Q7151 Q7153 = NMOS_4D1S: part number: NMOS_4D1S-ALPHA_AO6424L_TSOP_6P,6015B0135001,TSOP_290X160X125_6_095,1.4MM,NMOS_4D1S,TSOP,5A,TRANSISTOR-FET,NEMOS,30,5A,TSOP-6L,6P,TR; room: Sheet27
Q7154 = NMOS: part number: NMOS-LN2312LT1G,6015B0143801,SOT23_290X130X110_3_095_P2,1.25MM,NMOS,,,TRANSISTOR-FET,NEMOS,20V,4.9A,SOT-23,3P,TR; room: Sheet27
Q7159 = NMOS_4D1S: part number: NMOS_4D1S-EXCELLIANCE_MOS_EMB32N03K,6015B0263301,TSOT23_290X160X110_6_095,1.2MM,NMOS_4D1S,,,TRANSISTOR-FET,NEMOS,30V,5.5A,TSOP-6L,6P,TR; room: Sheet27
Q60000 Q60001 = NMOS_4D3S: part number: NMOS_4D3S-AON6380,6015B0196301,MOSFET_500X600X100_8_127,1.1MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,24A,DFN5X6,8P,TR; room: Sheet7
Q60002 Q60003 = NMOS_4D3S: part number: NMOS_4D3S-AOS_AONR36368,6015B0230101,MOSFET_300X300X080_8_065,0.9MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,23A,DFN,8P,TR; room: Sheet7
Q60010 = PMOS_4D3S_A: part number: PMOS_4D3S_A-SM3335PSQGC_TRG,6015B0166601,MOSFET_300X300X100_8_065,1.1MM,,SINOPOWER; room: Sheet7
Q60012 = NMOS_4D3S: part number: NMOS_4D3S-EMC_EMB07N03V,6015B0252601,MOSFET_300X300X090_8_065,1MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,15A,DFN3X3A,8P,TR; room: Sheet7
Q60032 Q60035 = NMOS_C: part number: NMOS_C-L2N7002SWT1G,6015B0205901,SC70_200X125X100_3_065,1.1MM,NMOS_C,TRANSISTOR-FET,NEMOS,60V,380MA,SC-70,3P,TR; room: Sheet7
Q60033 Q60034 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet7
Q68000 = PNP_A: part number: PNP_A-YEL_LMBT3906LT1G_SOT23_3P,6015B0048101,TSSOT23_292X130X111_3_095,1.26MM,PNP_A,,,TRANSISTOR,PNP,40V,200MA,SOT23,3P,TR; room: Sheet9
Q68051 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet9
Q68054 Q68098 = NMOS_C: part number: NMOS_C-L2N7002SWT1G,6015B0205901,SC70_200X125X100_3_065,1.1MM,NMOS_C,TRANSISTOR-FET,NEMOS,60V,380MA,SC-70,3P,TR; room: Sheet9
Q68100 Q68101 Q68106 = PMOS_4D3S_A: part number: PMOS_4D3S_A-SM3335PSQGC_TRG,6015B0166601,MOSFET_300X300X100_8_065,1.1MM,,SINOPOWER; room: Sheet8
Q68102 Q68105 Q68107 = PMBT3906YS: part number: PMBT3906YS-NXP_PMBT3906YS_TSOT363_6P,6015B0154001,TSOT363_200X125X110_6_065_3,1.25MM,,TRANSISTOR,DUAL PNP,-40V,200MA,SOT363,6P; room: Sheet8
Q68103 Q68104 Q68108 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet8
Q68120 Q68121 = PNP_A: part number: PNP_A-YEL_LMBT3906LT1G_SOT23_3P,6015B0048101,TSSOT23_292X130X111_3_095,1.26MM,PNP_A,,,TRANSISTOR,PNP,40V,200MA,SOT23,3P,TR; room: Sheet7
R100 = RSC_0201: part number: RSC_0201-47_5%_1,6013B0110456,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,47,5%,1/20W,0201,TR; signal model: R2_6013B0110456_47_5%_1; room: Sheet62
R101 R103 R303 R322 R324 R334 R341 R352 R368 R369 R396 R406 R418 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet62
R129 = RSC_0201: part number: RSC_0201-470K_1%_1,6013B01104AK,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,470K,1%,1/20W,0201,TR; signal model: R2_6013B01104AK_470K_1%_1; room: Sheet62
R200 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet68
R300 R302 R443 R444 = RSC_0201: part number: RSC_0201-300_5%_1,6013B0459501,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP-300_5%_1/20W-0201-TAP; signal model: R2_6013B0459501_300_5%_1; room: Sheet62
R301 R374 R377 R398 R420 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet62
R304 R305 R390 R419 R421 = RSC_0201: part number: RSC_0201-33_5%_1,6013B0110459,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,33,5%,1/20W,0201,TR; signal model: R2_6013B0110459_33_5%_1; room: Sheet62
R306 R307 R310 R311 R397 = RSC_0201: part number: RSC_0201-2.2K_5%_1,6013B0110418,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,2.2K,5%,1/20W,0201,TR; signal model: R2_6013B0110418_2_2K_5%_1; room: Sheet62
R308 R319 R323 R335 R340 R358 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet32
R309 = RSC_0402: part number: RSC_0402-34K_1%_2,6013A0092501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-34K-1%-1/16W-0402-TAP; signal model: R2_6013A0092501_34K_1%_2; room: Sheet63
R312-R314 R367 R422 R425 R442 R4790 R4793-R4796 = RSC_0201: part number: RSC_0201-22_5%_1,6013B01104AH,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,22,5%,1/20W,0201,TR; signal model: R2_6013B01104AH_22_5%_1; room: Sheet62
R315 R317 R320 R357 R385 R387 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet63
R316 R439-R441 = RSC_0201: part number: RSC_0201-4.7_5%_1,6013B0110403,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7,5%,1/20W,0201,TR; signal model: R2_6013B0110403_4_7_5%_1; room: Sheet62
R318 R325 R354 R391 R394 R426 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet62
R321 = RSC_0201: part number: RSC_0201-20K_5%_1,6013B0110499,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,20K,5%,1/20W,0201,TR; signal model: R2_6013B0110499_20K_5%_1; room: Sheet63
R326 R329 R342 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet63
R327 = RSC_0402: part number: RSC_0402-470K_1%_2,6013A0051501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-1%-1/16W-0402-TAP; signal model: R2_6013A0051501_470K_1%_2; room: Sheet62
R328 = RSC_0201: part number: RSC_0201-43_5%_1,6013B0193301,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,43,5%,1/20W,0201,TR; signal model: R2_6013B0193301_43_5%; room: Sheet63
R330 R433 R434 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet63
R331 R355 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet62
R332 R333 R415 R2513 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet63
R336-R339 = RSC_0201: part number: RSC_0201-15_5%_1,6013B0395401,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,15,5%,1/20W,0201,TR; signal model: R2_6013B0395401_15_5%_1; room: Sheet32
R343 R362 R393 R404 R407 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet64
R344 R346 = RSC_0201: part number: RSC_0201-3.3K_5%_1,6013B0154401,RSC_060X030X026_2,0.41MM,RSC_0201,RES-CHIP-3.3K_5%_1-1/20W-0201-TAP; signal model: R2_6013B0154401_3_3K_5%_1; room: Sheet62
R345 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet62; signal model: R2_60130B0000ZT_DY_0_5%_2_DY
R347 R359 R384 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet62
R348 R349 R380 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet63
R350 R370 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet62
R351 R372 R376 R378 R389 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet64
R353 R360 R361 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet62
R356 R375 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet62
R364 R365 = RSC_0201: part number: RSC_0201-470_5%_1,6013B0110405,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,470,5%,1/20W,0201,TR; signal model: R2_6013B0110405_470_5%_1; room: Sheet64
R366 R371 R388 R392 = RSC_0402: part number: RSC_0402-200_5%_2,6013A0051201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200-5%-1/16W-0402-TAP; signal model: R2_6013A0051201_200_5%_2; room: Sheet64
R373 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet62
R379 = RSC_0402: part number: RSC_0402-2.2_5%_2,6013B0137701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2.2,5%,1/16W,0402,TR; signal model: R2_6013B0137701_2_2_5%_2; room: Sheet62
R381 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet62
R382 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet64
R383 R386 R428 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet63
R395 = RSC_0201: part number: RSC_0201-10_5%_1,6013B0110483,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10,5%,1/20W,0201,TR; signal model: R2_6013B0110483_10_5%_1; room: Sheet32
R399 R402 = RSC_0201: part number: RSC_0201-200K_5%_1,6013B0110463,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,200K,5%,1/20W,0201,TR; signal model: R2_6013B0110463_200K_5%_1; room: Sheet64
R400 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet64
R401 R409 R410 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet64
R403 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet64
R405 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet62
R408 R411 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet64
R413 R435 = RSC_0402: part number: RSC_0402-560_5%_2,60130B56100Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-560-5%-1/16W-0402-TAP; signal model: R2_60130B56100Y_560_5%_2; room: Sheet69
R417 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet32
R423 = RSC_0201: part number: RSC_0201-1M_5%_1,6013B0110474,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1M,5%,1/20W,0201,TR; signal model: R2_6013B0110474_1M_5%_1; room: Sheet62
R424 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet63
R430 R432 = RSC_0201: part number: RSC_0201-100K_1%_1,6013B0110479,RSC_060X030X030_2,0.45MM,RSC_0201,RESISTOR-CHIP,100K,1%,1/20W,0201,TR; signal model: R2_6013B0110479_100K_1%_1; room: Sheet62
R431 = RSC_0402: part number: RSC_0402-806K_1%_2,6013A0089009,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-806K-1%-1/16-0402-TAP; signal model: R2_6013A0089009_806K_1%_2; room: Sheet62
R445 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet64
R449 = RSC_0402: part number: RSC_0402-22K_5%_2,60130B22300Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22K-5%-1/16W-0402-TAP; signal model: R2_60130B22300Y_22K_5%_2; room: Sheet63
R500 R506 R516 R518 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet70
R501 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet70
R502 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet70
R503 R517 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet70
R504 = RSC_0201: part number: RSC_0201-33_5%_1,6013B0110459,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,33,5%,1/20W,0201,TR; signal model: R2_6013B0110459_33_5%_1; room: Sheet70
R505 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet70
R507 = RSC_0201: part number: RSC_0201-1K_5%_1,6013B0110477,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1K,5%,1/20W,0201,TR; signal model: R2_6013B0110477_1K_5%_1; room: Sheet70
R508 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet70
R509 R510 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_40_NSP,SHORT_0805_40_NSP,RSC_200X125X115_2_40_SHORT_NSP,0.127MM,RSC_SHORT,SHORT_0805_40_NSP; signal model: R2_short_0805_40_nsp_short_0805_40_nsp; room: Sheet70
R511 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet70
R512 R514 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet70
R513 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50_NSP,SHORT_0805_50_NSP,RSC_200X125X115_2_50_SHORT_NSP,0.0003MM,RSC_SHORT,SHORT_0805_50_NSP; signal model: R2_Short_0805_50_NSP_Short_0805_50_NSP; room: Sheet70
R515 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet70
R519 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet70
R520 R521 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet70
R550 R551 R566 R567 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet71
R906 = RSC_0402: part number: RSC_0402-51.1K_1%_2,6013A0073501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51.1K-1%-1/16W-0402-TAP; signal model: R2_6013A0073501_51_1K_1%_2; room: Sheet63
R1000 R1002 R1003 R1021 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet72
R1001 R1004 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet72
R1005 R1006 R1010 R1013 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet72
R1007 R1019 = RSC_0201: part number: RSC_0201-10K_5%_1,6013B0110476,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10K,5%,1/20W,0201,TR; signal model: R2_6013B0110476_10K_5%_1; room: Sheet72
R1008 = RSC_0201: part number: RSC_0201-1M_5%_1,6013B0110474,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,1M,5%,1/20W,0201,TR; signal model: R2_6013B0110474_1M_5%_1; room: Sheet72
R1009 = RSC_0201: part number: RSC_0201-10M_5%_1,6013B0110473,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,10M,5%,1/20W,0201,TR; signal model: R2_6013B0110473_10M_5%_1; room: Sheet72
R1011 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet72
R1012 R1018 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet72
R1014 R1017 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet27
R1015 = RSC_0402: part number: RSC_0402-220K_1%_2,60130B22039Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-1%-1/16W-0402-TAP; signal model: R2_60130B22039Z_220K_1%_2; room: Sheet27
R1016 = RSC_0402: part number: RSC_0402-110K_1%_2,60130B11039Y,RSC_100X050X040_2,0.5MM,RSC_0402,0402,RES-CHIP-110K-1%-1/16-0402-TR; signal model: R2_60130B11039Y_110K_1%_2; room: Sheet27
R1300 R4533 R4539 R4543 R4562 R4703 R4724 R4727 R4754 R4763 R4766 R4768 R4771 R4772 R4774 R4809 R4918 = RSC_0201: part number: RSC_0201-100K_5%_1,6013B0110475,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,100K,5%,1/20W,0201,TR; signal model: R2_6013B0110475_100K_5%_1; room: Sheet35
R1301 R1306 R1336 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet66
R1302 = RSC_0402: part number: RSC_0402-150_1%_2,60130B15009Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-1%-1/16W-0402-TAP; signal model: R2_60130B15009Y_150_1%_2; room: Sheet66
R1303 R1308 R1317 R1347 R1349 R1351 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet66
R1304 R1305 R1307 R1342 R1346 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet66
R1309 R1345 R4905 R4908 = RSC_0201: part number: RSC_0201-20K_5%_1,6013B0110499,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,20K,5%,1/20W,0201,TR; signal model: R2_6013B0110499_20K_5%_1; room: Sheet66
R1310 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_5,SHORT_0201_5,RSC_060X030X030_2_5_SHORT,0.127MM,RSC_SHORT,SHORT_0201_5; signal model: R2_short_0201_5_short_0201_5; room: Sheet66
R1312-R1314 R1316 = RSC_0201: part number: RSC_0201-22_1%_1,6013B0155201,RSC_060X030X026_2,0.36MM,RSC_0201,RESISTOR-CHIP,22,1%,1/20W,0201,TR; signal model: R2_6013B0155201_22_1%_1; room: Sheet66
R1315 = RSC_SHORT: part number: RSC_SHORT-SHORT_0805_50,SHORT_0805_50,RSC_200X125X115_2_50_SHORT,0.127MM,RSC_SHORT,SHORT_0805_50; signal model: R2_short_0805_50_short_0805_50; room: Sheet66
R1318-R1329 R1334 R1335 R1338 R1339 = RSC_SHORT: part number: RSC_SHORT-SHORT_0201_10,SHORT_0201_10,RSC_060X030X030_2_10_SHORT,0.127MM,RSC_SHORT,RSC_060X030X030_2_10_SHORT; signal model: R2_SHORT_0201_10_SHORT_0201_10; room: Sheet66
R1332 = RSC_0402: part number: RSC_0402-71.5K_1%_2,6013A008860K,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-71.5K_1%-1/16W-0402-TAP; signal model: R2_6013A008860K_71_5K_1%_2; room: Sheet66
R1333 R1344 = RSC_0201: part number: RSC_0201-4.7K_5%_1,6013B0110407,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,4.7K,5%,1/20W,0201,TR; signal model: R2_6013B0110407_4_7K_5%_1; room: Sheet66
R1337 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet66
R1343 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet66
