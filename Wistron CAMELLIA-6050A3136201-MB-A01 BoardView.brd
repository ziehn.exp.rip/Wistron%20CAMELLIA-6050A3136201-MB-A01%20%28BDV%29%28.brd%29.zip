# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Library data of the parts (continued)
R9205 R9221-R9223 R9225-R9229 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet81
R9208 R9210-R9215 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet80
R9217 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.127MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet82
R9219 = RSC_0402: part number: RSC_0402-4.99K_1%_2,6013A0015201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.99K-1%-1/16W-0402-TAP; signal model: R2_6013A0015201_4_99K_1%_2; room: Sheet81
R9220 R9224 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet81
R9230 R9231 = RSC_0402: part number: RSC_0402-30_5%_2,6013B0094201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,30,5%,1/16W,0402,TAP; signal model: R2_6013B0094201_30_5%_2; room: Sheet82
R9300-R9303 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet85
R9304 = RSC_0201: part number: RSC_0201-0_5%_1_NSP,6013B0111001_NSP,RSC_060X030X030_2_NSP,0.0003MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_NPS_0_5%_1_NSP; room: Sheet84
R9305 = RSC_0201: part number: RSC_0201-0_5%_1,6013B0111001,RSC_060X030X030_2,0.45MM,RSC_0201,RES-CHIP,0,5%,1/20W,0201,TR; signal model: R2_6013B0111001_0_5%_1; room: Sheet84
R9350 R9352 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet83
R60000 = RSC_1206_4PIN: part number: RSC_1206_4PIN-0.01_1%_6,6013B0109401,RSC_320X160X089_4_P2,0.989MM,RSC_1206_4PIN,RES-M/F,0.01,1%,1W,1206,TR; signal model: R4_6013B0109401_0_01_1%_6; room: Sheet7
R60001 = RSC_1206_4PIN: part number: RSC_1206_4PIN-0.005_1%_6,6013B2223101,RSC_320X160X085_4,0.95MM,RSC_1206_4PIN,RESISTOR-M/F,0.005,1%,1W,1206,TR; signal model: R4_6013B2223101_0_005_1%_6; room: Sheet7
R60002 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet7
R60003 = RSC_0603: part number: RSC_0603-4.7_5%_3,60130B4R700T-002,REBORN-60130B4R700T-002,0.95MM,RSC_0603,0603,RES-CHIP-4.7-5%-1/10W-0603-TAP; signal model: R2_60130B4R700T-002_4_7_5%_3; room: Sheet7
R60004 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet7
R60005 R60092 = RSC_0603: part number: RSC_0603-10_1%_3,60130B10009T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-10-1%-1/10W-0603-TAP; signal model: R2_60130B10009T_10_1_3%; room: Sheet7
R60009 = RSC_0805: part number: RSC_0805-10_5%_5,60130BA1003S,RSC_200X125X060_2,0.7MM,RSC_0805,0805,RES-CHIP-10-5%-1/8-0805-TAP; signal model: R2_60130BA1003S_10_5%; room: Sheet7
R60011 R60018 R60019 R60028 R60038 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet7
R60012 R60021 R60061 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet7
R60013 R60094 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet7
R60014 = RSC_0402: part number: RSC_0402-2.74K_1%_2,60130B27419Z,RSC_100X050X035_2,0.45MM,RSC_0402,0402,RESISTOR-CHIP,2.74K,1%,1/16W,0402,TR; signal model: R2_60130B27419Z_2_74K_1%_2; room: Sheet7
R60015 R60025 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet7
R60016 R60026 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet7
R60017 R60032 R60051 R60053 R60054 R68121 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet7
R60020 R60039 = RSC_0402: part number: RSC_0402-2.2_5%_2,6013B0137701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2.2,5%,1/16W,0402,TR; signal model: R2_6013B0137701_2_2_5%_2; room: Sheet7
R60022 = RSC_0402: part number: RSC_0402-6.04K_1%_1/16W_2,6013A0077201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-6.04K-1%-1/16W-0402-TAP; signal model: R2_6013A0077201_6_04K_1%_1_16W_2; room: Sheet7
R60024 R60027 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet7
R60045 R68122 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet7
R60048 = RSC_1206: part number: RSC_1206-4.7_5%_6,60130B4R704T,RSC_320X160X145_2,1.6MM,RSC_1206,,1206,RES-CHIP-4.7-5%-1/4W-1206-TAP; signal model: R2_60130B4R704T_4_7_5%_6; room: Sheet7
R60050 R60052 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet7
R60110 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet12
R60115 = RSC_0603: part number: RSC_0603-3.3_5%_3,6013B0049701,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RESISTOR-CHIP,3.3,5%,1/10W,0603,TR,+/-400PPM/DEGREEC; signal model: R2_6013B00497013_3_5%_3; room: Sheet12
R60116 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet12
R60199 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet12
R60200 R60201 R60204 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet10
R60202 R60217 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet10
R60205 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet10
R60206 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet10
R60215 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet10
R60216 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet10
R60218 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet10
R60253 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet11
R60254 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet11
R60255 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet11
R60265 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet11
R60266 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet11
R60289 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet11
R60300 = RSC_0402: part number: RSC_0402-10.2K_1%_2,6013A0074801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0074801_10_2K_1%_2; room: Sheet13
R60301 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet13
R60302 R60346 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet13
R60315 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet13
R60316 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet13
R60349 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet13
R60400 = RSC_0402: part number: RSC_0402-324K_1%_2,6013A008880W,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-324K-1%-1/16W-0402-TAP; signal model: R2_6013A008880W_324K_1%_2; room: Sheet14
R60401 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet14
R60505 R60523-R60525 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet18
R60506 = RSC_0402: part number: RSC_0402-2.2_5%_2,6013B0137701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2.2,5%,1/16W,0402,TR; signal model: R2_6013B0137701_2_2_5%_2; room: Sheet18
R60515 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet18
R60516 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet18
R60520 R60529 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet18
R60522 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet18
R60526 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet18
R60600 = RSC_0402: part number: RSC_0402-102K_1%_2,6013A0088706,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-102K-1%-1/16-0402-TAP; signal model: R2_6013A0088706_102K_1%_2; room: Sheet15
R60601 = RSC_0402: part number: RSC_0402-49.9K_1%_2,6013A0014301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0014301_49_9K_1%_2; room: Sheet15
R60605 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet15
R60615 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet15
R60616 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet15
R60620 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet15
R60630 = RSC_0402: part number: RSC_0402-4.7_5%_2,60130B4R700Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7-5%-1/16W-0402-TAP; signal model: R2_60130B4R700Z_4_7_5%_2; room: Sheet15
R60900 = RSC_0402: part number: RSC_0402-102K_1%_2,6013A0088706,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-102K-1%-1/16-0402-TAP; signal model: R2_6013A0088706_102K_1%_2; room: Sheet17
R60901 = RSC_0402: part number: RSC_0402-133K_1%_2,6013A008870H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-133K-1%-1/16W-0402-TAP; signal model: R2_6013A008870H_133K_1%_2; room: Sheet17
R60903 R60905 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet17
R60915 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet17
R60916 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet17
R60920 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet17
R60930 = RSC_0402: part number: RSC_0402-4.7_5%_2,60130B4R700Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7-5%-1/16W-0402-TAP; signal model: R2_60130B4R700Z_4_7_5%_2; room: Sheet17
R61400 R61428 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet19
R61401 R61403-R61405 R61421 R61422 R61424 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet19
R61406 = RSC_0402: part number: RSC_0402-2.2_5%_2,6013B0137701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2.2,5%,1/16W,0402,TR; signal model: R2_6013B0137701_2_2_5%_2; room: Sheet19
R61415 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet19
R61416 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet19
R61700 = RSC_0402: part number: RSC_0402-15.4K_1%_2,6013A008840B,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-15.4K-1%-1/16W-0402-TAP; signal model: R2_6013A008840B_15_4K_1%_2; room: Sheet16
R61701 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet16
R66000 R66003 R66004 R66106 R66161 R66680 R66681 R66819 R66821 R66829 R66831 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.127MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet20
R66001 = RSC_0402: part number: RSC_0402-75_5%_2,60130B7500ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75OHM-5%-1/16W-0402-TAP; signal model: R2_60130B7500ZT_75_5%_2; room: Sheet20
R66002 R66105 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet20
R66016 R66026 R66036 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet21
R66100 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet20
R66101 = RSC_0402: part number: RSC_0402-45.3_1%_2,6013A008750L,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-45.3-1%-1/16-0402-TAP; signal model: R2_6013A008750L_45_3_1%_2; room: Sheet20
R66102 = RSC_0402: part number: RSC_0402-49.9_1%_2,6013A0076901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9-1%-1/16W-0402-TAP; signal model: R2_6013A0076901_49_9_1%_2; room: Sheet20
R66103 = RSC_0402: part number: RSC_0402-10_5%_2,60130B10000X,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10-5%-1/16W-0402-TAP; signal model: R2_60130B10000X_10_5%_2; room: Sheet20
R66104 R66111 R66114 R66172 R66472 R66672 = RSC_0402: part number: RSC_0402-RSC_0402,RSC_0402,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402; signal model: R2_RSC_0402_RSC_0402; room: Sheet20
R66107 = RSC_0402: part number: RSC_0402-120K_1%_2,6013B0027202,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,120K,1%,1/16W,0402,TR,-55/+125PPM/DEGREEC; signal model: R2_6013B0027202_120K_1%_2; room: Sheet20
R66108 R66109 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet20
R66110 = RSC_0402: part number: RSC_0402-4.7_5%_2,60130B4R700Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7-5%-1/16W-0402-TAP; signal model: R2_60130B4R700Z_4_7_5%_2; room: Sheet20
R66112 R66195 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet20
R66113 = RSC_0402: part number: RSC_0402-73.2K_1%_2,6013A008860L,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-73.2K-1%-1/16W-0402-TAP; signal model: R2_6013A008860L_73_2K_1%_2; room: Sheet20
R66115 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet20
R66154 R66155 R66454 R66455 R66654 = RSC_0402: part number: RSC_0402-1.5K_1%_2,6013A0016301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,1.5K,1%,1/16W,0402,TR; signal model: R2_6013A0016301_1_5K_1%_2; room: Sheet20
R66160 = RSC_0402: part number: RSC_0402-49.9K_1%_2,6013A0014301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0014301_49_9K_1%_2; room: Sheet20
R66171 = RSC_0402: part number: RSC_0402-2.43K_1%_2,6013A0022901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.43K-1%-1/16W-0402-TAP; signal model: R2_6013A0022901_2_43K_1%_2; room: Sheet20
R66197 = RSC_0402: part number: RSC_0402-14.3K_1%_2,6013A0088408,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-14.3K-1%-1/16W-0402-TAP; signal model: R2_6013A0088408_14_3K_1%_2; room: Sheet20
R66198 = RSC_0402: part number: RSC_0402-133K_1%_2,6013A008870H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-133K-1%-1/16W-0402-TAP; signal model: R2_6013A008870H_133K_1%_2; room: Sheet20
R66199 = RSC_0402: part number: RSC_0402-2M_5%_2,6013A009000D,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2M-5%-1/16-0402-TAP; signal model: R2_6013A009000D_2M_5%_2; room: Sheet20
R66316 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet22
R66407 = RSC_0402: part number: RSC_0402-43.2K_1%_2,6013A008850T,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-43.2K-1%-1/16W-0402-TAP; signal model: R2_6013A008850T_43_2K_1%_2; room: Sheet20
R66471 = RSC_0402: part number: RSC_0402-1.43K_1%_2,6013B0675201,RSC_100X050X040_2,0.5MM,RSC_0402,0402,RES-CHIP-1.43K-1%-1/16-0402-TAP; signal model: R2_6013B0675201_1_43K_1%_2; room: Sheet20
R66607 = RSC_0402: part number: RSC_0402-620K_1%_2,6013A0058001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-620K,1%-1/16W-0402-TAP; signal model: R2_6013A0058001_620K_1%_2; room: Sheet20
R66616 = RSC_0603: part number: RSC_0603-RSC_0603,RSC_0603,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603; signal model: R2_RSC_0603_RSC_0603; room: Sheet23
R66671 = RSC_0402: part number: RSC_0402-8.06K_1%_2,6013A0073001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.06K-1%-1/16W-0402-TAP; signal model: R2_6013A0073001_8_06K_1%_2; room: Sheet20
R68004 R68068 = RSC_0402: part number: RSC_0402-9.09K_1%_2,6013A008830H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-9.09K-1%-1/16-0402-TAP; signal model: R2_6013A008830H_9_09K_1%_2; room: Sheet9
R68009 = RSC_0402: part number: RSC_0402-3.32K_1%,6013A0088203,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,3.32KOHM,1%,1/16W,0402,TAPMM; signal model: R2_6013A0088203_3_32K_1%; room: Sheet9
R68054 R68055 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.127MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet9
R68065 = RSC_0402: part number: RSC_0402-32.4K_1%_2,6013A008850E,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-32.4K-1%-1/16W-0402-TAP; signal model: R2_6013A008850E_32_4K_1%_2; room: Sheet9
R68067 R68086 = RSC_0402: part number: RSC_0402-1.87K_1%_2,6013A0088107,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1.87K-1%-1/16W-0402-TAP; signal model: R2_6013A0088107_1_87K_1%_2; room: Sheet9
R68094 R68096 = RSC_0402: part number: RSC_0402-49.9K_1%_2,6013A0014301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0014301_49_9K_1%_2; room: Sheet9
R68095 = RSC_0402: part number: RSC_0402-301K_1%_2,6013A008880R,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-301K-1%-1/16W-0402-TAP; signal model: R2_6013A008880R_301K_1%_2; room: Sheet9
R68099 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet9
R68100 R68102 R68104 R68105 R68107 R68109 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet8
R68101 R68103 R68106 R68108 = RSC_0402: part number: RSC_0402-470K_5%_2,60130B47400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-5%-1/16W-0402-TAP; signal model: R2_60130B47400Z_470K_5%_2; room: Sheet8
R68120 = RSC_0402: part number: RSC_0402-1M_1%_2,60130B10049Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-1%-1/16W-0402-TAP; signal model: R2_60130B10049Z_1M_1%_2; room: Sheet7
R68123 = RSC_0402: part number: RSC_0402-549K_1%_2,6013A0057401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-549K,1%-1/16W-0402-TAP; signal model: R2_6013A0057401_549K_1%_2; room: Sheet7
R68124 = RSC_0402: part number: RSC_0402-76.8K_1%_2,6013B0104901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,76.8K,+/-1%,1/16W,0402,TR; signal model: R2_6013B0104901_76_8K_1%_2; room: Sheet7
R68125 = RSC_0402: part number: RSC_0402-33K_1%_2,6013A0049501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33K-1%-1/16W-0402-TAP; signal model: R2_6013A0049501_33K_1%_2; room: Sheet7
RS300 = 10P8R: part number: 10P8R-10K_5%,60130CJ0053T,RSC_368X216X050_10_064,0.65MM,10P8R,RES-AR-10P8R-10K-5%-1/16W-TAP; signal model: R10_60130CJ0053T_10k_5%; room: Sheet64
S5 = SCREW_1: part number: SCREW_1-SCREW300X420_860_1P,SCREW300X420_860_1P,SCREW300X420_860_1P,0.0003MM,SCREW_1,SCREW300X420_860_1P; room: Sheet74
S6 = SCREW_1: part number: SCREW_1-SCREW250_600_500_1P,SCREW250_600_500_1P,SCREW250_600_500_1P,0.127MM,SCREW_1,SCREW250_600_500_1P; room: Sheet74
S7-S9 = SCREW_1: part number: SCREW_1-SCREW250_600_1P,SCREW250_600_1P,SCREW250_600_1P,0.127MM,SCREW_1,SCREW250_600_1P; room: Sheet74
S12 S19 = SCREW_1: part number: SCREW_1-SCREW250_700_1P,SCREW250_700_1P,SCREW250_700_1P,0.127MM,SCREW_1,SCREW250_700_1P; room: Sheet74
S13 S14 S16-S18 = SCREW_1: part number: SCREW_1-SCREW450_700_1P,SCREW450_700_1P,SCREW450_700_1P,0.127MM,SCREW_1,SCREW450_700_1P; room: Sheet74
S15 = SCREW_1: part number: SCREW_1-SCREW500_700_NP_1P,SCREW500_700_NP_1P,SCREW500_700_NP_1P,0.0003MM,SCREW_1,SCREW500_700_NP_1P; room: Sheet74
S20 S21 = SCREW_1: part number: SCREW_1-SCREW400_700_1P,SCREW400_700_1P,SCREW400_700_1P,0.127MM,SCREW_1,SCREW400_700_1P; room: Sheet74
S22 = SCREW_1: part number: SCREW_1-SCREW370_700_1P,SCREW370_700_1P,SCREW370_700_1P,0.127MM,SCREW_1,SCREW370_700_1P; room: Sheet74
S30-S33 = SCREW_1: part number: SCREW_1-SCREW330_600_500_1P,SCREW330_600_500_1P,SCREW330_600_500_1P,0.127MM,SCREW_1,SCREW330_600_500_1P; room: Sheet74
S9201 = SCREW_1: part number: SCREW_1-SCREW250_700_1P,SCREW250_700_1P,SCREW250_700_1P,0.127MM,SCREW_1,SCREW250_700_1P; room: Sheet79
S9202 = SCREW_1: part number: SCREW_1-SCREW250_500_1P,SCREW250_500_1P,SCREW250_500_1P,0.127MM,SCREW_1,SCREW250_500_1P; room: Sheet79
S9203 = SCREW_1: part number: SCREW_1-SCREW260_460_1P,SCREW260_460_1P,SCREW260_460_1P,0.127MM,SCREW_1,SCREW260_460_1P; room: Sheet79
ST1300 = STDPAD_1: part number: STDPAD_1-STANDOFF_3.2_6.0,6052B0407701,STD_R_FF45021_D30007_M20275_SN,2.33MM,STDPAD_1,STANDOFF,FF,M2.0,2.75MM,4.5MM,RND,SN,2.1MM; room: Sheet66
ST1400 = STDPAD_1: part number: STDPAD_1-STANDOFF_3.2_6.0,6052B0407701,STD_R_FF45021_D30007_M20275_SN,2.33MM,STDPAD_1,STANDOFF,FF,M2.0,2.75MM,4.5MM,RND,SN,2.1MM; room: Sheet67
ST1950 = STDPAD_1: part number: STDPAD_1-STANDOFF_3.2_6.0,6052B0407701,STD_R_FF45021_D30007_M20275_SN,2.33MM,STDPAD_1,STANDOFF,FF,M2.0,2.75MM,4.5MM,RND,SN,2.1MM; room: Sheet60
SW1000 = T3C2QR: part number: T3C2QR-DIPTRONICS_T3C2QR_2P_NSP,6026B0394201_NSP,SWCH-TACT_DIP_2_SMD_V_060_NSP,0.0003MM,,SWITCH,TACTILE,2P,SMD,TR,; room: Sheet72
SW1001 SW1002 = NDTP016_G1A_AAET: part number: NDTP016_G1A_AAET-MISAKI_NDTP016_G1A_AAET_4P_NSP,6026B0476001_NSP,SWCH-DETECT_MISKI_4_SMD_V_380_NSP,0.0003MM,,SWITCH, TACTILE, 4P, SMD, TR; room: Sheet72
TP300 TP304 TP305 = TPX_1: part number: TPX_1-TP24_NP,TP24_NP,TP24_NP,0.0003MM,TPX_1,TP24_NP; room: Sheet64
TP302 TP303 TP307 TP309 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet62
TP308 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet63
TP375 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet32
TP501-TP504 TP515 = TPX_1: part number: TPX_1-TP24_NP,TP24_NP,TP24_NP,0.0003MM,TPX_1,TP24_NP; room: Sheet70
TP505 TP506 TP508 TP509 TP513 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet70
TP850-TP855 TP2500-TP2502 TP2515-TP2517 TP2521 TP2522 TP4300-TP4303 TP4750 TP4751 TP6001 TP6002 TP6050-TP6054 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet78
TP1301-TP1303 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet66
TP1411-TP1413 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet67
TP1951 = TPX_1: part number: TPX_1-TP30,TPX30,TP30,0.127MM,TPX_1,TP30; room: Sheet60
TP1952 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet60
TP2503-TP2512 TP2518 TP2519 = TPX_1: part number: TPX_1-TP24_NP,TP24_NP,TP24_NP,0.0003MM,TPX_1,TP24_NP; room: Sheet78
TP2600-TP2603 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet52
TP2700 TP2701 TP2703 TP2704 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet50
TP3301 TP3303 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet48
TP3800 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet73
TP4500 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet37
TP4501 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet35
TP4502 TP4505 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet34
TP4503 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet42
TP4504 = TPX_1: part number: TPX_1-TP24_NP,TP24_NP,TP24_NP,0.0003MM,TPX_1,TP24_NP; room: Sheet35
TP4506 = TPX_1: part number: TPX_1-TP24_NP,TP24_NP,TP24_NP,0.0003MM,TPX_1,TP24_NP; room: Sheet36
TP4507 TP4517 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet31
TP4508 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet40
TP4509 TP4515 = TPX_1: part number: TPX_1-TP24_NP,TP24_NP,TP24_NP,0.0003MM,TPX_1,TP24_NP; room: Sheet45
TP4510-TP4514 TP4516 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet45
TP4518-TP4521 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet39
TP4522-TP4525 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet36
TP4526 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet33
TP9200 TP9202 = TPX_1: part number: TPX_1-TP30,TPX30,TP30,0.127MM,TPX_1,TP30; room: Sheet80
TP9201 = TPX_1: part number: TPX_1-TP30_NP,TPX30_NP,TP30_NP,0.0003MM,TPX_1,TP30_NP; room: Sheet80
TP9203-TP9205 = TPX_1: part number: TPX_1-TP30,TPX30,TP30,0.127MM,TPX_1,TP30; room: Sheet81
TP60000 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet7
TP60100-TP60102 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet12
TP60200 TP60202 TP60204 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet10
TP60250 TP60251 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet11
TP60300 TP60350 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet13
TP60301 TP60351 = TPX_1: part number: TPX_1-TP24_NP,TP24_NP,TP24_NP,0.0003MM,TPX_1,TP24_NP; room: Sheet13
TP60400 TP60410 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet14
TP60500 TP60501 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet18
TP60600 TP60601 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet15
TP60900 TP60901 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet17
TP61400 TP61401 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet19
TP61700 TP61701 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet16
TP66000 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet21
TP66001 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet20
TP66300 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet22
TP66600 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet23
U300 = NPCX797HA1BX: part number: NPCX797HA1BX-NUVOTON_NPCX797HA1BX_VFBGA_144P,6019B1811501,VFBGA_800X800X095_144_065_P2,0.95MM,,IC,EMBEDDED CONTROLLER,32BIT ARM,BGA,144P,TRAY; room: Sheet62
U302 = NL27WZ07DFT2G: part number: NL27WZ07DFT2G-OSRAM_NL27WZ07DFT2G_SC88_6P,6019B0262201,TSSC88_200X125X110_6_065,1.25MM,,IC,BUFFER,DUAL N_INV,SC88,6P,TR; room: Sheet62
U366 = W25Q128FVPIG: part number: W25Q128FVPIG-WINBOND_W25Q128JVPIQ_WSON_8P,6019B1598001,WSON_500X600X080_8_127_T2,0.9MM,,IC,FLASH MEMORY,128M,2.7~3.6V,104MHZ,4KBYTE,WSON,8P,TR; room: Sheet62
U367 = W25Q128FVPIG: part number: W25Q128FVPIG-WINBOND_W25Q256JVEIN_WSON_8P,6019B1905101,WSON_600X800X080_8_127_T1,0.9MM,,IC,SPI,256M,-40~+85C,2.7~3.6V,133MHZ,4K,WSON,8P,TR; room: Sheet62
U500 = ALC3292_CG: part number: ALC3292_CG-REA_ALC3292_CG_MQFN_48P,6019B1759301,MQFN_600X600X100_48_040_T1,1.10MM,,IC,AUDIO CODEC,48PIN,MQFN,TR; room: Sheet70
U1000 = SLG4T43296VTR: part number: SLG4T43296VTR-DIALOG_SLG4T43296VTR_STQFN_12P,6019B1922701,STQFN_160X160X060_12_040_P2,0.7MM,,IC,RESET TIMER,FIXED DELAY,STQFN-12,12P,TR; room: Sheet72
U1300 = 74LVC1G08GW: part number: 74LVC1G08GW-NXP_74LVC1G08GW_TSOT353_5P,6019A0136301,TSOT353_205X125X110_5_065,1.25MM,,IC-AND GATE-SINGLE 2INPUT-SOT353-5P-TR; room: Sheet66
U1400 = WSTM066: part number: WSTM066-GEMALTO_WSTM056_WLCSP_11P,6042B0529201,WLCSP_254X274X060_11_065,0.6MM,,IC,WSTM056, MULTISIM 4.2,EUICC,WLCSP,11P,TR; room: Sheet67
U1401 = SN74AUP1G97DCKR: part number: SN74AUP1G97DCKR-TI_SN74AUP1G97DCKR_SC70_6P,6019B1272401,SC70_200X125X110_6_065_P2,1.25MM,,LOW-POWER CONFIGURABLE MULTIPLE-FUNCTION GATE, SEVEN, SC70, 6P, TR; room: Sheet67
U2403 = CYPD5225_96BZXIT: part number: CYPD5225_96BZXIT-CYPRESS_CYPD5225_96BZXIT_BGA_96P,6019B1837301,BGA_600X600X100_96_050_P2,1MM,,IC,USB TYPE-C PORT CONTROLLER,BGA,96P,TR; room: Sheet52
U2500 = G524B1T11U: part number: G524B1T11U-GMT_G524B1T11U_SOT23_5P,6019B1124501,TSOT23_290X160X125_5_095,1.40MM,,IC,POWER SWITCH,SOT-23-5,5P,TR; room: Sheet57
U2501 = TPS2546RTER: part number: TPS2546RTER-TEXAS_TPS2546RTER_QFN_16P,6019B1035901,QFN_300X300X080_16_050_T1,0.95MM,,TEXAS_TPS2546RTER_QFN_16P; room: Sheet57
U2600 = NX5P3290UK: part number: NX5P3290UK-NXP_NX5P3290AU_WLCSP_16P,6019B1580101,WLCSP_220X220X060_16_050,0.59MM,,IC,POWER SWITCH,USB PD/TYPE C,WLCSP,16P,TR; room: Sheet56
U2602 = NX5P3290UK: part number: NX5P3290UK-NXP_NX5P3290AU_WLCSP_16P,6019B1580101,WLCSP_220X220X060_16_050,0.59MM,,IC,POWER SWITCH,USB PD/TYPE C,WLCSP,16P,TR; room: Sheet54
U2700 = TITAN_RIDGE_DP: part number: TITAN_RIDGE_DP-INTEL_TITAN_RIDGE_DP_BGA_337P,6019B1717601,BGA_1070X1070X089_337,0.89MM,,IC,I/O CONTROLLER,TITAN RIDGE DP,BGA,337P,TR; room: Sheet50
U2701 = 74LVC1G08GW: part number: 74LVC1G08GW-NXP_74LVC1G08GW_TSOT353_5P,6019A0136301,TSOT353_205X125X110_5_065,1.25MM,,IC-AND GATE-SINGLE 2INPUT-SOT353-5P-TR; room: Sheet50
U2702 = 74LVC1G17GM: part number: 74LVC1G17GM-NXP_74LVC1G17GM_TSOT886_6P,6019B1178601,TSOT886_145X100X050_6_050,0.65MM,,IC,BUFFER,ONE N_INV,SOT886,6P,TAP; room: Sheet50
U2703 = W25Q80DVZPIG: part number: W25Q80DVZPIG-WINBOND_W25Q80DVZPIG_WSON_8P,6019B1298501,WSON_600X500X080_8_127_T1P2,0.9MM,,IC,FLASH MEMORY,8M,-40~+85C,2.7~3.6V,104MHZ,4KBYTE,WSON-8,8P,TR; room: Sheet50
U3000 = NCT3521U: part number: NCT3521U-NUVO_NCT3521U_SOT23_5P,6019B0849401,TSSOT23_290X160X135_5_095,1.5MM,,IC,POWER SWITCH,SOT23,5P,TR; room: Sheet58
U3001 = 74LVC1G3157GM: part number: 74LVC1G3157GM-NXP_74LVC1G3157GM_TSOT886_6P,6019B1608301,TSOT886_145X100X050_6_050,0.60MM,,IC,ANALOG MUX/DEMUX,SOT-886,6P,TR; room: Sheet58
U3002 U3003 = 74LVC1G3157GM: part number: 74LVC1G3157GM-NXP_74LVC1G3157GM_TSOT886_6P,6019B1608301,TSOT886_145X100X050_6_050,0.60MM,,IC,ANALOG MUX/DEMUX,SOT-886,6P,TR; room: Sheet59
U3150 = G524B1T11U: part number: G524B1T11U-GMT_G524B1T11U_SOT23_5P,6019B1124501,TSOT23_290X160X125_5_095,1.40MM,,IC,POWER SWITCH,SOT-23-5,5P,TR; room: Sheet49
U3300 = PS8339AQFN56GTR2_A1: part number: PS8339AQFN56GTR2_A1-PARADE_PS8339AQFN56GTR2_A1_QFN_56P,6019B1184101,QFN_700X700X090_56_040_T6,1.05MM,,IC,DEMUX,56P,7.8X7.8,QFN; room: Sheet48
U3500 = SLB9670VQ2_0_FW_7_85: part number: SLB9670VQ2_0_FW_7_85-INFINEON_SLB9670VQ2_0_FW_7_85_VQFN_32P,6019B1829201,VQFN_500X500X090_32_050_T1,1MM,,IC,HARDWARE SECURITY,TPM,VQFN,32P,TR; room: Sheet65
U3800 = SDINADF4_32G_H: part number: SDINADF4_32G_H-SANDISK_SDINBDA4_32G_V_TFBGA_153P,6019B1806501-001,CAMELLIA-6019B1806501-001,1MM,,IC,NAND FLASH MEMORY,E-MMC,32G,BGA,153P,TRAY; room: Sheet73
U4411 = G788P81U: part number: G788P81U-GMT_G788P81U_MSOP_8P,6019B1817301,MSOP_300X300X110_8_065_P3,1.2MM,,IC,TEMPERATURE SENSOR,3.3V,MSOP,8P,TR; room: Sheet29
U4412 = NCT7717U: part number: NCT7717U-NUVO_NCT7717U_SOT23_5P,6019B0914301,TSSOT23_290X160X135_5_095,1.5MM,,IC,ADC,ONE,SOT-23,5P,TR; room: Sheet29
U4413 = G708T1U: part number: G708T1U-GMT_G708T1U_SOT23_5P,6019B0158401,TSOT23_290X160X130_5_095,1.45MM,IC,TEMPERATURE SENSOR,SOT23-5,5P,TR; room: Sheet29
U4555 = J92043: part number: J92043-INTEL_J92043_BGA_1528P,TMP190102004,CPU_INTEL_CLU_6C_B_4600X2400,1.315MM,,CPU,6C_GT2,15W,BGA,1528P; room: Sheet37
U4700 = SCHMITT_TRIGGER: part number: SCHMITT_TRIGGER-74LVC1G17GW,6019B0278101,TSSC88A_200X125X110_5_065,1.25MM,SCHMITT_TRIGGER,IC,BUFFER,ONE N_INV,SC-88A,5P,TAP; room: Sheet34
U4920 U4921 = SN74AUP1G97DCKR: part number: SN74AUP1G97DCKR-TI_SN74AUP1G97DCKR_SC70_6P_NP,6019B1272401_NP,SC70_200X125X110_6_065_NP,0.0003MM,,LOW-POWER CONFIGURABLE MULTIPLE-FUNCTION GATE, SEVEN, SC70, 6P, TR; room: Sheet31
U7000 = 74LVC1G07GW: part number: 74LVC1G07GW-NXP_74LVC1G07GW_TSSOP_5P,6019B0267302,TSSOP_205X125X110_5_065,1.25MM,,IC,BUFFER/DRIVER,ONE N_INV,TSSOP,5P,TR; room: Sheet27
U7001 = G2898KD1U: part number: G2898KD1U-GMT_G2898KD1U_TDFN_15P,6019B1562901,TDFN_300X200X080_14_040_T4,0.9MM,,IC,LOAD SWITCH,DUAL CHANNEL,TDFN,14P,TR; room: Sheet26
U7400 = COMPARATOR_2: part number: COMPARATOR_2-ON_LMV393DMR2G_SOP_8P,6019B0618101,MICRO_300X300X110_8_065,1.25MM,COMPARATOR_2,IC,COMPARATOR,DUAL,MSOP,8P,TR; room: Sheet28
U9201 = PS8713BTQFN24GTR2_A2: part number: PS8713BTQFN24GTR2_A2-PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P,6019B1566001,TQFN_400X400X080_24_050_T6,0.90MM,,IC,REPEATER/REDRIVER,USB3.0,TQFN,24P,TR; room: Sheet80
U9203 = PS8713BTQFN24GTR2_A2: part number: PS8713BTQFN24GTR2_A2-PARADE_PS8713BTQFN24GTR2_A3_TQFN_24P,6019B1566001,TQFN_400X400X080_24_050_T6,0.90MM,,IC,REPEATER/REDRIVER,USB3.0,TQFN,24P,TR; room: Sheet81
U9204 = MH255EST: part number: MH255EST-MST_MH255ESP_PSOT23_3P,6019B1548301,IC-HALL_MST_3_SMD_105,1.22MM,,IC,MICROPOWER HALL SWITCH,PSOT-23,3P,TR; room: Sheet82
U9300 U9301 = CM32181E: part number: CM32181E-CAPELLA_CM32181E_OPLGA_6P,6019B1265501-002,CAMELLIA-6019B1265501-002,1.2MM,,IC,LIGHT SENSOR,I2C,OPLGA,6P,TR; room: Sheet85
U9302 = CM32181E: part number: CM32181E-CAPELLA_CM32181E_OPLGA_6P,6019B1265501-002,CAMELLIA-6019B1265501-002,1.2MM,,IC,LIGHT SENSOR,I2C,OPLGA,6P,TR; room: Sheet84
U60000 = ISL9241HRTZ: part number: ISL9241HRTZ-INTERSIL_ISL9241HRTZ_TQFN_32P,6019B1729301,TQFN_400X400X075_32_040_T2,0.85MM,,IC,BATTERY CHARGER CONTROLLER,SMBUS,TQFN; room: Sheet7
U60100 = NB680AGD_Z: part number: NB680AGD_Z-MPS_NB680AGD_Z_QFN_12P,6019B1289201,QFN_300X200X100_12_050,1.15MM,,IC,DC/DC CONVERTER,QFN-12,12P,TR; room: Sheet12
U60200 = SYV127CTMC: part number: SYV127CTMC-SILERGY_SYV127CTMC_QFN_13P,6019B1920401,QFN_300X400X085_13,0.95MM,,IC,STEP-DOWN REGULATOR,DC/DC,QFN,13P,TR; room: Sheet10
U60250 = SY8288CRAC: part number: SY8288CRAC-SILERGY_SYV128CRAC_QFN_20P,6019B1934101,QFN_300X300X090_20_045_T2,1MM,,IC,SYNC STEP-DOWN REGULATOR,QFN,20P,TR; room: Sheet11
U60300 = NB685GQ_Z: part number: NB685GQ_Z-MPS_NB685AGQ_Z_QFN_16P,6019B1397101,QFN_300X300X100_16_050_P1,1.15MM,,IC,DC/DC CONVERTER,QFN-16,16P,TR; room: Sheet13
U60400 = RT8097ALGJ6: part number: RT8097ALGJ6-RICHTEK_RT8097ALGE_TSOT23_6P,6019B1265401,TSOT23_290X160X130_6_095,1.45MM,,IC,DC/DC CONVERTER,TSOT-23-6,6P,TR; room: Sheet14
U60500 = NB692GD: part number: NB692GD-MPS_NB692GD_QFN_13P,6019B1720201,QFN_300X200X100_13_050,1.1MM,,IC,SYNCHRONOUS BUCK CONVERTER,4.5~28V,6.5A,QFN,13P,TR; room: Sheet18
U60600 = SY8386RHC: part number: SY8386RHC-SILERGY_SY8386RHC_QFN_16P,6019B1920201,QFN_250X250X065_16_045_T1,0.75MM,,IC,STEP-DOWN REGULATOR,DC/DC,QFN,16P,TR; room: Sheet15
U60900 = SY8386RHC: part number: SY8386RHC-SILERGY_SY8386RHC_QFN_16P,6019B1920201,QFN_250X250X065_16_045_T1,0.75MM,,IC,STEP-DOWN REGULATOR,DC/DC,QFN,16P,TR; room: Sheet17
U61400 = NB692GD: part number: NB692GD-MPS_NB692GD_QFN_13P,6019B1720201,QFN_300X200X100_13_050,1.1MM,,IC,SYNCHRONOUS BUCK CONVERTER,4.5~28V,6.5A,QFN,13P,TR; room: Sheet19
U61700 = G5728TO1U: part number: G5728TO1U-SILERGY_SY8088A1AAC_SOT23_5P,6019B1827301,TSOT23_295X160X130_5_095,1.4MM,,IC,SYNCHRONOUS STEP-DOWN REG,2.5~5.5V,1.5MHZ,SOT-23-5,5P,TR; room: Sheet16
U66000 = MP2949GQK_LF_Z: part number: MP2949GQK_LF_Z-MPS_MP2979AGQKT_0180_Z_TQFN_48P,6019B1730810,TQFN_600X600X080_48_040_T3,0.9MM,,IC,POWER CONTROLLER,MULTI PHASE,TQFN-48,; room: Sheet20
U66010 U66020 U66030 = MP86901_CGLT: part number: MP86901_CGLT-MPS_MP86948GQVT_Z_TQFN_21P,6019B1854301,TQFN_500X300X080_21_040,0.9MM,,IC,DRIVER MOSFET,30A,TQFN,21P,TR; room: Sheet21
U66310 = MP86901_CGLT: part number: MP86901_CGLT-MPS_MP86948GQVT_Z_TQFN_21P,6019B1854301,TQFN_500X300X080_21_040,0.9MM,,IC,DRIVER MOSFET,30A,TQFN,21P,TR; room: Sheet22
U66610 = MP86901_AGQT: part number: MP86901_AGQT-MPS_MP86901_AGQT_TQFN_13P,6019B1513801,TQFN_300X300X080_13_040,0.9MM,,IC,DRIVER MOSFET,12A,TQFN,13P,TR; room: Sheet23
X2700 = XTAL_4PIN_F: part number: XTAL_4PIN_F-TXC_7M25000153_CRYSTAL_25M_20PF_4P,6018B0098201,XTAL_320X250X080_4_220,0.90MM,XTAL_4PIN_F,,,CRYSTAL,25MHZ,+/-10PPM,20PF,SMD,3.2X2.5X0.8,TR; room: Sheet50
X4750 = XTAL_4PIN: part number: XTAL_4PIN-32.768KHZ_12.5PF,6018A0009301,XTAL_670X140X140_4_630,1.55MM,XTAL_4PIN,12.5PF,20PPM,XTAL-32.768KHZ(6H03200413)-20PPM-12.5PF-TAP-TXC; room: Sheet41
X4751 = XTAL_4PIN_F: part number: XTAL_4PIN_F-TXC_24MHZ_12PF,6018B0097301,XTAL_320X250X080_4_220,0.90MM,XTAL_4PIN_F,,,CRYSTAL,24MHZ,+/-20PPM,12PF,SMD,3.2X2.5X0.8,TR; room: Sheet41

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
ALOE20-6036B0188001-002
  rect 1.295x3.15 smd: 1(-2.15,0) 2(2.15,0)
AUDIO_SIGAT_6_R_140_390_1
  round 1.194 hole 1.194 unplated: (-4.5,0)
  oval 0.991x1.702 hole 0.61x1.295: 1(-4.5,2.4) 2(-4.5,-2.6) 3(-4.5,-5.2) 4(4.5,-5.2) 6(4.5,-2.8)
  oval 0.991x1.6 hole 0.61x1.194: 5(4.5,2.95)
BALOS-6012B0622401-002
  rect 0.356x0.864 smd: 1(-4.25,2.5) 2(-3.75,2.5) 3(-3.25,2.5) 4(-2.75,2.5) 5(-2.25,2.5) 6(-1.75,2.5) 7(-1.25,2.5) 8(-0.75,2.5) 9(-0.25,2.5) 10(0.25,2.5) 11(0.75,2.5) 12(1.25,2.5) 13(1.75,2.5) 14(2.25,2.5) 15(2.75,2.5) 16(3.25,2.5) 17(3.75,2.5) 18(4.25,2.5)
  rect 0.61x0.787 smd: G1(-5.25,0) G2(5.25,0)
BGA_600X600X100_96_050_P2
  round 0.254 smd: A1(2.5,-2.5) A2(2,-2.5) A3(1.5,-2.5) A4(1,-2.5) A5(0.5,-2.5) A6(0,-2.5) A7(-0.5,-2.5) A8(-1,-2.5) A9(-1.5,-2.5) A10(-2,-2.5) A11(-2.5,-2.5) B1(2.5,-2) B11(-2.5,-2) C1(2.5,-1.5) C11(-2.5,-1.5) D1(2.5,-1) D11(-2.5,-1) E1(2.5,-0.5) E11(-2.5,-0.5) F1(2.5,0) F11(-2.5,0) G1(2.5,0.5) G11(-2.5,0.5) H1(2.5,1) H2(2,1) H11(-2.5,1) J1(2.5,1.5) J2(2,1.5) J11(-2.5,1.5) K1(2.5,2) K2(2,2) K3(1.5,2) K11(-2.5,2) L1(2.5,2.5) L2(2,2.5) L3(1.5,2.5) L4(1,2.5) L5(0.5,2.5) L6(0,2.5) L7(-0.5,2.5) L8(-1,2.5) L9(-1.5,2.5) L10(-2,2.5) L11(-2.5,2.5)
  round 0.356 smd: B2(2,-2) B3(1.5,-2) B4(1,-2) B5(0.5,-2) B6(0,-2) B7(-0.5,-2) B8(-1,-2) B9(-1.5,-2) B10(-2,-2) C2(2,-1.5) C10(-2,-1.5) D2(2,-1) D5(0.5,-1) D6(0,-1) D7(-0.5,-1) D8(-1,-1) D10(-2,-1) E2(2,-0.5) E4(1,-0.5) E5(0.5,-0.5) E6(0,-0.5) E7(-0.5,-0.5) E8(-1,-0.5) E10(-2,-0.5) F2(2,0) F4(1,0) F5(0.5,0) F6(0,0) F7(-0.5,0) F8(-1,0) F10(-2,0) G2(2,0.5) G4(1,0.5) G5(0.5,0.5) G6(0,0.5) G7(-0.5,0.5) G8(-1,0.5) G10(-2,0.5) H4(1,1) H5(0.5,1) H6(0,1) H7(-0.5,1) H8(-1,1) H10(-2,1) J10(-2,1.5) K4(1,2) K5(0.5,2) K6(0,2) K7(-0.5,2) K8(-1,2) K9(-1.5,2) K10(-2,2)
BGA_1070X1070X089_337
  round 0.254 smd: A1(5.06,-5.06) A23(-5.06,-5.06) AA2(4.6,4.14) AA22(-4.6,4.14) AB2(4.6,4.6) AB3(4.14,4.6) AB4(3.68,4.6) AB5(3.22,4.6) AB6(2.76,4.6) AB7(2.3,4.6) AB8(1.84,4.6) AB9(1.38,4.6) AB10(0.92,4.6) AB11(0.46,4.6) AB12(0,4.6) AB13(-0.46,4.6) AB14(-0.92,4.6) AB15(-1.38,4.6) AB16(-1.84,4.6) AB17(-2.3,4.6) AB18(-2.76,4.6) AB19(-3.22,4.6) AB20(-3.68,4.6) AB21(-4.14,4.6) AB22(-4.6,4.6) AC1(5.06,5.06) AC23(-5.06,5.06) B2(4.6,-4.6) B3(4.14,-4.6) B4(3.68,-4.6) B5(3.22,-4.6) B6(2.76,-4.6) B7(2.3,-4.6) B8(1.84,-4.6) B9(1.38,-4.6) B10(0.92,-4.6) B11(0.46,-4.6) B12(0,-4.6) B13(-0.46,-4.6) B14(-0.92,-4.6) B15(-1.38,-4.6) B16(-1.84,-4.6) B17(-2.3,-4.6) B18(-2.76,-4.6) B19(-3.22,-4.6) B20(-3.68,-4.6) B21(-4.14,-4.6) B22(-4.6,-4.6) C2(4.6,-4.14) C22(-4.6,-4.14) D2(4.6,-3.68) D4(3.9,-3.9) D5(3.25,-3.9) D6(2.6,-3.9) D8(1.95,-3.9) D9(1.3,-3.9) D11(0.65,-3.9) D12(0,-3.9) D13(-0.65,-3.9) D15(-1.3,-3.9) D16(-1.95,-3.9) D18(-2.6,-3.9) D19(-3.25,-3.9) D20(-3.9,-3.9) D22(-4.6,-3.68) E2(4.6,-3.22) E4(3.9,-3.25) E5(3.25,-3.25) E6(2.6,-3.25) E8(1.95,-3.25) E9(1.3,-3.25) E11(0.65,-3.25) E12(0,-3.25) E13(-0.65,-3.25) E15(-1.3,-3.25) E16(-1.95,-3.25) E18(-2.6,-3.25) E19(-3.25,-3.25) E20(-3.9,-3.25) E22(-4.6,-3.22) F2(4.6,-2.76) F4(3.9,-2.6) F5(3.25,-2.6) F6(2.6,-2.6) F8(1.95,-2.6) F9(1.3,-2.6) F11(0.65,-2.6) F12(0,-2.6) F13(-0.65,-2.6) F15(-1.3,-2.6) F16(-1.95,-2.6) F18(-2.6,-2.6) F19(-3.25,-2.6) F20(-3.9,-2.6) F22(-4.6,-2.76) G2(4.6,-2.3) G22(-4.6,-2.3) H2(4.6,-1.84) H4(3.9,-1.95) H5(3.25,-1.95) H6(2.6,-1.95) H8(1.95,-1.95) H9(1.3,-1.95) H11(0.65,-1.95) H12(0,-1.95) H13(-0.65,-1.95) H15(-1.3,-1.95) H16(-1.95,-1.95) H18(-2.6,-1.95) H19(-3.25,-1.95) H20(-3.9,-1.95) H22(-4.6,-1.84) J2(4.6,-1.38) J4(3.9,-1.3) J5(3.25,-1.3) J6(2.6,-1.3) J8(1.95,-1.3) J9(1.3,-1.3) J11(0.65,-1.3) J12(0,-1.3) J13(-0.65,-1.3) J15(-1.3,-1.3) J16(-1.95,-1.3) J18(-2.6,-1.3) J19(-3.25,-1.3) J20(-3.9,-1.3) J22(-4.6,-1.38) K2(4.6,-0.92) K22(-4.6,-0.92) L2(4.6,-0.46) L4(3.9,-0.65) L5(3.25,-0.65) L6(2.6,-0.65) L8(1.95,-0.65) L9(1.3,-0.65) L11(0.65,-0.65) L12(0,-0.65) L13(-0.65,-0.65) L15(-1.3,-0.65) L16(-1.95,-0.65) L18(-2.6,-0.65) L19(-3.25,-0.65) L20(-3.9,-0.65) L22(-4.6,-0.46) M2(4.6,0) M4(3.9,0) M5(3.25,0) M6(2.6,0) M8(1.95,0) M9(1.3,0) M11(0.65,0) M12(0,0) M13(-0.65,0) M15(-1.3,0) M16(-1.95,0) M18(-2.6,0) M19(-3.25,0) M20(-3.9,0) M22(-4.6,0) N2(4.6,0.46) N4(3.9,0.65) N5(3.25,0.65) N6(2.6,0.65) N8(1.95,0.65) N9(1.3,0.65) N11(0.65,0.65) N12(0,0.65) N13(-0.65,0.65) N15(-1.3,0.65) N16(-1.95,0.65) N18(-2.6,0.65) N19(-3.25,0.65) N20(-3.9,0.65) N22(-4.6,0.46) P2(4.6,0.92) P22(-4.6,0.92) R2(4.6,1.38) R4(3.9,1.3) R5(3.25,1.3) R6(2.6,1.3) R8(1.95,1.3) R9(1.3,1.3) R11(0.65,1.3) R12(0,1.3) R13(-0.65,1.3) R15(-1.3,1.3) R16(-1.95,1.3) R18(-2.6,1.3) R19(-3.25,1.3) R20(-3.9,1.3) R22(-4.6,1.38) T2(4.6,1.84) T4(3.9,1.95) T5(3.25,1.95) T6(2.6,1.95) T8(1.95,1.95) T9(1.3,1.95) T11(0.65,1.95) T12(0,1.95) T13(-0.65,1.95) T15(-1.3,1.95) T16(-1.95,1.95) T18(-2.6,1.95) T19(-3.25,1.95) T20(-3.9,1.95) T22(-4.6,1.84) U2(4.6,2.3) U22(-4.6,2.3) V2(4.6,2.76) V4(3.9,2.6) V5(3.25,2.6) V6(2.6,2.6) V8(1.95,2.6) V9(1.3,2.6) V11(0.65,2.6) V12(0,2.6) V13(-0.65,2.6) V15(-1.3,2.6) V16(-1.95,2.6) V18(-2.6,2.6) V19(-3.25,2.6) V20(-3.9,2.6) V22(-4.6,2.76) W2(4.6,3.22) W4(3.9,3.25) W5(3.25,3.25) W6(2.6,3.25) W8(1.95,3.25) W9(1.3,3.25) W11(0.65,3.25) W12(0,3.25) W13(-0.65,3.25) W15(-1.3,3.25) W16(-1.95,3.25) W18(-2.6,3.25) W19(-3.25,3.25) W20(-3.9,3.25) W22(-4.6,3.22) Y2(4.6,3.68) Y4(3.9,3.9) Y5(3.25,3.9) Y6(2.6,3.9) Y8(1.95,3.9) Y9(1.3,3.9) Y11(0.65,3.9) Y12(0,3.9) Y13(-0.65,3.9) Y15(-1.3,3.9) Y16(-1.95,3.9) Y18(-2.6,3.9) Y19(-3.25,3.9) Y20(-3.9,3.9) Y22(-4.6,3.68)
  oval 0.178x0.33 smd: A2(4.6,-5.06) A3(4.14,-5.06) A4(3.68,-5.06) A5(3.22,-5.06) A6(2.76,-5.06) A7(2.3,-5.06) A8(1.84,-5.06) A9(1.38,-5.06) A10(0.92,-5.06) A11(0.46,-5.06) A12(0,-5.06) A13(-0.46,-5.06) A14(-0.92,-5.06) A15(-1.38,-5.06) A16(-1.84,-5.06) A17(-2.3,-5.06) A18(-2.76,-5.06) A19(-3.22,-5.06) A20(-3.68,-5.06) A21(-4.14,-5.06) A22(-4.6,-5.06) AC2(4.6,5.06) AC3(4.14,5.06) AC4(3.68,5.06) AC5(3.22,5.06) AC6(2.76,5.06) AC7(2.3,5.06) AC8(1.84,5.06) AC9(1.38,5.06) AC10(0.92,5.06) AC11(0.46,5.06) AC12(0,5.06) AC13(-0.46,5.06) AC14(-0.92,5.06) AC15(-1.38,5.06) AC16(-1.84,5.06) AC17(-2.3,5.06) AC18(-2.76,5.06) AC19(-3.22,5.06) AC20(-3.68,5.06) AC21(-4.14,5.06) AC22(-4.6,5.06)
  oval 0.33x0.178 smd: AA1(5.06,4.14) AA23(-5.06,4.14) AB1(5.06,4.6) AB23(-5.06,4.6) B1(5.06,-4.6) B23(-5.06,-4.6) C1(5.06,-4.14) C23(-5.06,-4.14) D1(5.06,-3.68) D23(-5.06,-3.68) E1(5.06,-3.22) E23(-5.06,-3.22) F1(5.06,-2.76) F23(-5.06,-2.76) G1(5.06,-2.3) G23(-5.06,-2.3) H1(5.06,-1.84) H23(-5.06,-1.84) J1(5.06,-1.38) J23(-5.06,-1.38) K1(5.06,-0.92) K23(-5.06,-0.92) L1(5.06,-0.46) L23(-5.06,-0.46) M1(5.06,0) M23(-5.06,0) N1(5.06,0.46) N23(-5.06,0.46) P1(5.06,0.92) P23(-5.06,0.92) R1(5.06,1.38) R23(-5.06,1.38) T1(5.06,1.84) T23(-5.06,1.84) U1(5.06,2.3) U23(-5.06,2.3) V1(5.06,2.76) V23(-5.06,2.76) W1(5.06,3.22) W23(-5.06,3.22) Y1(5.06,3.68) Y23(-5.06,3.68)
BTB_SAM_60_050_F_325
  round 1.016 hole 1.016 unplated: (-10.061,0.003) (10.066,0.003)
  rect 0.356x2.362 smd: 1(-7.249,-5.53) 2(-7.249,0.201) 3(-6.749,-5.53) 4(-6.749,0.201) 5(-6.248,-5.53) 6(-6.248,0.201) 7(-5.748,-5.53) 8(-5.748,0.201) 9(-5.248,-5.53) 10(-5.248,0.201) 11(-4.747,-5.53) 12(-4.747,0.201) 13(-4.247,-5.53) 14(-4.247,0.201) 15(-3.747,-5.53) 16(-3.747,0.201) 17(-3.249,-5.53) 18(-3.249,0.201) 19(-2.748,-5.53) 20(-2.748,0.201) 21(-2.248,-5.53) 22(-2.248,0.201) 23(-1.748,-5.53) 24(-1.748,0.201) 25(-1.247,-5.53) 26(-1.247,0.201) 27(-0.749,-5.53) 28(-0.749,0.201) 29(-0.249,-5.53) 30(-0.249,0.201) 31(0.254,-5.53) 32(0.254,0.201) 33(0.754,-5.53) 34(0.754,0.201) 35(1.252,-5.53) 36(1.252,0.201) 37(1.753,-5.53) 38(1.753,0.201) 39(2.253,-5.53) 40(2.253,0.201) 41(2.753,-5.53) 42(2.753,0.201) 43(3.254,-5.53) 44(3.254,0.201) 45(3.754,-5.53) 46(3.754,0.201) 47(4.252,-5.53) 48(4.252,0.201) 49(4.752,-5.53) 50(4.752,0.201) 51(5.253,-5.53) 52(5.253,0.201) 53(5.753,-5.53) 54(5.753,0.201) 55(6.253,-5.53) 56(6.253,0.201) 57(6.751,-5.53) 58(6.751,0.201) 59(7.254,-5.53) 60(7.254,0.201)
CAMELLIA-6012B0430404-001
  rect 0.356x0.864 smd: 1(2.75,2.5) 2(2.25,2.5) 3(1.75,2.5) 4(1.25,2.5) 5(0.75,2.5) 6(0.25,2.5) 7(-0.25,2.5) 8(-0.75,2.5) 9(-1.25,2.5) 10(-1.75,2.5) 11(-2.25,2.5) 12(-2.75,2.5)
  rect 0.61x0.787 smd: G1(3.75,0) G2(-3.75,0)
CAMELLIA-6012B0773101-009
  rect 0.356x1.372 smd: 1(-9.751,-1.951) 2(-9.251,-1.951) 3(-8.75,-1.951) 4(-8.25,-1.951) 5(-7.75,-1.951) 6(-7.249,-1.951) 7(-6.749,-1.951) 8(-6.248,-1.951) 9(-5.751,-1.951) 10(-5.25,-1.951) 11(-4.75,-1.951) 12(-4.249,-1.951) 13(-3.752,-1.951) 14(-3.251,-1.951) 15(-2.751,-1.951) 16(-2.25,-1.951) 17(-1.75,-1.951) 18(-1.25,-1.951) 19(-0.749,-1.951) 20(-0.249,-1.951) 21(0.249,-1.951) 22(0.752,-1.951) 23(1.25,-1.951) 24(1.75,-1.951) 25(2.25,-1.951) 26(2.751,-1.951) 27(3.251,-1.951) 28(3.752,-1.951) 29(4.252,-1.951) 30(4.75,-1.951) 31(5.25,-1.951) 32(5.751,-1.951) 33(6.248,-1.951) 34(6.749,-1.951) 35(7.252,-1.951) 36(7.752,-1.951) 37(8.25,-1.951) 38(8.75,-1.951) 39(9.251,-1.951) 40(9.751,-1.951)
  rect 1.194x2.692 smd: G1(-12.151,0) G5(12.151,0)
  rect 2.007x1.295 smd: G2(-8.9,1.951) G3(0,1.951) G4(8.9,1.951)
CAMELLIA-6012B0856401-001
  rect 0.356x0.864 smd: 1(1.25,3.15) 2(0.75,3.15) 3(0.25,3.15) 4(-0.25,3.15) 5(-0.75,3.15) 6(-1.25,3.15)
  rect 0.61x0.787 smd: G1(2.25,0.65) G2(-2.25,0.65)
