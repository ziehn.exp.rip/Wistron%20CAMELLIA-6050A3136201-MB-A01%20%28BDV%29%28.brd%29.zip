# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NFC_DWL_REQ_PCH: length 133.7
  TOP w0.102: R4769.2 204.93,55.87 204.93,55.87 v2(204.24,55.87) 204.16,55.95 R4774.2
  L3 w0.076: 179.39,55.9 179.25,55.9 176.87,55.9 175.86,56.92 174.86,56.92 174.62,57.16 174.62,59.96 v1(174.09,60.49)
  L3 w0.102: v2(204.24,55.87) 204.31,55.95 204.31,56.65 203.9,57.06 202.43,57.06 201.52,56.15 199.35,56.15 199.33,56.13 199.31,56.13 199.09,55.9 179.39,55.9
  L5 w0.102: v1(225.62,6.82) 226.56,5.88 227.91,5.88 229.24,7.22 234.27,7.22 235.24,8.19 235.29,8.19 235.53,8.43 235.53,8.48 238.44,11.39 238.73,11.39 241.78,14.44 241.78,17.88 237.76,21.9 236.58,21.9 234.97,23.51 234.97,24.07 232.62,26.43 232.06,26.99 229.97,26.99 229.77,27.19 219.73,27.19 217.31,29.61 213.08,29.61 198.87,43.82 198.87,47.18 199.08,47.38 199.08,51.21 200.3,52.43 201.14,53.28 201.14,55.74 202.46,57.06 203.87,57.06 204.08,56.86 204.08,56.86 204.31,56.62 204.31,55.95 v2(204.24,55.87)
  BOTTOM w0.076: U4555.CC27 v1(174.09,60.49)
  BOTTOM w0.102: v1(225.62,6.82) 225.6,6.85 225.6,7.78 CN4350.5
NFC_INT: length 141.3
  L3 w0.102: v1(204.01,72.37) 204.01,70.72 202.52,69.23 192.45,69.23 192.35,69.33 192.35,71.3 192.11,71.54 186.26,71.54 186.04,71.76 183.31,71.76 v1(182.9,72.17)
  L6 w0.102: v1(228.45,8.6) 229.26,7.79 238.06,7.79 238.26,7.99 239.27,7.99 239.52,7.99 241.42,9.89 241.75,9.89 242.95,11.1 242.95,19.3 242.52,19.73 242.52,20.05 237.44,25.13 237.44,25.84 237.44,29.83 235.81,31.46 235.81,31.56 235.81,31.56 235.81,32.07 235.45,32.42 233.35,32.42 233.02,32.75 232.45,32.75 232.45,32.76 232.17,32.76 231.97,32.96 230.12,32.96 229.99,32.96 229.59,33.36 228.09,33.36 227.38,34.08 226.76,34.08 226.59,34.08 224.28,36.39 223.06,36.39 221.61,37.84 221.61,37.84 221.51,37.94 221.51,39.57 220.29,40.79 220.29,41.08 219.38,41.99 219.38,44.96 217.93,46.41 217.93,48.17 214.7,51.4 214.7,54.61 214.08,55.24 214.08,58.07 213.69,58.46 213.69,61.26 213.79,61.36 213.79,61.37 214.58,62.17 214.58,65.91 214.58,66.08 211.87,68.8 208.11,68.8 207.31,69.59 207.31,70.05 205.41,71.96 204.42,71.96 v1(204.01,72.37)
  BOTTOM w0.076: v1(182.9,72.17) 182.87,72.17 182,73.03 180.37,73.03 180.2,72.97 180.06,72.97 179.88,73.03 179.42,73.03 179.35,73.11 178.77,73.11 U4555.CM8
  BOTTOM w0.102: v1(228.45,8.6) 228.35,8.7 222.91,8.7 222.5,8.29 CN4350.11 ; v1(204.01,72.37) 203.85,72.52 R4724.2 203.85,73.02 203.19,73.67 v3(202.89,73.67)
NFC_RST#: length 130.6
  TOP w0.102: R4619.2 204.49,56.83 204.11,56.45 v1(203.91,56.45)
  L3 w0.076: v1(174.12,58.57) 173.74,58.19 173.74,57.72 173.73,57.71 173.73,57.13 173.95,56.91 174.63,56.91 174.79,56.75 175.79,56.75 176.81,55.74 178.81,55.74 178.84,55.7 180.51,55.7
  L3 w0.102: v1(203.91,56.45) 203.5,56.86 202.55,56.86 201.63,55.95 199.44,55.95 199.41,55.92 199.4,55.92 199.18,55.7 180.51,55.7
  L5 w0.102: v1(203.91,56.45) 203.5,56.86 202.55,56.86 201.34,55.66 201.34,53.19 201.14,52.99 200.65,52.5 200.38,52.23 199.28,51.13 199.28,47.3 199.08,47.09 199.08,43.9 213.16,29.81 217.4,29.81 219.81,27.4 230.47,27.4 230.67,27.19 232.44,27.19 237.53,22.11 237.84,22.11 241.98,17.97 241.98,17.8 241.98,14.36 241.8,14.18 241.8,12.9 240.1,11.19 238.82,11.19 238.6,11.19 234.43,7.02 229.33,7.02 227.99,5.68 226.07,5.68 225.07,6.68 v1(225.07,7.05)
  BOTTOM w0.076: v1(174.12,58.57) 173.86,58.83 U4555.CC30
  BOTTOM w0.102: CN4350.6 225,7.12 v1(225.07,7.05)
NMI_SMI_DBG#: length 122.2
  TOP w0.076: 183.28,55.65 183,55.65 182.85,55.5 176.28,55.5 174.5,57.27 174.5,58.83 v1(174.13,59.2)
  TOP w0.102: R4765.2 214.09,61.46 v1(214.09,61.09) 212.84,61.09 v3(212.04,60.29) 211.71,59.96 211.5,59.96 211.5,59.96 200.95,59.96 200.83,60.08 195.56,60.08 193.94,58.46 192.26,58.46 191.92,58.12 188.18,58.12 188.04,57.98 187.37,57.98 186.75,57.37 185.06,57.37 183.34,55.65 183.28,55.65 ; v1(235.81,23.25) 235.81,23.82 235.55,24.09 235.5,24.09 230.9,28.7 230.9,33.59 229.54,34.94 225.54,34.94 224.49,35.99 Q302.S 224.38,36.87 v1(223.91,37.34)
  L3 w0.102: v1(246.17,34.59) 245.66,34.08 245.66,31.02 244.55,29.9 244.55,27.69 244.21,27.36 243.18,27.36 v1(241.39,25.57)
  L6 w0.102: v1(214.09,61.09) 214.45,60.73 214.45,58.91 214.28,58.74 214.28,55.32 214.91,54.7 214.91,51.48 218.13,48.26 218.13,46.5 219.58,45.05 219.58,42.08 220.49,41.16 220.49,40.87 221.71,39.65 221.71,39.45 223.82,37.34 v1(223.91,37.34)
  BOTTOM w0.076: U4555.CC29 v1(174.13,59.2)
  BOTTOM w0.102: v1(246.17,34.59) 247.32,34.59 247.9,34.01 248.67,33.24 250.32,33.24 251.01,33.92 251.67,33.92 252.11,34.37 252.11,34.8 252.3,34.99 CN375.5 ; v1(235.81,23.25) 239.07,23.25 240.41,24.59 240.69,24.59 240.93,24.83 240.93,25.11 v1(241.39,25.57)
NUM_LOCK_LED#: length 37.5
  TOP w0.076: v1(238.88,39.34) U300.D7
  TOP w0.102: R320.1 241.39,30.11 241.53,30.24 v1(241.53,30.29)
  L3 w0.076: v1(238.88,39.34) 238.87,39.33 238.87,37.59 238.35,37.07 238.35,35.32
  L3 w0.102: v1(241.53,30.29) 241.53,30.42 240.92,31.03 239.22,31.03 238.73,31.51 238.73,34.17 238.35,34.56 238.35,35.32
  L5 w0.102: v1(254.28,29.02) 252.54,29.02 251.91,28.39 250.28,28.39 250.13,28.54 249.35,28.54 246.73,25.92 245.54,25.92 244.9,26.56 244.31,26.56 241.91,28.96 241.91,28.97 241.53,29.35 v1(241.53,30.29)
  BOTTOM w0.102: CN375.15 257.27,35.62 257.27,33.34 256.69,32.76 v3(256.69,31.79) 256.69,30.85 255.04,29.2 254.81,29.2 254.63,29.02 v1(254.28,29.02)
OCP_CHG#: length 8.4
  TOP w0.102: R68055.1 183.41,106.45 v3(183.41,105.78) 184.28,105.78 184.48,105.98 184.88,105.98 185.29,105.58 188.21,105.58 188.34,105.45 189.29,105.45 189.9,106.06 U60000.23
OCP_ID_ADC2: length 108.1
  TOP w0.102: R300.1 v1(247.75,40.07)
  L5 w0.102: v1(247.75,40.07) 248.79,41.11 248.79,44.11 248,44.9 247.43,44.9 246.96,45.36 246.96,45.7 247.58,46.32 247.92,46.32 248.61,47.01 248.61,61.06 248.12,61.55 248.12,67.57 248.41,67.86 248.41,70.19 247.82,70.78 246.38,70.78 244.45,72.71 244.45,77.5 243.99,77.96 241.52,77.96 241.08,77.51 238.74,77.51 238.13,78.12 237.66,78.12 237.31,78.12 235.61,79.82 235.61,79.92 233.14,82.39 229.77,82.39 227.33,84.83 227.33,88.45 224.47,91.32 224.47,98.14 224.67,98.34 224.67,100.96 221.59,104.04 221.59,104.92 222.27,105.6 222.27,107.86 v2(221.46,108.88)
  L6 w0.102: v2(221.46,108.88) 221.46,108.96 220.93,109.49 220.39,109.49 220.14,109.23 217.27,109.23 217.12,109.08 215.31,109.08 215.06,109.33 215.06,110.05 215.26,110.25 215.26,110.76 213.97,112.05 213.97,116.68 v1(214.02,116.73)
  BOTTOM w0.102: R68004.1 213.45,116.29 R68009.2 213.58,116.29 v1(214.02,116.73)
OCP_ID_SEL: length 90.7
  TOP w0.076: U300.K9 236.92,43.9 236.92,45 236.9,45.02 236.9,46.32 v1(236.39,46.83)
  TOP w0.102: R68099.1 v3(213.79,108.55) 214.32,108.02 v1(215.92,108.02)
  L5 w0.076: v1(236.39,46.83) 235.73,47.49 235.73,48.02
  L5 w0.102: v1(215.92,108.02) 215.92,108.98 216.18,109.23 217.19,109.23 217.6,108.83 217.6,106.06 217.52,105.98 217.52,103.19 217.14,102.81 217.14,100.79 220.03,97.91 220.74,97.91 220.98,97.67 220.98,96.45 219.5,94.98 219.5,89 223.31,85.19 223.31,83.96 223.82,83.45 223.82,79.13 223.14,78.44 223.14,77.87 221,75.73 221,70.43 222.32,69.11 222.32,68.44 221.64,67.76 221.06,67.76 220.45,67.15 220.36,67.15 220.06,66.85 220.06,65.88 220.88,65.06 220.88,63.96 226.12,58.71 227.64,58.71 229.89,56.46 229.89,54.95 235.53,49.31 235.53,49.21 235.73,49.01 235.73,48.02
  BOTTOM w0.102: v1(215.92,108.02) 214.5,108.02 213.24,109.27 Q68098.G
OCP_PWM_OUT: length 138.6
  TOP w0.076: v1(239.53,41.29) U300.G6
  TOP w0.102: Q68054.G 181.65,109.61 180.46,108.42 180.46,107.25 181.6,106.11 182.36,106.11 183.2,105.27 183.62,105.27 183.77,105.42 183.78,105.42 183.93,105.58 184.6,105.58 v2(184.68,105.5)
  L3 w0.076: v1(239.53,41.29) 239.53,43.39 239.17,43.74 239.17,45.82 v1(239.34,45.99)
  L5 w0.076: 237.88,48.02 237.88,47.45 v1(239.34,45.99)
  L5 w0.102: v1(214.65,110.5) 216.5,110.5 218,109 218,105.89 217.93,105.81 217.93,103.02 217.55,102.64 217.55,100.96 219.71,98.8 220.19,98.31 221.25,98.31 221.99,97.57 221.99,96.89 219.91,94.81 219.91,89.17 223.24,85.84 224.08,85.84 224.48,85.44 224.48,82.51 225.07,81.92 225.07,79.81 224.48,79.21 224.48,78.64 221.41,75.56 221.41,70.6 222.73,69.28 222.73,69.11 222.73,63.5 223.85,62.39 223.85,62.1 226.21,59.73 229.08,59.73 230.55,58.26 230.55,57.91 230.79,57.67 236.87,57.67 242.06,52.48 242.06,51.61 240.9,50.45 238.78,50.45 237.88,49.55 237.88,48.02
  L6 w0.102: v1(214.65,110.5) 213.79,110.5 213.37,110.92 206.73,110.92 204.61,108.8 199.45,108.8 196.41,105.75 194.94,105.75 193.94,104.75 188.12,104.75 187.24,105.63 184.81,105.63 v2(184.68,105.5)
ON_OFF#: length 234.2
  TOP w0.102: v1(238.66,25.92) 238.35,26.23 Q1003.S 237.5,26.65 R1012.2
  L6 w0.102: v2(44.76,11.26) 45.17,11.67 50.74,11.67 52.98,13.91 55.62,13.91 55.82,13.71 69.05,13.71 73.6,9.16 v1(77.84,9.16) 78.41,9.16 81.67,12.42 86.34,12.42 87.64,11.12 89.08,11.12 91.07,9.13 120.13,9.13 120.33,9.34 128.67,9.34 133.02,4.99 144.01,4.99 144.68,5.65 164.4,5.65 164.4,5.65 164.57,5.65 164.74,5.65 168,8.91 212.35,8.91 212.37,8.93 227.26,8.93 228.81,7.38 238.23,7.38 238.43,7.58 239.1,7.58 239.69,7.58 241.59,9.49 241.92,9.49 243.35,10.93 243.35,19.47 244.55,20.67 244.55,23.53 244.11,23.97 240.19,23.97 238.66,25.51 v1(238.66,25.92)
  BOTTOM w0.102: v1(77.84,9.16) 78.41,9.16 78.64,8.93 SW1000.T2 ; v2(44.76,11.26) 44.79,11.28 CN300.7
ON_OFF#1: length 4.2
  TOP w0.102: v3(239.11,24.53) R327.1 239.11,26.61 Q1003.D 239.5,27.06 R1010.2 240.37,27.06 Q1000.D
ON_OFF#1_Q: length 311.7
  TOP w0.102: R4888.1 125.98,69.43 v1(126.59,70.04) ; PAD300.2 242,23.33 242,25.26 242.58,25.85 242.58,26.62 242.19,27.01 242.19,27.01 Q1000.S 241.5,27.53 v1(241.5,27.68) 241.91,28.09 241.91,30.1 241.93,30.12 241.93,30.46 241.62,30.77 R100.1
  L3 w0.102: v1(241.5,27.68) 241.68,27.68 243.99,29.99 244.35,29.99 245.46,31.1 245.46,36.91 245.93,37.38 248.18,37.38 249.48,36.08 251.28,36.08 255.11,39.91 255.85,39.91 258.7,42.76 258.7,47.79 v1(259,48.1)
  L5 w0.102: v1(86.64,11.51) 88.08,12.96 88.08,15.76 92.84,20.52 92.84,25.71 97.97,30.84 100.57,30.84 101.22,31.48 101.22,31.78 105.8,36.36 106.94,36.36 109.28,38.7 109.31,38.7 111.83,41.22 111.83,45.94 113.31,47.41 113.31,60.7 114.5,61.89 115.92,61.89 118.48,64.45 118.48,67.32 121.21,70.04 v1(126.59,70.04)
  L6 w0.102: v1(241.5,27.68) 243.28,25.9 244.11,25.9 245.42,24.58 245.42,22.94 245.16,22.68 245.16,20.75 245.16,20.41 244.21,19.46 244.21,15.43 245.46,14.17 245.46,11.35 243.85,9.74 242.46,9.74 242,9.28 241.67,9.28 239.77,7.38 239.02,7.38 239.02,7.38 238.51,7.38 236.84,5.7 236.17,5.7 234.7,7.17 228.73,7.17 227.17,8.73 212.46,8.73 212.44,8.71 168.08,8.71 164.82,5.45 164.66,5.45 164.49,5.45 164.49,5.45 164.32,5.45 144.76,5.45 144.1,4.79 132.93,4.79 128.59,9.13 120.42,9.13 120.21,8.93 90.99,8.93 88.99,10.92 87.23,10.92 v1(86.64,11.51)
  BOTTOM w0.102: CN4941.11 259.12,47.98 v1(259,48.1)
ON_OFF#1_Q_XDP: length 2
  TOP w0.102: R4888.2 124.73,69.65 CN4920.41
PA_USB2_MXCTL: length 4
  TOP w0.076: R2735.2 254.89,71.12 256.66,69.35 256.66,68.86 256.88,68.63 U2700.R2
PA_USB2_RBIAS: length 4.3
  TOP w0.203: v1(259.89,60.4) U2700.H19
  BOTTOM w0.076: v1(259.89,60.4) 259.89,60.24 v3(261.13,58.99) 262.59,58.99 262.76,59.17
  BOTTOM w0.102: 262.76,59.17 R2721.2
PB_USB2_MXCTL: length 6.5
  TOP w0.076: U2700.R1 256.88,69.36 255.28,70.97 255.28,72.02
  TOP w0.102: v3(254.91,74.69) 254.89,74.67 R2736.2 254.94,73.95 255.29,73.6 255.29,72.62 255.28,72.61 255.28,72.02
PB_USB2_RBIAS: length 2.3
  TOP w0.076: v1(261.18,60.4) U2700.F19
  BOTTOM w0.076: v1(261.18,60.4) 262.76,60.4
  BOTTOM w0.102: 262.76,60.4 262.78,60.4 R2723.2
PCBEEP: length 2
  TOP w0.254: U500.34 20.65,44.11 20.34,44.41 C527.1
PCH_3A_SMCLK: length 67.4
  TOP w0.13: Q4752.6 219.64,37.98 219.64,38.18 219.53,38.29 217.9,38.29 R4830.2 217.87,38.37 217.63,38.61 216.82,38.61 v1(216.63,38.8)
  L6 w0.076: v1(177.99,68.7) 180.77,68.7 182.84,66.62
  L6 w0.127: 182.84,66.62 199.98,66.62 200.9,66.62 202.6,64.93 202.6,62.72 202.6,62.37 206.97,58 206.97,47.73 208.57,46.13 208.57,43.41 210.56,41.42 210.56,37.87 v2(210.74,37.69)
  BOTTOM w0.13: U4555.CK14 v1(177.99,68.7) ; v1(216.63,38.8) 216.21,38.8 216.21,38.81 211.86,38.81 v2(210.74,37.69)
PCH_3A_SMDATA: length 67.2
  TOP w0.13: v1(216.2,39.23) 217.17,39.23 v3(217.22,39.18) 217.47,38.93 R4792.2 218.51,38.93 Q4752.3
  L6 w0.076: v1(176.73,67.62) 177.15,68.04 181.11,68.04 182.78,66.37
  L6 w0.127: 182.78,66.37 200.8,66.37 202.35,64.82 202.35,61.77 206.71,57.4 206.71,47.63 207.4,46.94 207.4,45.51 207.66,45.25 207.66,43.97 210.13,41.49 v1(210.13,37.94)
  BOTTOM w0.13: v1(210.13,37.94) 211.42,39.23 v1(216.2,39.23) ; U4555.CH15 v1(176.73,67.62)
PCH_3S_SMCLK: length 286.5
  TOP w0.13: v1(101.95,45.98) 101.76,45.98 99.76,43.97 99.43,43.97 98.93,43.97 95.56,40.61 95.56,27.01 91.13,22.58 89.9,21.35 89.9,14.46 91.05,13.31 91.5,13.31 v1(92.05,13.73) ; CN4920.53 124.51,72.65 v1(124.63,72.77) ; v1(222.88,37.43) 222.17,37.43 R4913.2 221.05,38.62 220.47,39.2 Q4752.1
  L3 w0.097: v1(222.88,37.43) 222.88,36.97 222.91,36.94 222.91,36.83 223.17,36.57 223.17,36.28 224.69,34.76 225.18,34.76 226.27,33.67 226.45,33.49 226.45,33.06 228.97,30.54 228.97,29.98 230.45,28.51 233.08,25.87 233.76,25.87 237.37,22.26 237.37,18.35 237.36,18.34 237.36,17.1 236.69,16.44 236.69,15.58 v1(237.11,15.16) 237.07,15.16 236.69,14.79 236.69,13.23 234.64,11.18 230.34,11.18 229.74,10.58 202.94,10.58 202.35,11.18 197.12,11.18 197.09,11.21 171.51,11.21 171.39,11.09 v1(167.33,11.09) 166.67,11.75 151.21,11.75 150.07,10.61 145.71,10.61 145.47,10.84 145.47,11.18 144.88,11.77 113.29,11.77 113.27,11.75 95.86,11.75 93.88,13.73 v1(92.05,13.73)
  L6 w0.127: v1(124.63,72.77) 124.41,72.71 123.52,71.82 123.52,66.69 117.89,61.06 117.71,61.06 116.82,60.17 116.13,60.17 114.2,58.25 114.2,49.12 111.81,46.73 102.7,46.73 v1(101.95,45.98)
  BOTTOM w0.13: CN4100.253 160.13,19.64 161.88,17.88 161.88,16.13 163.59,14.42 164,14.42 v1(167.33,11.09) ; CN4125.253 235.84,20.83 235.84,16.43 v1(237.11,15.16)
PCH_3S_SMDATA: length 280.6
  TOP w0.13: v1(124.64,72.11) 124.61,72.15 CN4920.51 ; v1(91.26,13.73) 91,13.73 90.16,14.57 90.16,21.25 91.24,22.32 95.82,26.91 95.82,40.5 99.03,43.72 100.3,43.72 v1(102.56,45.98) ; v1(223.31,37) 222.16,37 221.25,37.91 R4828.2 221.05,37.29 220.64,36.88 219.32,36.88 218.77,37.43 Q4752.4
  L3 w0.097: v1(91.26,13.73) 92.4,12.59 94.7,12.59 95.76,11.53 113.36,11.53 113.38,11.55 143.77,11.55 144.71,10.61 145.39,10.61 145.62,10.38 150.16,10.38 151.3,11.53 166.29,11.53 v1(166.72,11.09) 166.76,11.09 167.16,10.69 167.5,10.69 167.65,10.83 170.5,10.83 170.53,10.87 171.49,10.87 171.61,10.99 196.99,10.99 197.02,10.96 202.25,10.96 202.85,10.36 229.83,10.36 230.43,10.96 234.74,10.96 236.92,13.14 236.92,14.29 v1(237.13,14.51) 237.13,14.62 237.51,15 237.51,15.33 237.28,15.57 237.02,15.57 236.92,15.67 236.92,16.34 237.58,17.01 237.58,18.25 237.59,18.25 237.59,22.17 237.59,22.36 233.85,26.1 233.18,26.1 230.67,28.6 230.67,28.6 229.2,30.08 229.2,30.63 226.67,33.15 226.67,33.59 226.37,33.89 225.28,34.98 225.09,34.98 225.09,34.98 224.78,34.98 223.6,36.16 223.6,36.71 v1(223.31,37)
  L6 w0.127: v1(102.56,45.98) 103.06,46.47 111.91,46.47 114.46,49.01 114.46,58.14 116.24,59.92 116.93,59.92 117.82,60.81 117.99,60.81 123.77,66.59 123.77,71.71 124.17,72.11 v1(124.64,72.11)
  BOTTOM w0.13: v1(237.13,14.51) 236.93,14.51 236.07,13.66 236.07,12.39 236.09,12.37 CN4125.254 ; CN4100.254 160.38,13.33 160.65,13.6 160.65,13.92 160.89,14.16 163.65,14.16 v1(166.72,11.09)
PCH_CIO_PLUG_EVENT: length 86.2
  TOP w0.102: R2722.1 249.71,69.59 248.8,69.59 248.68,69.46 247.69,69.46 247.61,69.38 247.27,69.38 v1(246.86,69.79)
  L3 w0.102: v2(246.1,74.67) 246.1,73.86 244,71.77 236.42,71.77 233.9,74.28 231.68,74.28 230.03,75.94 221.78,75.94 218.34,79.38 218.34,80.45 217.89,80.89 217.56,80.89 217.15,80.48 v1(217.12,80.48)
  L6 w0.102: v1(246.86,69.79) 246.86,70.77 246.28,71.36 246.28,74.49 v2(246.1,74.67) ; v1(189.48,72.57) 189.89,72.98 189.89,72.98 190.87,72.98 191.11,72.74 191.32,72.52 197,72.52 197.36,72.16 199.06,72.16 201.91,75.02 207.11,75.02 207.17,74.96 212.36,74.96 212.71,75.32 212.71,75.61 217.12,80.01 v1(217.12,80.48)
  BOTTOM w0.076: 188,71.96 187.08,71.96 186.73,71.61 180.83,71.61 180.61,71.8 180.61,71.81 180.34,71.81 179.85,71.54 U4555.CP10
  BOTTOM w0.102: v1(189.48,72.57) 189.38,72.47 R4748.2 189.3,71.96 188,71.96
PCH_CLICKPAD_INT#: length 251.3
  TOP w0.102: R4625.2 110.11,5.78 110.21,5.68 v1(110.21,4.18)
  L5 w0.102: v1(210.99,37.08) 219.71,28.36 230.37,28.36 230.88,27.85 233.23,27.85 238.69,22.39 238.69,22.13 242.59,18.22 242.59,17.55 242.59,14.1 242.41,13.93 242.41,11.1 239.85,8.53 239.85,5.79 239.1,5.04 v1(239.06,5.04)
  L6 w0.102: v1(239.06,5.04) 239.51,5.04 239.82,4.73 239.82,4.39 239.24,3.81 237.76,3.81 237.26,4.31 235.65,4.31 235.48,4.48 229.95,4.48 229.48,4.95 227.39,4.95 227.31,4.87 220.25,4.87 219.14,3.77 215.75,3.77 215.03,4.49 205.54,4.49 202.52,7.51 177.15,7.51 175.78,6.14 172.51,6.14 168.91,2.53 157.5,2.53 156.69,3.34 154.66,3.34 154.15,3.85 133.06,3.85 132.89,3.85 132.84,3.8 132.78,3.74 132.78,3.74 131.52,2.48 131.52,2.27 131.21,1.96 114.78,1.96 112.79,3.95 110.44,3.95 v1(110.21,4.18) ; v1(210.99,37.08) 210.17,37.08 208.66,38.6 208.66,40 207.41,41.24 207.41,45.16 207.16,45.41 207.16,46.84 206.47,47.53 206.47,57.3 202.1,61.67 202.1,64.72 201.59,65.24 192.48,65.24 v2(191.81,64.57)
  BOTTOM w0.076: 188,63.76 185.88,63.76 185.45,64.19 181.76,64.19 181.28,63.71 180.71,63.71 U4555.CR22
  BOTTOM w0.102: 188,63.76 190.77,63.76 190.79,63.77 191.34,63.77 191.64,64.08 191.64,64.4 v2(191.81,64.57) 191.81,64.97 R4831.2
PCH_I2C3_3S_SCL: length 2.1
  TOP w0.13: v3(197.68,64.58) 197.94,64.84 R4802.2 198.4,63.61 Q4750.3
PCH_I2C3_3S_SDA: length 2.2
  TOP w0.13: Q4750.6 199.74,62.26 199.75,62.26 199.97,62.26 v3(200.5,62.79) 200.83,63.12 R4825.2
PCH_I2C3_SCL: length 25.8
  TOP w0.13: R4561.2 197.63,63.03 ; 197.63,63.03 197.25,62.65 v1(197.25,61.48) ; 197.63,63.03 Q4750.4
  L3 w0.076: 180.28,59.62 179.97,59.94 179.34,59.94 178.78,60.5 177.46,60.5 v1(176.82,59.86)
  L3 w0.097: 180.28,59.62 180.99,58.92 181.18,58.92 181.51,58.92 181.6,59.01 183.11,59.01 183.12,59 194.79,59 197.25,61.46 v1(197.25,61.48)
  BOTTOM w0.076: U4555.CH28 v1(176.82,59.86)
PCH_I2C3_SDA: length 29.4
  TOP w0.13: v1(196.03,61.84) 196.03,62.94 196.41,63.32 v3(196.41,63.84) 196.41,63.88 196.54,64.01 197.36,64.01 197.63,63.74 R4560.2 198.14,63.16 199.16,63.16 199.4,63.4 Q4750.1
  L3 w0.076: v1(175.9,60.46) 176.28,60.46 176.66,60.84 176.99,60.84 177.16,60.66 178.85,60.66 179.34,60.17 180.05,60.17
  L3 w0.097: 180.05,60.17 181.09,59.14 181.42,59.14 181.51,59.23 183.21,59.23 183.21,59.22 194.7,59.22 196.03,60.56 v1(196.03,61.84)
  BOTTOM w0.076: U4555.CH27 v1(175.9,60.46)
PCH_KBC_SMCLK: length 216.7
  TOP w0.076: 233.75,48.02 234.38,47.39 235.04,47.39 235.63,46.8 235.63,46.27 v1(235.72,46.19) ; v1(237.58,43.89) U300.K8
  TOP w0.13: 233.75,48.02 232.98,48.78 232.76,48.78 232.42,49.12 R310.1
  L3 w0.076: v1(237.58,43.89) 237.58,43.94 236.25,45.27 236.03,45.27 235.71,45.59 235.71,46.18 v1(235.72,46.19)
  L3 w0.097: v1(183.58,116.34) 183.58,114.05 181.81,112.28 164.24,112.28 156.66,104.71 156.66,100.4 147.32,91.06 141.54,91.06 141.47,91.06 141.25,90.84 130.82,90.84 v2(130.32,90.34)
  L6 w0.076: 233.88,46.19 v1(235.72,46.19)
  L6 w0.127: v1(220.77,79.17) 220.77,78.7 219.67,77.6 219.67,68.93 219.39,68.65 219.39,66.27 220.13,65.54 220.13,63.21 222.56,60.78 222.56,52.93 221.5,51.86 221.5,49.46 222.23,48.74 231.33,48.74 233.88,46.19
  BOTTOM w0.13: Q4411.6 127.67,85.98 128.31,85.98 128.55,86.23 128.55,88.57 v2(130.32,90.34) ; v1(220.77,79.17) 221.58,79.98 221.58,81.67 222.32,82.41 222.32,86.53 221.16,87.69 221.16,88.28 219.76,89.68 219.76,93.21 220.53,93.97 222.07,93.97 224.92,96.82 226.03,96.82 226.5,97.29 226.5,107.71 226.03,108.18 220.49,108.18 218.4,106.09 211.62,106.09 209.53,104 205.62,104 200.89,108.74 200,108.74 200,108.74 199.79,108.74 198.54,109.98 198.54,112.63 197.19,113.98 184.97,113.98 184.49,114.46 U4412.1 184.49,115.44 v1(183.58,116.34)
PCH_KBC_SMDATA: length 222.1
  TOP w0.076: v1(236.24,45.79) 236.24,46.19 235.8,46.63 235.8,46.86 235.1,47.56 234.57,47.56 234.11,48.02 ; U300.K7 v1(238.23,43.89)
  TOP w0.13: R311.1 233.04,49.09 234.11,48.02
  L3 w0.076: v1(238.23,43.89) 236.32,45.79 v1(236.24,45.79)
  L3 w0.097: v1(184.19,116.34) 183.97,116.13 183.97,114.13 181.9,112.06 164.37,112.06 156.88,104.57 156.88,100.31 147.41,90.83 141.56,90.83 141.34,90.62 131.26,90.62 v1(130.98,90.34)
  L6 w0.076: v1(236.24,45.79) 236.07,45.62 233.88,45.62
  L6 w0.127: v1(220.21,78.75) 218.83,77.37 218.83,69.1 219.14,68.79 219.14,66.17 219.87,65.43 219.87,63.11 222.31,60.67 222.31,53.03 221.24,51.96 221.24,49.36 222.12,48.48 228.44,48.48 231.3,45.62 233.88,45.62
  BOTTOM w0.13: v1(130.98,90.34) 128.81,88.17 128.81,86.12 128.41,85.72 128.12,85.72 127.91,85.51 127.45,85.51 127.06,85.13 126.78,85.13 126.65,85 Q4411.3 ; v1(184.19,116.34) 184.19,116.91 U4412.5 184.96,117.21 185.09,117.08 185.09,114.36 185.22,114.23 197.3,114.23 198.79,112.74 198.79,110.09 199.89,108.99 200.99,108.99 205.73,104.26 209.42,104.26 211.51,106.35 218.29,106.35 220.38,108.44 226.14,108.44 226.76,107.82 226.76,97.18 226.14,96.56 225.02,96.56 222.18,93.72 220.63,93.72 220.02,93.1 220.02,89.79 221.42,88.39 221.42,87.79 222.57,86.64 222.57,82.31 221.83,81.57 221.83,79.64 220.95,78.75 v1(220.21,78.75)
PCH_LAN_RST#: length 13.6
  TOP w0.076: 188.11,71.08 188,70.97 186.93,70.97 186.49,70.54 183.41,70.54 183.17,70.3 180.65,70.3 v3(180.62,70.27) 178.77,70.27 178.59,70.09 176.49,70.09 v1(176.09,69.7)
  TOP w0.102: R4768.2 188.11,71.08
  BOTTOM w0.089: U4555.CG12 v1(176.09,69.7)
PCH_LAN_SMCLK: length 83.7
  TOP w0.076: 186.74,69.58 186.47,69.58 186.15,69.25 182.7,69.25 182.5,69.06 182.34,69.06 182,68.72 v3(178.66,68.72) 178.31,69.08 177.14,69.08 v1(176.73,68.66)
  TOP w0.13: R2764.1 250.55,76.71 249.95,76.71 248.4,78.26 247.29,78.26 247.29,78.26 246.1,78.26 245.83,78 243.18,78 242.21,77.03 242.21,76.62 241.6,76.01 241.6,74.01 241.33,73.74 241.33,72.1 241.05,71.82 233.99,71.82 233.99,71.82 233.35,71.82 233.35,71.82 233.03,71.82 223.68,71.82 223.23,72.27 222.89,72.27 222.26,71.64 214.82,71.64 214.27,71.1 213.35,71.1 213.01,70.75 R4797.2 212.66,70.68 211.61,71.73 206.73,71.73 205.43,70.43 203.97,70.43 203.11,69.58 202.22,69.58 186.74,69.58
  BOTTOM w0.076: U4555.CH14 176.55,68.84 v1(176.73,68.66)
PCH_LAN_SMDATA: length 86.7
  TOP w0.076: 186.81,69.83 186.49,69.83 186.08,69.42 182.63,69.42 182.43,69.22 179.85,69.22 v3(179.83,69.24) 175.99,69.24 v1(175.44,68.7)
  TOP w0.13: 186.81,69.83 203.01,69.83 203.86,70.69 205.08,70.69 205.08,70.69 205.33,70.69 206.62,71.99 211.72,71.99 212.13,71.57 R4884.2 214.39,71.57 214.71,71.9 222.15,71.9 222.78,72.52 223.34,72.52 223.78,72.08 233.14,72.08 233.45,72.08 240.94,72.08 241.07,72.21 241.07,73.84 241.35,74.12 241.35,76.11 241.96,76.72 241.96,77.14 243.07,78.26 245.73,78.26 245.99,78.52 251.34,78.52 252.6,77.26 252.6,77.04 253.08,76.56 R2761.1
  BOTTOM w0.076: U4555.CF15 175.25,68.5 v1(175.44,68.7)
PCH_OPI_RCOMP: length 2.9
  TOP w0.254: v1(170.85,62.08) 171.28,62.08 171.29,62.08 172.16,62.94 v3(172.16,62.99) 172.2,62.95 R4588.2
  BOTTOM w0.2: U4555.BW25 171.17,61.75 v1(170.85,62.08)
PCH_PWROK: length 35.3
  TOP w0.102: v1(193.31,49.66) 194.57,48.4 v3(194.64,48.4) 196.31,48.4 R4511.2 R4552.2
  L6 w0.076: v1(168.58,57.91) 168.6,57.47 169.44,56.64 169.58,56.64 169.86,56.36 169.86,55.98 170.93,54.91 170.93,54.71
  L6 w0.102: 170.93,54.71 170.93,53 171.38,52.55 171.7,52.55 173.7,52.55 174.53,51.72 186.67,51.72 188.49,49.9 191.65,49.9 192.3,49.25 192.9,49.25 v1(193.31,49.66)
  BOTTOM w0.076: v1(168.58,57.91) 168.57,57.93 U4555.BP31
PCH_SLP_S0IX#: length 134.3
  TOP w0.076: v1(175.5,69.72) 175.95,70.17 176.33,70.17 176.42,70.26 178.52,70.26 178.7,70.44 180.08,70.44 180.41,70.77 181.67,70.77 182.01,71.11 182.65,71.11 v3(182.8,70.96) 183.06,70.7 186.41,70.7 187.73,72.02 188.11,72.02
  TOP w0.102: 188.11,72.02 R4772.2 ; R353.1 248.87,43.47 249.26,43.47 v1(249.27,43.46)
  L6 w0.076: 183.18,69.63 182.63,70.18 179.18,70.18 179.1,70.25 178.78,70.25 178.72,70.19 175.97,70.19 v1(175.5,69.72)
  L6 w0.102: 183.18,69.63 183.95,68.86 185.83,68.86 187.11,67.58 199.59,67.58 202.49,67.58 204.65,65.42 205.23,65.42 205.23,65.42 205.83,65.42 206.45,64.8 206.45,60.79 209.58,57.65 209.58,47.08 209.96,46.7 209.96,44.22 219.06,35.12 219.06,33.78 223.97,28.86 v1(231.3,28.86) ; v1(241.25,33.73) 243.19,33.73 245.79,31.13 245.79,31.09 246.03,30.85 246.62,30.85 247.44,31.67 247.44,31.68 249.55,33.79 249.55,34.4 249.31,34.64 249.03,34.64 248.41,35.26 248.41,42.61 v1(249.27,43.46)
  BOTTOM w0.102: v1(231.3,28.86) 231.41,28.76 233.07,28.76 233.45,29.13 233.45,31.74 233.85,32.15 234.63,32.15 234.73,32.25 235.03,32.25 235.79,33.01 237.43,33.01 238.14,33.73 v1(241.25,33.73)
  BOTTOM w0.13: U4555.CF12 175.44,69.75 175.44,69.74 175.46,69.72 v1(175.5,69.72)
PCH_SLP_SUS#: length 90.8
  TOP w0.076: U300.J6 238.88,43.24 v1(238.88,43.24)
  TOP w0.102: v1(193.56,50.52) 193.99,50.52 R4859.1
  L3 w0.076: v1(170.44,59.22) 170.99,59.76 171.56,59.76 171.88,59.44 171.88,57.74 172.1,57.52 172.43,57.52 172.46,57.56 172.74,57.56 173.06,57.23 173.06,56.87 174.27,55.66 176.18,55.66 177.66,54.18 177.66,54.08 177.84,53.9
  L3 w0.102: 177.84,53.9 178.7,53.04 186.51,53.04 188.83,50.72 192.54,50.72 192.74,50.52 v1(193.56,50.52)
  L6 w0.102: v2(206.37,37.76) 203.01,41.12 203.01,47.01 201.11,48.91 195.18,48.91 v1(193.56,50.52)
  BOTTOM w0.076: v1(238.88,43.24) 238.58,43.53 238.58,44.04 238.37,44.24 237.43,44.24 237.34,44.16 236.14,44.16 235.07,43.09 234.35,43.09 234.14,42.88 233.65,42.88 233.59,42.94 233.2,42.94 233.02,42.76 232.51,42.76
  BOTTOM w0.089: U4555.BU29 v1(170.44,59.22)
  BOTTOM w0.102: 232.51,42.76 231.88,42.76 231.81,42.83 231.41,42.83 231.41,42.83 229.9,42.83 229.9,42.83 226.43,42.83 225.47,41.87 225.47,40.83 225.22,40.58 223.72,40.58 223.64,40.5 219.45,40.5 218.54,41.42 214.29,41.42 214.03,41.16 212.72,41.16 210.11,38.55 209.88,38.55 209.29,37.97 206.58,37.97 v2(206.37,37.76)
PCH_SML1CLK: length 10.4
  BOTTOM w0.076: U4555.CN15 179.7,68.15 179.92,68.15 180.06,68.1 180.2,68.1 180.33,68.15 180.35,68.17 180.39,68.17 180.41,68.18 181.46,68.18 181.89,67.75 182.57,67.75 182.84,67.48 v3(184.68,67.48) 185.35,67.48 187.98,70.11 188,70.11
  BOTTOM w0.13: 188,70.11 R4827.2
PCH_SML1DATA: length 11.3
  BOTTOM w0.076: U4555.CM15 179.09,68.63 179.57,68.63 179.68,68.59 179.93,68.59 179.94,68.6 180.03,68.63 180.22,68.63 180.35,68.59 182.89,68.59 183.48,67.99 185.62,67.99 185.92,68.3 185.92,68.65
  BOTTOM w0.13: 185.92,68.65 185.92,68.75 v3(186.26,69.09) 187.89,70.72 R4856.2
PCH_SPKR: length 256.9
  TOP w0.254: Q500.G 11.69,42.11 R519.2 11.66,42.17 11.66,42.76 R517.1 11.3,42.97 11,43.27 10.34,43.27 9.13,42.05 v1(6.4,42.05)
  L5 w0.254: v1(6.4,42.05) 7.04,42.05 11.54,37.55 11.54,36.01 11.79,35.75 12.22,35.75 12.77,36.31 14.32,36.31 14.7,35.93 24.33,35.93 24.96,35.3 25.65,35.3 27.24,36.88 27.24,38.13 27.55,38.44 30.52,38.44 30.96,38 35.9,38 39.56,34.34 39.56,20.32 37.92,18.68 36.45,18.68 35.67,17.91 v1(35.67,17.91)
  L6 w0.254: v1(105.03,41.7) 105.03,40.73 104.21,39.92 102.1,39.92 94.69,32.5 94.69,30.95 84.38,20.64 81.71,20.64 80.34,19.27 74.27,19.27 72.9,20.64 68.29,20.64 66.36,22.56 66.03,22.9 53.49,22.9 51.97,24.42 50.11,24.42 47.67,21.98 47.67,19.71 46.68,18.73 46.68,16.68 46.1,16.1 45.39,16.1 44.55,16.93 36.65,16.93 v1(35.67,17.91)
  BOTTOM w0.076: U4555.CF35 174.84,55.57 174.84,55.02 174.75,54.83 174.68,54.68 174.68,54.31 174.71,54.27 174.86,54.06 174.89,53.88 176.35,52.43 179.17,52.43 183.23,48.37
  BOTTOM w0.102: 183.23,48.37 183.28,48.33 183.59,48.33 184.18,47.74 184.18,47.28 184.23,47.23 184.23,46.02 183.29,45.07 181.55,45.07 180.87,44.4 180.87,43.7 177.14,39.97 154.91,39.97 153.57,38.64 112.49,38.64 108.71,42.42 105.14,42.42 105.03,42.31 v1(105.03,41.7)
PCH_SPKR_R: length 4.7
  TOP w0.102: v3(14.42,46.67) 13.57,46.67 R508.1
  TOP w0.254: R517.2 11.45,44.59 12.08,45.22 12.08,45.22 C514.1 12.35,45.46 R508.1
PCH_SPKR_R_R: length 6.9
  TOP w0.254: R508.2 13.86,46.12 14.66,46.12 14.93,46.39 14.94,46.39 v3(15.69,46.39) 16.87,46.39 16.88,46.39 C515.1 17.62,46.29 17.62,46.29 R507.1 18.99,46.16 19.03,46.2 20.25,46.2 C527.2
PCH_TBT_PERST#: length 88
  TOP w0.076: 188.11,70.48 186.9,70.48 186.01,69.58 182.34,69.58 v2(182.24,69.68)
  TOP w0.102: R4727.2 190.81,70.55 190.49,70.22 190.04,70.22 189.98,70.28 189.77,70.5 R4678.2 189.38,70.55 189.31,70.48 188.11,70.48 ; v1(246.1,76.31) 244.93,75.13 244.93,73.08 244.73,72.89 U2701.2 ; v1(205.36,70.01) 206.83,71.49 211.51,71.49 212.73,70.27 215.63,70.27 216.74,71.38 232.85,71.38 233.16,71.38 233.16,71.38 234.17,71.38 234.17,71.38 241.24,71.38 241.78,71.92 241.78,73.55 242.05,73.82 242.05,75.82 242.66,76.43 242.66,76.85 243.16,77.35 v1(243.74,77.35)
  L3 w0.102: v2(182.24,69.68) 182.45,69.47 185.76,69.47 186.61,68.62 202.78,68.62 204.58,70.42 204.95,70.42 v1(205.36,70.01) ; v1(246.1,76.31) 244.78,76.31 v1(243.74,77.35)
  BOTTOM w0.076: U4555.CR12 180.47,70.26 181.62,70.26 182.19,69.7 v2(182.24,69.68)
PCH_TCK: length 34.2
  TOP w0.13: CN4920.55 124.43,73.15 126.03,74.74 v1(126.03,75.18) ; v1(146.51,74.13) 146.18,74.45 146.18,75.33 146.34,75.49 146.34,75.96 146.3,76 146.3,76.64 R4589.1
  L3 w0.097: v1(146.51,74.13) 146.51,74.42 145.54,75.4 145.54,77.15 143.96,78.73 141.5,78.73 140.61,79.62 136.81,79.62 131.81,74.61 126.6,74.61 v1(126.03,75.18)
  BOTTOM w0.13: v1(146.51,74.13) U4555.W6
PCH_TDI: length 54.4
  TOP w0.13: CN4920.56 116.08,73.15 115.59,73.64 115.59,73.67 115.47,73.79 115.47,76.29 114.14,77.61 114.14,78.07 113.87,78.35 113.87,79.74 R4615.1 115.08,80.96 115.59,80.96 116.88,82.25 117.64,82.25 119.99,84.59 120.2,84.59 123.03,84.59 v3(123.31,84.88) 123.67,84.88 126.38,87.59 137.54,87.59 v1(138.73,86.4) 138.73,85.19 140.55,83.37 142.77,83.37 145.33,80.8 145.33,79.75 145.3,79.72 145.3,75.03 v1(145.66,74.67)
  BOTTOM w0.13: v1(145.66,74.67) U4555.U5 ; R4891.2 v1(138.73,86.4)
PCH_TDO: length 61.5
  TOP w0.13: v1(147.06,75.05) 147.07,75.06 147.07,81.89 144.06,84.9 141.12,84.9 v1(139.61,86.4) 139.61,86.9 138.41,88.1 126.17,88.1 124.39,86.32 116.89,86.32 v3(116.61,86.04) 116.2,86.04 113.02,82.87 113.02,77.21 114.58,75.66 114.58,74.81 114.33,74.57 R4612.1 114.07,74.44 114.83,73.68 114.83,73.34 116.03,72.15 CN4920.52
  BOTTOM w0.13: R4807.2 v1(139.61,86.4) ; U4555.W5 v1(147.06,75.05)
PCH_TMS: length 52.6
  TOP w0.13: CN4920.58 115.98,73.64 115.85,73.77 115.85,77.38 114.61,78.62 R4614.2 115.14,79.06 116,79.06 116.92,79.98 116.92,80.42 120.32,83.82 124.02,83.82 126.11,85.9 135.1,85.9 v2(135.6,86.4) 139.52,82.49 141.84,82.49 142.23,82.09 142.95,82.09 144.56,80.48 144.56,80.07 144.52,80.03 144.52,79.07 144.16,78.71 143.58,78.71 143.31,78.44 143.21,78.44 142.58,77.82 142.58,75.87 143.09,75.36 143.15,75.36 v1(143.81,74.69)
  BOTTOM w0.076: v1(143.81,74.69) U4555.P5
  BOTTOM w0.13: R4886.2 v2(135.6,86.4)
PCH_WAKE#: length 384.4
  TOP w0.102: v1(203.24,53.65) 203.61,53.27 R1413.2 ; v1(199.69,46.84) 199.67,46.86 R4946.1 ; Q2701.3 249.16,71.59 v1(248.74,71.59) 248.46,71.31 R2759.2
  L3 w0.102: v1(99.92,35.24) 96.42,35.24 93.16,31.98 85.67,31.98 85.34,31.65 85.34,22.13 82.6,19.39 80.29,19.39 80.1,19.21 73.61,19.21 73.2,19.61 69.15,23.66 62.35,23.66 60.62,25.39 59.34,25.39 58.96,25.01 53.62,25.01 53.62,25.01 52.87,25.01 49.32,25.01 48.16,26.18 48.16,27.18 48.39,27.42 48.76,27.42 v1(49.17,27.01)
  L5 w0.102: v1(239.44,5.96) 239.44,8.41 242.21,11.18 242.21,14.01 242.39,14.19 242.39,17.63 242.39,18.14 238.48,22.04 238.48,22.3 233.19,27.6 232.61,27.6 232.28,27.6 232.28,27.6 230.84,27.6 230.28,28.16 219.63,28.16 217.57,30.22 217.4,30.22 213.33,30.22 199.69,43.87 v1(199.69,46.84) 199.69,50.96 200.55,51.82 202.05,53.32 202.91,53.32 v1(203.24,53.65)
  L6 w0.102: v1(239.44,5.96) 239.85,6.36 240.21,6.36 242.12,8.27 242.42,8.27 242.43,8.27 242.88,8.72 251.66,8.72 254.61,11.67 261.49,11.67 262.76,12.94 262.76,13.11 262.76,17.03 262.43,17.36 262.43,18.11 258.47,22.07 258.47,28.37 257.63,29.21 257.63,30.35 258.89,31.61 260.1,31.61 260.73,32.24 260.73,42.02 259.61,43.13 259.61,50.41 259,51.02 257.01,51.02 255.72,52.3 255.72,52.88 255.47,53.13 254.49,54.12 254.49,54.12 251.56,57.04 251.56,57.1 251.56,57.27 250.19,58.64 250.19,68.69 248.87,70 248.87,71.46 v1(248.74,71.59)
  BOTTOM w0.102: v1(99.92,35.24) 103.81,35.24 106.18,32.87 155.66,32.87 157.21,34.42 185.05,34.42 190.06,39.42 208.42,39.42 208.66,39.66 208.66,40 208.49,40.16 208.49,40.21 208.43,40.27 208.43,40.61 208.49,40.67 208.49,45.95 208.09,46.35 207.89,46.35 200.18,46.35 v1(199.69,46.84) ; v1(49.17,27.01) 49.58,27.42 50.47,27.42 R1303.2 50.65,27.49 50.86,27.7 51.99,27.7 52.5,27.18 52.5,26.85 52.23,26.58 52.23,23.73 51.8,23.3 Q1301.D
PCH_WAKE#_R: length 36.8
  TOP w0.102: v1(192.88,50.09) 193.68,50.09 195.13,48.64 197.01,48.64 R4947.2 197.58,48.21 197.58,48.09 198,47.66 198.75,47.66 v3(198.95,47.87) 199.02,47.94 R4946.2
  L3 w0.076: v1(170.44,58.58) 170.82,58.96 170.82,59.24 171.18,59.6 171.49,59.6 171.72,59.38 171.72,57.67 172.03,57.36 172.5,57.36 172.53,57.39 172.67,57.39 172.9,57.16 172.9,56.8 174.2,55.49 175.11,55.49 176.71,53.9
  L3 w0.102: 176.71,53.9 177.77,52.83 186.42,52.83 188.74,50.51 192.46,50.51 v1(192.88,50.09)
  BOTTOM w0.089: U4555.BU30 v1(170.44,58.58)
PCH_WAKE#_WWAN: length 3.1
  TOP w0.102: v3(203.48,52.19) 203.48,52.21 204.11,52.84 R1413.1 204.1,52.9 204.1,52.91 v1(204.1,53.65)
  BOTTOM w0.102: v1(204.1,53.65) 204.25,53.49 CN1400.23
PCH_WLAN_RST#: length 293.7
  TOP w0.102: v1(190.73,71.13) 190.64,71.21 R4771.2
  L3 w0.076: 180.51,70.25 177.29,70.25 v1(176.73,69.7)
  L3 w0.102: v1(190.73,71.13) 190.26,70.67 189.4,70.67 188.73,71.34 186.18,71.34 186.02,71.49 182.35,71.49 181.12,70.25 180.51,70.25
  L5 w0.076: 181.86,68.86 181.59,69.12 178.51,69.12 178.36,69.28 177.16,69.28 176.74,69.7 v1(176.73,69.7)
  L5 w0.102: 181.86,68.86 182.71,68.86 183.81,67.76 190.9,67.76 193.57,70.43 193.57,70.88 194.94,72.26 194.94,73.09 196.08,74.23 196.08,76.4 196.08,76.57 196.08,76.74 196.08,77.07 196.08,77.07 196.08,77.69 195.09,78.68 195.09,83.68 193.85,84.93 193.85,106.15 191.2,108.8 177.81,108.8 175.7,110.91 174.07,110.91 171.68,108.52 162.04,108.52 161.37,108.52 159.95,109.95 155.7,109.95 155.31,109.56 147.15,109.56 145.02,107.43 139.8,107.43 139.3,106.92 139.26,106.92 138.68,106.35 135.28,106.35 134.67,106.96 131.45,106.96 130.84,106.35 127.39,106.35 127.01,106.73 123.35,106.73 122.68,106.73 121.03,108.37 112.36,108.37 110.26,106.27 109.62,105.63 109.62,102.46 111.3,100.78 111.3,100.51 114.53,97.28 114.53,97.27 115.47,96.33 115.47,87.69 112.77,85 112.77,81.04 105.33,73.6 105.33,58.23 102.08,54.98 98.55,54.98 92.58,49.01 90.48,49.01 82.42,40.95 82.42,38.56 81.56,37.7 81.56,34.02 78.75,31.21 78.75,30.58 77.14,28.97 75.69,28.97 73.99,27.27 72.6,27.27 70.49,25.16 67.3,25.16 64.97,22.82 53.16,22.82 v2(52.27,21.93)
  BOTTOM w0.089: U4555.CH12 v1(176.73,69.7)
  BOTTOM w0.102: v2(52.27,21.93) 52.27,23.19 52.64,23.56 52.64,23.89 52.82,24.07 U1300.2
PCIE_RBIAS: length 1.2
  TOP w0.203: U2700.N16 v1(257.29,61.7)
  BOTTOM w0.254: v1(257.29,61.7) 257.29,61.67 257.81,61.15 R2708.2
PCIE_RCOMPN: length 3.6
  TOP w0.076: v3(176.15,75.58) 176.15,75.2 175.77,74.83 175.77,74.58 v1(175.23,74.03)
  TOP w0.203: v1(175.23,74.03) 174.75,74.51 R4608.2
  BOTTOM w0.2: U4555.CE6 v1(175.23,74.03)
PCIE_RCOMPP: length 4.5
  TOP w0.076: v3(176.22,77.18) 176.22,76.3 175.69,75.77 175.69,75.13 v1(175.23,74.67)
  TOP w0.203: v1(175.23,74.67) 175.23,75.04 174.8,75.47 R4608.1
  BOTTOM w0.2: U4555.CE5 v1(175.23,74.67)
PCIE_RX5_C_DN: length 4.7
  TOP w0.076: C2701.1 253.37,56.56 253.37,57.04 253.55,57.22 254.1,57.22 254.83,57.95 255.22,57.95 255.38,58.12 255.38,58.55 255.34,58.68 255.28,58.74 255.28,58.75 255.28,59.07 U2700.V22
PCIE_RX5_C_DP: length 4.7
  TOP w0.076: C2700.1 253.54,56.47 253.54,56.97 253.62,57.05 254.17,57.05 254.9,57.79 255.28,57.79 255.55,58.05 255.55,58.49 255.74,58.67 255.74,59.03 255.66,59.1 255.56,59.1 255.5,59.04 U2700.V23
PCIE_RX5_DN: length 117.3
  TOP w0.119: C2701.2 253.37,55.54 253.37,54.56 253.27,54.46 253.27,49.23 253.58,48.92 254.88,48.92 255.05,48.74 255.05,48.57 254.89,48.4 v1(254.86,48.4)
  L3 w0.076: v2(170.6,71.5) 170.6,71.64 172.09,73.13 172.09,75.52 172.62,76.06 173.23,76.06 174.98,77.81 174.98,78.05 175,78.07 175,78.09
  L3 w0.109: 175,78.09 175,78.82 178.76,82.58 181.89,82.58 182.22,82.91 191.7,82.91 192.63,81.98 195.14,79.47 195.32,79.47 197.29,79.47 197.44,79.32 197.88,79.32 201.53,75.67 201.53,75.57 201.89,75.2 205.05,75.2 208.76,71.49 209.46,71.49 210.82,70.13 210.82,67.83 212.95,65.7 217.18,65.7 217.44,65.44 218.21,65.44 218.82,64.84 218.94,64.84 219.71,64.07 220.85,64.07 224.42,60.5 224.95,60.5 225.46,59.98 226.03,59.98 227.12,58.89 227.7,58.89 227.9,58.68 227.9,58.18 228.64,57.44 233.11,57.44 233.32,57.23 238.02,57.23 240.05,55.2 242.57,55.2 246.81,50.96 248.99,50.96 249.94,50.01 252.56,50.01 253.67,48.91 254.95,48.91 255.06,48.8 255.06,48.58 254.89,48.4 v1(254.86,48.4)
  BOTTOM w0.076: v2(170.6,71.5) 170.97,71.87 U4555.BW9
PCIE_RX5_DP: length 117.4
  TOP w0.119: C2700.2 253.59,55.67 253.59,54.47 253.49,54.37 253.49,49.33 253.68,49.14 254.97,49.14 255.28,48.83 255.28,48.57 v1(255.47,48.38)
  L3 w0.076: v1(170.6,72.18) 170.91,72.18 171.92,73.2 171.92,75.59 172.56,76.22 173.16,76.22 174.81,77.88 174.81,78.05 174.79,78.07 174.79,78.09
  L3 w0.109: 174.79,78.09 174.79,78.91 178.67,82.79 181.8,82.79 182.13,83.12 191.78,83.12 192.84,82.07 195.23,79.68 197.38,79.68 197.53,79.53 197.97,79.53 201.74,75.76 201.74,75.65 201.98,75.41 205.14,75.41 208.85,71.7 209.55,71.7 211.03,70.22 211.03,67.92 213.04,65.91 217.27,65.91 217.53,65.66 218.3,65.66 218.91,65.05 219.03,65.05 219.8,64.28 220.94,64.28 224.51,60.71 225.03,60.71 225.55,60.19 226.12,60.19 227.21,59.1 227.78,59.1 228.12,58.77 228.12,58.26 228.73,57.65 233.2,57.65 233.4,57.44 238.11,57.44 240.14,55.41 242.66,55.41 246.9,51.17 249.08,51.17 250.02,50.22 252.65,50.22 253.76,49.12 255.04,49.12 255.27,48.89 255.27,48.58 v1(255.47,48.38)
  BOTTOM w0.076: U4555.BW8 170.73,72.18 v1(170.6,72.18)
PCIE_RX6_C_DN: length 3.9
  TOP w0.076: C2703.1 255.79,56.54 255.79,56.69 257.27,58.18 257.27,58.57 257.11,58.73 257.11,59.07 U2700.P22
PCIE_RX6_C_DP: length 3.9
  TOP w0.076: C2702.1 255.95,56.5 255.95,56.63 257.44,58.11 257.44,58.49 257.58,58.63 257.58,59.03 257.5,59.1 257.4,59.1 257.34,59.04 U2700.P23
PCIE_RX6_DN: length 112.6
  TOP w0.119: C2703.2 255.74,55.6 255.74,51.24 254.78,50.29 254.78,49.8 v1(254.58,49.6)
  L3 w0.076: v1(170.61,73.4) 170.61,73.52 170.99,73.9 170.99,74.08 171.16,74.24 171.16,75.16 173.94,77.94 173.98,77.94 174,77.96
  L3 w0.109: v1(254.58,49.6) 254.78,49.8 254.78,49.99 254.67,50.1 253.36,50.1 252.82,50.64 250.2,50.64 249.25,51.58 247.07,51.58 242.83,55.82 240.31,55.82 238.28,57.85 233.58,57.85 232.94,58.49 229.84,58.49 229.42,58.92 228.55,58.92 227.96,59.52 227.38,59.52 226.29,60.61 225.72,60.61 225.21,61.13 224.68,61.13 221.11,64.69 219.97,64.69 219.2,65.46 219.08,65.46 218.44,66.11 217.67,66.11 217.44,66.33 213.21,66.33 211.45,68.09 211.45,70.4 207.75,74.1 207.51,74.34 206.64,75.2 206.34,75.2 205.31,76.23 201.98,76.23 197.68,80.53 194.96,80.53 194.11,81.38 194.11,81.38 193.26,82.24 191.96,83.54 181.96,83.54 181.63,83.21 178.5,83.21 174.25,78.95 174.25,78.21 174,77.96
  BOTTOM w0.076: U4555.BU6 v1(170.61,73.4)
PCIE_RX6_DP: length 112.6
  TOP w0.119: v1(255.19,49.6) 255.01,49.78 255.01,50.2 255.96,51.15 255.96,55.6 C2702.2
  L3 w0.076: v2(170.61,74.06) 170.75,74.06 171,74.31 171,75.22 173.84,78.07 173.84,78.1 173.85,78.11
  L3 w0.109: v1(255.19,49.6) 254.99,49.79 254.99,50.08 254.76,50.31 253.45,50.31 252.91,50.85 250.28,50.85 249.34,51.79 247.16,51.79 242.92,56.03 240.4,56.03 238.37,58.06 233.66,58.06 233.02,58.7 229.93,58.7 229.5,59.13 228.64,59.13 228.04,59.73 227.47,59.73 226.38,60.82 225.81,60.82 225.29,61.34 224.77,61.34 221.2,64.9 220.06,64.9 219.29,65.67 219.17,65.67 218.52,66.32 217.75,66.32 217.53,66.54 213.3,66.54 211.66,68.18 211.66,70.49 211.53,70.61 207.96,74.19 207.59,74.55 207.59,74.55 206.73,75.41 206.43,75.41 205.4,76.44 202.07,76.44 197.77,80.75 195.05,80.75 194.2,81.59 192.04,83.75 181.87,83.75 181.54,83.42 178.41,83.42 174.04,79.04 174.04,78.3 173.85,78.11
  BOTTOM w0.076: U4555.BU5 v2(170.61,74.06)
PCIE_RX7_C_DN: length 3.7
  TOP w0.076: C2705.1 258.24,56.55 258.24,57.29 259.06,58.12 259.06,58.63 258.95,58.74 258.95,59.08 258.95,59.09 258.95,59.14 U2700.K22
PCIE_RX7_C_DP: length 3.6
  TOP w0.076: C2704.1 258.4,56.49 258.4,57.22 259.23,58.05 259.23,58.45 259.42,58.63 259.42,59.03 259.34,59.1 259.24,59.1 259.18,59.04 U2700.K23
PCIE_RX7_DN: length 117
  TOP w0.119: C2705.2 258.18,55.6 258.18,55.4 257.63,54.85 257.63,52.62 256.39,51.37 256.39,50.98 255.89,50.48 255.89,50.09 v1(255.7,49.9)
  L3 w0.076: 172.59,78.18 172.58,78.17 172.55,78.17 171.28,76.9 171.28,75.84 170.57,75.13 170.42,75.13 170.23,74.94 170.23,74.38 170.07,74.21 170.07,73.9 169.68,73.52 v1(169.68,73.4)
  L3 w0.109: 172.59,78.18 172.9,78.49 172.9,79.71 175.04,81.85 175.04,83.03 175.97,83.96 181.37,83.96 181.57,84.16 192.22,84.16 193.88,82.5 194.78,81.6 197.5,81.6 202.24,76.86 206.14,76.86 207.94,75.06 207.94,74.79 212.07,70.66 212.07,68.35 213.47,66.95 217.7,66.95 217.92,66.73 218.7,66.73 219.34,66.09 219.46,66.09 220.23,65.32 221.37,65.32 224.94,61.75 226.6,61.75 228.81,59.54 229.67,59.54 230.1,59.12 233.2,59.12 233.84,58.48 238.54,58.48 240.57,56.45 243.09,56.45 247.33,52.21 249.51,52.21 250.45,51.26 253.08,51.26 253.62,50.73 255.72,50.73 255.89,50.55 255.89,50.1 v1(255.7,49.9)
  BOTTOM w0.076: U4555.BT7 v1(169.68,73.4)
PCIE_RX7_DP: length 116.9
  TOP w0.119: v1(256.31,49.9) 256.11,50.09 256.11,50.39 256.61,50.88 256.61,51.28 257.51,52.18 257.85,52.52 v4(257.85,54.27) 257.85,54.76 258.4,55.31 258.4,55.6 C2704.2
  L3 w0.076: v1(169.68,74.06) 170.07,74.44 170.07,75.01 170.35,75.3 170.5,75.3 171.12,75.91 171.12,76.97 172.43,78.29 172.43,78.32 172.44,78.33
  L3 w0.109: 172.44,78.33 172.69,78.58 172.69,79.8 174.83,81.93 174.83,83.12 175.88,84.17 181.28,84.17 181.48,84.37 192.3,84.37 194.86,81.81 197.59,81.81 202.33,77.07 206.23,77.07 208.15,75.15 208.15,74.88 212.28,70.75 212.28,68.44 213.56,67.16 217.79,67.16 218.01,66.94 218.78,66.94 219.42,66.3 219.55,66.3 220.32,65.53 221.46,65.53 225.02,61.96 226.69,61.96 228.9,59.75 229.76,59.75 230.19,59.33 233.28,59.33 233.92,58.69 238.62,58.69 240.66,56.66 243.17,56.66 247.42,52.42 249.6,52.42 250.54,51.47 253.17,51.47 253.7,50.94 255.81,50.94 256.1,50.64 256.1,50.1 v1(256.31,49.9)
  BOTTOM w0.076: U4555.BT6 v1(169.68,74.06)
PCIE_RX8_C_DN: length 3.4
  TOP w0.076: U2700.F22 260.79,59.07 260.79,58.68 260.93,58.55 260.93,57.34 260.68,57.09 260.68,56.52 C2707.1
PCIE_RX8_C_DP: length 3.4
  TOP w0.076: U2700.F23 261.02,59.04 261.08,59.1 261.18,59.1 261.26,59.03 261.26,58.64 261.09,58.47 261.09,57.27 260.84,57.02 260.84,56.51 C2706.1
PCIE_RX8_DN: length 122.8
  TOP w0.119: C2707.2 260.64,55.6 260.64,53.45 259.48,52.29 259.1,51.91 258.71,51.91 258.62,51.99 258.59,51.99 v1(258.42,52.16)
  L3 w0.076: v1(169.68,71.49) 169.42,71.76 169.27,71.76 169.1,71.93 169.1,75.07 169.1,75.14 169.1,75.21 169.76,75.87 169.76,77.21 169.73,77.24 169.73,77.26
  L3 w0.109: 169.73,77.26 169.73,80.15 172.64,83.06 173.68,83.06 175.42,84.8 181.02,84.8 181.22,85 192.56,85 194.72,82.84 196.13,82.84 196.53,82.44 197.84,82.44 202.59,77.69 206.49,77.69 208.78,75.41 208.78,75.14 212.91,71.01 212.91,68.7 213.82,67.79 218.05,67.79 218.27,67.57 219.04,67.57 219.68,66.92 219.81,66.92 220.58,66.15 225.48,66.15 228.87,62.76 228.87,60.66 229.16,60.38 230.02,60.38 230.45,59.95 233.54,59.95 234.18,59.31 239.49,59.31 239.92,58.88 241.83,58.88 247.67,53.04 249.86,53.04 250.8,52.1 253.43,52.1 253.96,51.56 256.29,51.56 256.89,52.16 v1(258.42,52.16)
  BOTTOM w0.076: U4555.BU9 169.77,71.49 v1(169.68,71.49)
PCIE_RX8_DP: length 122.7
  TOP w0.119: v1(258.42,51.5) 258.6,51.69 259.19,51.69 v4(259.64,52.13) 260.86,53.36 260.86,55.6 C2706.2
  L3 w0.076: 169.94,77.26 169.94,77.24 169.92,77.21 169.92,75.8 169.26,75.14 169.26,75.07 169.26,72 169.34,71.92 169.48,71.92 v1(169.68,72.13)
  L3 w0.109: v1(258.42,51.5) 258.42,51.58 258.05,51.95 256.98,51.95 256.38,51.35 253.88,51.35 253.34,51.89 250.71,51.89 249.77,52.83 247.59,52.83 241.74,58.67 239.83,58.67 239.4,59.1 234.09,59.1 233.45,59.74 230.36,59.74 229.93,60.17 229.07,60.17 228.66,60.58 228.66,62.67 225.39,65.94 220.49,65.94 219.72,66.71 219.6,66.71 218.96,67.35 218.18,67.35 217.96,67.58 213.73,67.58 212.7,68.61 212.7,70.92 208.57,75.05 208.57,75.32 206.4,77.48 202.5,77.48 197.76,82.23 196.45,82.23 196.04,82.63 194.63,82.63 192.47,84.79 181.31,84.79 181.11,84.59 175.51,84.59 173.77,82.84 172.72,82.84 169.94,80.06 169.94,77.26
  BOTTOM w0.076: U4555.BU8 169.76,72.13 v1(169.68,72.13)
PCIE_RX9_DN: length 181.4
  L3 w0.109: v1(248.64,13.82) 248.92,14.1 249.31,14.1 250.47,15.27 251.84,15.27 252.2,15.63 252.2,18.16 249.23,21.13 249.23,21.92 248.83,22.33 247.89,22.33 246.96,23.26 246.96,25.25 247.45,25.74 247.45,29.06 248.61,30.22 248.61,30.96 250.4,32.75 250.4,33.44 255.63,38.66 256.39,38.66 260.07,42.34 260.07,42.52 260.27,42.71 260.27,55.06 259.31,56.01 252.94,56.01 252.16,56.79 249.23,56.79 243.44,62.58 243.44,62.65 241.87,64.21 235.8,64.21 227.54,72.47 220.34,72.47 217.93,74.88 217.35,74.88 211.93,80.31 211.93,80.44 209.11,83.25 209.11,85.53 207.03,87.62 201.79,87.62 199.44,89.97 178.42,89.97 177.47,90.91 169.35,90.91 166.95,88.52 166.95,81.32 167.74,80.53 167.74,78.44 168.3,77.89 168.3,74.92 168.06,74.68 v2(167.84,74.68)
  BOTTOM w0.076: v2(167.84,74.68) 168.05,74.47 U4555.BP5
  BOTTOM w0.119: CN1951.5 249.15,12.82 249.29,12.96 249.29,13.32 249.47,13.51 249.47,13.99 249.35,14.11 248.93,14.11 v1(248.64,13.82)
PCIE_RX9_DP: length 181.3
  L3 w0.109: v2(248.64,14.57) 248.89,14.31 249.22,14.31 250.39,15.48 251.75,15.48 251.99,15.72 251.99,18.07 249.02,21.04 249.02,21.83 248.74,22.12 247.8,22.12 246.75,23.17 246.75,25.34 247.24,25.83 247.24,29.14 248.4,30.3 248.4,31.04 250.19,32.84 250.19,33.52 255.54,38.87 256.31,38.87 259.86,42.43 259.86,42.6 260.05,42.8 260.05,54.97 259.22,55.8 252.85,55.8 252.07,56.58 249.14,56.58 243.23,62.49 243.23,62.56 241.79,64 235.71,64 227.46,72.26 220.25,72.26 217.84,74.67 217.26,74.67 211.71,80.22 211.71,80.35 208.9,83.16 208.9,85.44 206.94,87.41 201.7,87.41 199.35,89.76 178.33,89.76 177.38,90.7 169.44,90.7 167.17,88.43 167.17,81.41 167.95,80.62 167.95,78.53 168.51,77.98 168.51,74.83 168.24,74.56 168.24,74.52 167.84,74.12 v1(167.84,74.02)
  BOTTOM w0.076: U4555.BP6 168.06,73.82 v1(167.84,74.02)
  BOTTOM w0.119: CN1951.7 249.65,12.62 249.51,12.75 249.51,12.91 249.51,12.92 249.51,13.23 249.69,13.41 249.69,14.08 249.44,14.33 248.88,14.33 v2(248.64,14.57)
PCIE_RX10_DN: length 181.8
  L3 w0.076: v1(166.92,74.03) 166.92,74.16 167.07,74.31 167.07,74.31 167.3,74.54 167.32,74.56 167.32,74.64 167.46,74.79 167.46,76.04 167.49,76.06 167.49,76.08
  L3 w0.109: v2(252.08,13.72) 252.32,13.96 252.32,14.2 253.19,15.07 253.19,18.55 247.86,23.88 247.86,28.89 249.02,30.04 249.02,30.79 250.81,32.58 250.81,33.27 255.8,38.25 256.32,38.25 256.32,38.25 256.57,38.25 260.48,42.17 260.48,42.34 260.68,42.54 260.68,55.23 259.48,56.43 253.11,56.43 252.33,57.2 249.4,57.2 245.95,60.65 245.95,63.45 244.77,64.63 235.97,64.63 227.71,72.88 220.51,72.88 210.61,82.78 210.61,83.59 210.61,83.59 210.61,85.78 210.32,86.07 209.16,86.07 207.2,88.03 201.96,88.03 199.61,90.38 178.59,90.38 177.64,91.33 169.18,91.33 165.8,87.94 165.8,81.9 167.33,80.36 167.33,76.49 167.49,76.34 167.49,76.08
  BOTTOM w0.076: U4555.BN6 167.13,73.82 v1(166.92,74.03)
  BOTTOM w0.119: CN1951.17 252.15,12.99 252.31,13.15 252.31,13.43 v2(252.08,13.72)
PCIE_RX10_DP: length 181.9
  L3 w0.076: v1(166.92,74.69) 167.14,74.69 167.3,74.86 167.3,76.04 167.27,76.06 167.27,76.08
  L3 w0.109: v1(252.8,13.69) 252.53,13.96 252.53,14.11 253.4,14.98 253.4,18.64 248.07,23.97 248.07,28.8 249.23,29.96 249.23,30.7 251.02,32.49 251.02,33.18 255.89,38.04 256.23,38.04 256.23,38.04 256.65,38.04 260.69,42.08 260.69,42.26 260.89,42.45 260.89,55.32 259.57,56.64 253.2,56.64 252.42,57.41 249.49,57.41 246.16,60.74 246.16,63.53 244.86,64.84 236.06,64.84 227.8,73.1 220.6,73.1 210.82,82.87 210.82,83.23 210.82,85.87 210.4,86.28 209.24,86.28 207.29,88.24 202.05,88.24 199.7,90.59 178.68,90.59 177.73,91.54 169.09,91.54 165.58,88.03 165.58,81.81 167.12,80.28 167.12,76.41 167.27,76.25 167.27,76.08
  BOTTOM w0.076: v1(166.92,74.69) 167.14,74.47 U4555.BN5
  BOTTOM w0.119: CN1951.19 252.65,12.99 252.54,13.1 252.54,13.43 v1(252.8,13.69)
PCIE_RX11_DN: length 189.6
  L3 w0.076: v1(167.84,72.12) 167.26,72.12 166.37,73 166.37,75.17 166.35,75.2 166.35,75.21
  L3 w0.109: v2(255.89,15.37) 255.07,15.37 254.02,16.41 254.02,16.96 254.02,17.59 254.02,18.9 248.7,24.22 248.7,28.54 249.86,29.7 249.86,30.44 251.22,31.81 251.57,31.81 251.92,31.81 252.84,32.72 252.84,33.83 256.14,37.13 256.93,37.13 261.32,41.52 261.32,42 261.52,42.19 261.52,55.58 259.83,57.26 253.45,57.26 252.68,58.04 249.75,58.04 246.79,61 246.79,63.79 245.12,65.46 239.59,65.46 233.48,71.57 231.26,71.57 229.11,73.72 220.86,73.72 211.45,83.13 211.45,86.12 210.66,86.91 209.5,86.91 207.54,88.87 202.31,88.87 199.96,91.22 178.93,91.22 177.99,92.16 168.83,92.16 164.96,88.29 164.96,86.33 164.48,85.84 164.48,82.03 166.49,80.02 166.49,75.56 166.35,75.41 166.35,75.21
  BOTTOM w0.076: U4555.BN10 167.84,72.07 v1(167.84,72.12)
  BOTTOM w0.119: CN1951.29 255.15,13.64 255.01,13.78 255.01,15.06 255.32,15.37 v2(255.89,15.37)
PCIE_RX11_DP: length 189.6
  L3 w0.076: v2(167.84,72.78) 167.84,72.65 167.47,72.28 167.33,72.28 166.54,73.07 166.54,75.17 166.56,75.2 166.56,75.21
  L3 w0.109: 166.56,75.21 166.56,75.32 166.71,75.47 166.71,80.1 164.69,82.12 164.69,85.76 165.17,86.24 165.17,88.2 168.92,91.95 177.9,91.95 178.85,91.01 199.87,91.01 202.22,88.66 207.46,88.66 209.42,86.7 210.58,86.7 211.24,86.04 211.24,83.04 220.77,73.51 229.02,73.51 231.17,71.36 233.39,71.36 239.5,65.25 245.03,65.25 246.58,63.71 246.58,60.91 249.66,57.83 252.59,57.83 253.37,57.05 259.74,57.05 261.3,55.49 261.3,42.28 261.11,42.09 261.11,41.61 256.84,37.34 256.05,37.34 252.63,33.92 252.63,32.81 251.83,32.02 251.66,32.02 251.14,32.02 249.65,30.53 249.65,29.79 248.49,28.63 248.49,24.14 253.81,18.81 253.81,17.59 253.81,17.27 253.81,16.32 254.98,15.16 255.53,15.16 255.89,14.79 v1(255.89,14.71)
  BOTTOM w0.076: U4555.BN8 167.3,72.59 167.3,72.77 167.38,72.85 167.77,72.85 v2(167.84,72.78)
  BOTTOM w0.119: CN1951.31 255.65,12.99 255.37,13.27 255.37,13.73 255.23,13.87 255.23,14.97 255.41,15.15 255.53,15.15 255.89,14.78 v1(255.89,14.71)
