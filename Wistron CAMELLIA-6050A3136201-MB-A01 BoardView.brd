# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CCG5_VBUS_C_CTRL_P2: length 109.2
  TOP w0.076: v1(261.16,23.64) 261.32,23.8 261.32,24.58 U2403.B5
  TOP w0.102: v2(272.97,102.4) 272.97,102.13 272.37,101.53 270.46,101.53 269.59,102.39 268.41,102.39 265.67,99.66 263.48,99.66 263.38,99.56 263.38,97.9 263.11,97.63 Q2605.2 262.35,97.63 262.25,97.53 262.25,96.97 262.02,96.74 R2614.2 262.02,95.96 R2613.1
  L3 w0.102: v1(261.16,23.64) 261.36,23.64 263.51,25.79 263.51,30.27 264.03,30.79 264.24,31 266.1,31 274.05,38.94 274.05,41.33 274.05,42.52 273.86,42.71 273.86,53.03 273.51,53.39 271.68,55.21 271.68,69.85 271.68,70.46 272.01,70.79 272.01,72 272.01,72.29 272.29,72.58 272.29,80.98 273.2,81.89 273.2,90 v1(272.69,90.52)
  L6 w0.102: v1(272.69,90.52) 270.87,90.52 270.18,91.21 270.18,97.15 270.27,97.24 270.27,97.31 272.97,100.01 v2(272.97,102.4)
CCG5_VBUS_CSN1: length 2.3
  TOP w0.254: R2620.1 264.81,42.81 263.01,42.81
  vias: v3(261.97,46.98)
CCG5_VBUS_CSN1_R: length 1.9
  TOP w0.102: U2602.A4 264.75,41.63 R2620.2 v3(265.99,41.63)
CCG5_VBUS_CSN2: length 7.1
  TOP w0.254: R2604.1 266.45,98.21 266.98,98.73 v1(266.98,98.81)
  L6 w0.254: v1(265.8,93.03) 266.15,93.38 266.15,96.37 266.98,97.19 v1(266.98,98.81)
  vias: v3(266.85,90.87)
CCG5_VBUS_CSN2_R: length 1.6
  TOP w0.254: U2600.A4 266.85,95.96 266.85,96.95 R2604.2
CCG5_VBUS_P_CTRL_P1: length 13.9
  TOP w0.076: 262.32,30.03 262.32,29.11 262.57,28.86 U2403.K3
  TOP w0.13: 262.32,30.03 262.32,30.19 262.67,30.54 262.67,31.39 v1(263.47,32.19) ; v2(266.82,38.24) 266.94,38.36 266.94,38.36 Q2613.G
  L3 w0.097: v2(266.82,38.24) 267.61,37.46 267.61,36.14 263.66,32.19 v1(263.47,32.19)
  BOTTOM w0.13: v1(263.47,32.19) 263.8,32.52 R2422.1
CCG5_VBUS_P_CTRL_P1#: length 5.4
  TOP w0.102: v3(268.65,40.5) 268.15,40 R2628.1 267.41,39.62 Q2613.D 265.79,40.01 265.18,40.63 U2602.B4
CCG5_VBUS_P_CTRL_P2: length 94.6
  TOP w0.076: v1(261.97,23.64) 261.82,23.79 261.82,24.58 U2403.B4
  TOP w0.13: v1(276.4,91.94) 275.32,93.02 275.32,93.82 275.23,93.91 275.23,96.18 273.09,98.32 273.09,98.32 271.76,99.65 268.21,99.65 Q2602.G ; R2421.1 261.97,21.37 v1(261.97,23.64)
  L3 w0.097: v1(261.97,23.64) 261.97,23.75 263.87,25.64 263.87,26.03 263.87,26.04 263.87,30.12 264.39,30.64 266.25,30.64 274.19,38.59 274.4,38.79 274.4,41.19 274.4,42.67 274.22,42.85 274.22,53.18 274.01,53.38 273.65,53.74 272.03,55.36 272.03,70 272.03,70 272.03,70.32 272.36,70.64 272.36,72.15 272.64,72.43 272.64,80.84 273.55,81.75 273.55,89.07 276.4,91.92 v1(276.4,91.94)
CCG5_VBUS_P_CTRL_P2#: length 2.9
  TOP w0.102: U2600.B4 267.4,95.99 267.13,96.26 267.13,96.6 267.29,96.76 R2618.1 267.29,98.01 267.37,98.09 267.38,98.09 267.74,98.45 Q2602.D
CCG51_VCCD: length 9.6
  TOP w0.076: 256.73,24.07 257.83,24.07 258.34,24.58 258.7,24.58 258.95,24.83 U2403.B10
  TOP w0.102: 256.73,24.07 v3(252.96,24.07) 251.02,24.07 250.96,24.12 250.35,24.12 C2427.1
CFG<0>: length 43.7
  TOP w0.13: CN4920.9 124.21,61.65 124.71,62.15 124.71,62.92 124.97,63.17 124.97,63.62 130.07,68.72 v1(130.07,70.17) 130.07,75.95 131.91,77.79 134.81,77.79 135.88,78.86 136.46,78.86 137.32,79.72 138.04,79.72 138.29,79.97 143.04,79.97 143.16,79.85 143.64,79.85 v2(144.07,80.28) ; v1(126.56,70.7) 126.18,70.7 126.12,70.69 126.12,70.69 R4822.1
  L6 w0.127: v1(130.07,70.17) 129.53,70.7 129.53,70.7 v1(126.56,70.7)
  BOTTOM w0.076: U4555.T4 144.98,75.81 144.98,76.34 144.98,76.35 144.98,76.43 144.79,76.61 144.79,79.55 v2(144.07,80.28)
CFG<1>: length 37.8
  TOP w0.13: v2(142.03,80.55) 141.71,80.22 138.18,80.22 137.93,79.98 137.21,79.98 136.35,79.12 135.77,79.12 134.7,78.05 131.8,78.05 129.62,75.87 129.62,68.64 124.71,63.73 124.71,63.28 124.46,63.02 124.46,62.39 124.21,62.15 CN4920.11
  BOTTOM w0.076: 142.61,79.67 142.61,78.92 142.99,78.55 143.3,78.55 143.71,78.14 143.72,77.38 143.72,77.05 143.76,76.94 143.76,76.75 143.72,76.64 143.72,76.39 143.87,76.04 143.87,75.84 143.87,75.84 143.87,75.67 144.15,75.39 U4555.R4
  BOTTOM w0.13: v2(142.03,80.55) 142.03,80.25 142.61,79.67
CFG<2>: length 37.2
  TOP w0.13: CN4920.15 124.21,63.15 124.46,63.39 124.46,63.84 129.37,68.75 129.37,75.97 131.7,78.31 134.6,78.31 135.67,79.37 136.24,79.37 137.1,80.23 137.83,80.23 138.08,80.49 140.8,80.49 141.35,81.05 142.44,81.05 143.22,80.27 v1(143.33,80.27)
  BOTTOM w0.076: 144.52,78.5 144.6,78.42 144.6,76.3 U4555.T3
  BOTTOM w0.13: v1(143.33,80.27) 143.88,79.72 144.04,79.72 144.52,79.23 144.52,78.5
CFG<3>: length 47.7
  TOP w0.13: v2(142.99,79.2) 142.48,79.71 138.39,79.71 138.15,79.46 137.42,79.46 136.56,78.6 136,78.6 132.86,75.46 132.86,75.25 132.86,70 127.12,64.26 127.12,61.46 R4932.1 126.31,58.51 125.61,57.81 122.93,57.81 120.93,59.81 120.93,62.93 121.64,63.64 CN4920.17
  BOTTOM w0.076: 142.99,79.11 143.89,78.22 143.89,77.08 143.94,76.93 143.94,76.76 143.89,76.62 143.89,76.42 143.96,76.24 144.15,76.05 U4555.R3
  BOTTOM w0.13: 142.99,79.11 v2(142.99,79.2)
CFG<4>: length 34.9
  TOP w0.13: v2(133.18,79.28) 133.14,79.24 131.66,79.24 128.68,76.26 128.68,69.03 125.79,66.14 CN4920.27
  BOTTOM w0.076: U4555.J4 140.39,75.39 140.13,75.66 140.13,76.5 139.76,76.86 139.76,77.11 139.39,77.48 138.84,77.48 138.83,77.49 137.68,78.64 136.94,78.64 136.34,79.24
  BOTTOM w0.13: R4523.1 133.77,82.28 133.18,81.69 v2(133.18,79.28) 133.48,79.58 136,79.58 136.34,79.24
CFG<5>: length 33.8
  TOP w0.13: v1(138.05,81.47) 138.05,81.43 137.54,80.92 136.82,80.92 136.32,80.42 135.64,80.42 135.1,79.88 135.09,79.88 135.07,79.86 134.44,79.86 131.92,79.87 128.42,76.37 128.42,69.14 125.93,66.64 CN4920.29
  BOTTOM w0.076: U4555.M4 142.38,75.65 142.38,75.88 142.54,76.03 142.54,76.42 142.31,76.65 142.31,77.48 141.9,77.9 141.9,78.37 140.52,79.74 140.36,79.74
  BOTTOM w0.13: v1(138.05,81.47) 138.05,81.32 v3(139.1,80.26) 139.62,79.74 140.36,79.74
CFG<6>: length 31.3
  TOP w0.13: v2(136.13,80.97) 135.82,80.97 134.99,80.14 134.98,80.14 134.97,80.12 134.54,80.12 131.81,80.12 128.16,76.47 128.16,69.24 125.82,66.9 124.58,66.9 124.46,67.03 124.46,67.4 124.21,67.65 CN4920.33
  BOTTOM w0.076: 137.7,79.41 139.12,77.98 139.67,77.98 140.18,77.47 140.5,77.47 140.67,77.3 140.67,76.17 140.39,75.89 U4555.J3
  BOTTOM w0.13: 137.7,79.41 v2(136.13,80.97)
CFG<7>: length 33.1
  TOP w0.13: CN4920.35 123.79,68.15 123.92,68.02 124.34,68.02 124.46,67.9 124.46,67.77 124.71,67.51 124.71,67.29 124.84,67.16 125.71,67.16 127.91,69.35 127.91,76.58 131.71,80.38 134.65,80.38 134.86,80.38 135.71,81.22 135.71,81.25 135.93,81.47 137.29,81.47 v2(137.33,81.42)
  BOTTOM w0.076: 139.19,79.46 140.56,79.46 140.73,79.29 140.73,79.29 141.73,78.29 141.73,77.83 142.15,77.41 142.15,76.31 U4555.M3
  BOTTOM w0.13: 139.19,79.46 137.33,81.32 v2(137.33,81.42)
CFG<8>: length 47.4
  TOP w0.13: CN4920.10 119.59,61.65 120.29,60.95 120.29,59.72 122.72,57.29 125.89,57.29 126.99,58.4 126.99,60.61 127.63,61.25 127.63,64.05 133.37,69.79 133.37,74.69 v3(134.43,75.74) 137.63,78.95 138.36,78.95 138.61,79.2 140.93,79.2 141.48,78.64 141.89,78.64 141.95,78.7 143.2,78.7 143.63,79.13 v1(143.99,79.13)
  BOTTOM w0.076: v1(143.99,79.13) 144.01,79.11 144.01,78.7 144.41,78.3 144.41,77.01 144.24,76.83 144.24,76.6 U4555.R2
CFG<9>: length 55
  TOP w0.13: v2(141.69,79.14) 141.37,79.46 138.5,79.46 138.25,79.21 137.53,79.21 136.67,78.35 136.11,78.35 133.12,75.35 133.12,69.89 127.38,64.16 127.38,61.35 126.74,60.71 126.74,58.51 125.78,57.55 122.83,57.55 120.62,59.76 120.62,61.23 119.7,62.15 CN4920.12
  BOTTOM w0.076: v2(141.69,79.14) 141.69,78.84 142.06,78.47 142.06,77.98 142.48,77.56 142.48,76.87 U4555.N2
  BOTTOM w0.13: v2(141.69,79.14) 141.39,79.14 139.22,81.32 138.74,81.32 138.47,81.59 138.47,81.64 137.95,82.16 137.22,82.16 135.07,84.31 R4534.1
CFG<10>: length 43.8
  TOP w0.13: v1(140.81,81.82) 140.39,81.4 138.76,81.4 138.24,81.92 137.38,81.92 137.37,81.92 137.13,81.92 136.94,81.72 135.82,81.72 135.45,81.35 135.45,81.33 134.75,80.63 131.43,80.63 126.42,75.62 125.87,75.62 125.66,75.62 122.06,75.63 121.13,74.69 121.13,70.81 121.21,70.73 121.21,67.48 120.68,66.96 120.68,64.47 119.46,63.24 118.83,63.24 118.73,63.15 CN4920.16
  BOTTOM w0.076: 143.53,78.95 143.53,78.88 144.05,78.37 144.05,78.33 144.15,78.24 144.15,77.16 U4555.R1
  BOTTOM w0.13: v1(140.81,81.82) 141.67,80.97 142.21,80.97 142.49,80.69 142.49,80.35 143.53,79.31 143.53,78.95
CFG<11>: length 41.9
  TOP w0.13: v1(138.93,81.82) 138.7,81.82 138.35,82.18 137.27,82.18 137.27,82.17 137.02,82.17 136.83,81.98 135.72,81.98 135.19,81.46 135.19,81.44 134.65,80.89 131.33,80.89 126.32,75.88 125.98,75.88 125.98,75.88 125.76,75.88 121.96,75.88 120.87,74.79 120.87,70.7 120.95,70.62 120.95,67.59 120.43,67.07 120.43,64.57 119.5,63.64 CN4920.18
  BOTTOM w0.076: U4555.N1 142.64,77.36 142.64,77.63 142.24,78.03 142.24,78.6 142.12,78.72 142.12,79.3 141.86,79.56 141.51,79.56
  BOTTOM w0.13: 141.51,79.56 139.24,81.82 v1(138.93,81.82)
CFG<12>: length 36.7
  TOP w0.13: CN4920.28 119.26,66.14 119.66,66.54 119.66,67.43 120.16,67.94 120.16,70.32 120.1,70.38 120.1,75.11 121.64,76.65 126,76.65 131.17,81.83 131.2,81.82 v1(134.26,81.82)
  BOTTOM w0.076: 137.32,78.83 137.72,78.83 138.9,77.65 139.52,77.65 140.13,77.04 140.13,76.95 140.32,76.76 140.32,76.59 U4555.J2
  BOTTOM w0.13: v1(134.26,81.82) 134.32,81.82 137.32,78.83
CFG<13>: length 40
  TOP w0.13: CN4920.30 119.15,66.64 119.4,66.89 119.4,67.54 119.91,68.04 119.91,70.21 119.84,70.28 119.84,75.22 122.09,77.47 123.95,77.47 129.09,82.61 135.02,82.61 135.52,83.11 v2(135.53,83.11)
  BOTTOM w0.076: 138.83,79.26 140.53,79.26 140.66,79.13 140.66,79.13 141.57,78.23 141.57,77.76 141.98,77.35 141.98,76.78 U4555.L2
  BOTTOM w0.13: 138.83,79.26 136.63,81.46 136.63,82 v2(135.53,83.11)
CFG<14>: length 36.7
  TOP w0.13: CN4920.34 119.15,67.65 119.65,68.15 119.65,70.1 119.59,70.17 119.59,75.32 121.98,77.72 123.84,77.72 129.23,83.11 v2(134.21,83.11)
  BOTTOM w0.076: U4555.J1 140.25,77.16 139.59,77.82 138.97,77.82 137.71,79.07 137.44,79.07
  BOTTOM w0.13: 137.44,79.07 135.71,80.8 135.71,81.34 134.21,82.84 v2(134.21,83.11)
CFG<15>: length 38.4
  TOP w0.13: v1(134.87,83.11) 134.87,83.15 134.42,83.6 129.36,83.6 123.74,77.98 121.88,77.98 119.33,75.43 119.33,75.22 119.33,70.06 119.39,70 119.39,68.26 119.15,68.01 118.67,68.01 118.53,68.15 CN4920.36
  BOTTOM w0.076: U4555.L1 141.56,77.53 141.4,77.69 141.4,78.15 140.49,79.06 138.66,79.06
  BOTTOM w0.13: v1(134.87,83.11) 136.38,81.6 136.38,81.33 138.66,79.06
CFG<16>: length 43.9
  TOP w0.13: R4566.1 139.92,78.23 139.95,78.26 139.95,78.32 v2(140.31,78.68) 140.12,78.86 139.14,78.86 138.98,78.69 137.74,78.69 135.75,76.7 135.75,75.64 133.63,73.52 133.63,69.55 127.89,63.81 127.89,61.14 127.25,60.5 127.25,58.27 126.01,57.04 122.6,57.04 118.99,60.64 CN4920.6
  BOTTOM w0.076: U4555.L3 141.67,75.9 141.44,76.42 141.44,76.62 141.49,76.74 141.49,76.96 141.44,77.09 141.44,77.38 141.24,77.58 141.24,78.04 140.6,78.68 v2(140.31,78.68)
CFG<17>: length 43.1
  TOP w0.13: v1(139.54,78.44) 137.85,78.44 136.29,76.88 v3(136.29,76.49) 136.29,75.82 133.89,73.42 133.89,69.44 128.15,63.71 128.15,61.03 127.51,60.39 127.51,58.17 126.12,56.78 122.49,56.78 119.13,60.14 CN4920.4
  BOTTOM w0.076: v1(139.54,78.44) 139.55,78.44 139.7,78.29 140.68,78.29 141.07,77.91 141.07,77.51 141.27,77.31 141.27,77.06 141.32,76.93 141.32,76.76 141.28,76.65 141.28,76.38 141.44,76.01 141.44,75.66 141.71,75.39 U4555.L4
CFG<18>: length 45.8
  TOP w0.13: CN4920.24 119.28,65.15 119.92,65.78 119.92,67.33 120.42,67.83 120.42,70.42 120.36,70.49 120.36,75.01 121.74,76.39 126.11,76.39 131.12,81.4 134.44,81.4 134.68,81.65 134.68,81.67 135.5,82.49 136.58,82.49 v2(137.03,82.94)
  BOTTOM w0.076: 141.6,79.92 141.78,79.92 142.28,79.42 142.28,78.79 142.4,78.67 142.4,78.13 143.1,77.43 143.1,77.07 143.06,76.96 143.06,76.71 143.1,76.6 143.1,76.42 143.01,76.22 142.83,76.04 U4555.N3
  BOTTOM w0.13: 141.6,79.92 139.05,82.47 137.5,82.47 v2(137.03,82.94) 136.86,82.94 135.04,84.76 R4597.1
CFG<19>: length 44.2
  TOP w0.13: CN4920.22 119.37,64.65 120.17,65.44 120.17,67.22 120.68,67.72 120.68,70.53 120.61,70.59 120.61,74.9 121.85,76.14 125.87,76.14 126.21,76.14 131.22,81.15 134.54,81.15 134.94,81.54 134.94,81.56 135.61,82.24 136.72,82.24 136.92,82.43 137.16,82.43 137.17,82.43 137.23,82.43 v1(137.77,82.97)
  BOTTOM w0.076: 141.69,80.25 142.41,79.52 142.41,79.52 142.45,79.49 142.45,78.85 142.57,78.74 142.57,78.2 143.26,77.5 143.26,77.03 143.23,76.94 143.23,76.73 143.26,76.63 143.26,76.38 143.1,76.01 143.1,75.71 142.92,75.53 142.92,75.3 U4555.N4
  BOTTOM w0.13: v1(137.77,82.97) 138.97,82.97 140.32,81.62 140.32,81.62 140.61,81.33 141.69,80.25
CFG_RCOMP: length 1.3
  TOP w0.254: v2(148.44,74.67) 148.98,75.21 R4519.2
  BOTTOM w0.254: v2(148.44,74.67) 148.23,74.47 U4555.AB5
CL_CLK1: length 256.3
  L6 w0.076: 179.32,73.22 178.97,73.22 178.4,73.8 177.94,73.8 177.51,73.36 v1(177.08,73.36)
  L6 w0.127: 179.32,73.22 185.14,73.22 186.21,72.15 188.36,70 198.58,70 203.49,70 203.7,69.79 204.95,68.55 205.22,68.28 206.99,68.28 207.63,67.64 208.02,67.64 211.79,63.87 211.79,61.19 212.91,60.07 212.91,58.14 213.31,57.74 213.31,49.67 215.91,47.07 215.91,45.43 216.09,45.25 216.09,44.5 v1(215.9,44.31)
  BOTTOM w0.13: v1(215.9,44.31) 215.48,43.89 214.64,43.89 209.87,39.13 209.64,39.13 209.05,38.54 190.42,38.54 185.42,33.53 157.58,33.53 156.03,31.99 105.81,31.99 103.71,34.09 95.87,34.09 90.77,28.99 90.77,22.51 81.1,12.85 61.54,12.85 61.54,12.85 60.16,12.85 60.16,12.85 59.78,12.85 58.11,14.52 58.11,17.01 56.33,18.78 56.33,23.67 59.06,26.4 60.18,26.4 60.77,26.99 v3(61.87,26.99) 61.88,27 CN1300.42 ; U4555.CH7 v1(177.08,73.36)
CL_DATA1: length 254.2
  L6 w0.076: v1(177.08,72.72) 177.1,72.72 178.01,73.63 178.33,73.63 179.12,72.84 179.47,72.84
  L6 w0.127: v1(215.29,44.31) 215.71,44.73 215.71,45.1 215.53,45.27 215.53,46.91 212.24,50.2 212.24,53.7 212.43,53.89 212.43,60.01 211.41,61.03 211.41,63.71 207.86,67.26 207.47,67.26 206.83,67.9 205.06,67.9 204.68,68.28 203.86,69.1 203.34,69.62 201.44,69.62 201.44,69.62 198.74,69.62 198.74,69.62 188.2,69.62 184.98,72.84 179.47,72.84
  BOTTOM w0.13: CN1300.40 63.42,26.49 60.82,26.49 60.34,26.01 59.22,26.01 56.71,23.51 56.71,19.6 v3(56.92,19.39) 56.92,18.74 58.49,17.16 58.49,14.68 59.94,13.23 60.32,13.23 80.94,13.23 90.38,22.67 90.38,29.15 95.71,34.48 103.87,34.48 105.97,32.37 155.87,32.37 157.42,33.92 185.26,33.92 190.26,38.92 208.89,38.92 209.48,39.51 209.71,39.51 214.48,44.28 215.25,44.28 v1(215.29,44.31) ; U4555.CH8 v1(177.08,72.72)
CL_RST#1: length 251.9
  L6 w0.127: v1(215.29,44.92) 215.27,44.93 215.27,46.8 211.99,50.09 211.99,53.81 212.18,54 212.18,59.91 211.16,60.92 211.16,63.61 207.76,67.01 207.36,67.01 206.73,67.64 204.96,67.64 204.5,68.1 203.68,68.92 203.23,69.37 201.33,69.37 201.33,69.37 198.85,69.37 198.85,69.37 188.09,69.37 184.87,72.59 179.72,72.59 178.8,71.67 177.49,71.67 v1(177.08,72.07)
  BOTTOM w0.13: U4555.CH9 v1(177.08,72.07) ; CN1300.38 60.69,26 60.44,25.76 59.33,25.76 56.97,23.4 56.97,20.09 58.01,19.05 v3(58.01,18.71) 58.01,18.01 58.75,17.27 58.75,14.79 60.05,13.49 60.43,13.49 80.84,13.49 90.13,22.78 90.13,29.25 95.6,34.73 103.98,34.73 106.08,32.63 155.76,32.63 157.31,34.17 185.15,34.17 190.16,39.18 208.79,39.18 209.38,39.77 209.61,39.77 214.37,44.53 214.91,44.53 215.29,44.91 v1(215.29,44.92)
CLICK_PS2_CLK: length 4.3
  TOP w0.13: v1(105.71,6.66) 105.71,6.83 106.29,7.41 R401.1
  BOTTOM w0.13: v1(105.71,6.66) 105.71,6.76 106.25,7.29 CN303.3
CLICK_PS2_CLK_R: length 171.5
  TOP w0.076: v1(243.94,39) 243.93,39.01 U300.C1
  TOP w0.13: R426.1 239.42,34.83 240.11,35.53 240.23,35.53 241.13,36.42 v1(241.25,36.42) ; R401.2 108.95,7.08 109.93,7.08 110.17,7.32 110.17,7.33 v1(110.36,7.52)
  L3 w0.097: v1(243.94,39) 243.76,39 241.25,36.49 v1(241.25,36.42) 242.36,35.31 242.36,29.94 241.87,29.46 240.22,29.46 239.72,28.96 239.72,28.18 239.51,27.96 239.51,25.44 241.79,23.15 241.79,21.72 240.25,20.18 240.25,14.74 236.02,10.5 230.62,10.5 230.02,9.91 202.66,9.91 202.07,10.5 196.84,10.5 196.81,10.53 171.79,10.53 171.64,10.38 170.68,10.38 170.66,10.35 167.81,10.35 167.69,10.23 166.98,10.23 166.83,10.38 159.8,10.38 159.69,10.49 157.35,10.49 156.99,10.13 151.54,10.13 150.6,9.19 150.41,9.19 145.8,9.19 144.86,10.13 135.77,10.13 134.8,11.09 129.33,11.09 128.61,10.38 113.22,10.38 v1(110.36,7.52)
CLICKPAD_DISABLE#: length 187.8
  TOP w0.102: v1(240.13,28.79) 239.72,29.2 238.69,29.2 238.26,28.77 R449.2 238.06,29.35 R415.1
  L3 w0.102: v1(246.68,10.86) 245.82,10 241.45,10 240.26,8.8 236.22,8.8 235.4,7.99 232.2,7.99 231.41,7.2 231.41,6.17 231.05,5.81 230.03,5.81 227.92,3.7 222.66,3.7 221.44,4.92 217.34,4.92 v1(216.94,4.51) 214.75,6.7 206.26,6.7 205.13,7.83 192.19,7.83 191.55,8.47 190.29,8.47 177.67,8.47 173.76,4.56 172.73,4.56 162.34,4.56 160.52,6.39 150.85,6.39 149.7,7.53 139.74,7.53 139.64,7.63 139.3,7.63 138.31,6.64 136.07,6.64 135.67,7.05 133.9,7.05 133.69,6.85 132.1,6.85 130.76,8.19 115.39,8.19 111.78,4.59 105.81,4.59 105.76,4.64 103.75,4.64 103.15,5.24 103.15,5.24 v1(103.15,5.81)
  L6 w0.102: v1(246.68,10.86) 246.28,10.45 245.9,10.45 245.67,10.69 245.67,14.09 245.67,14.09 245.67,14.26 244.41,15.51 244.41,19.38 245.36,20.33 245.36,20.83 245.36,22.59 245.63,22.86 245.63,25.25 245.22,25.66 241.67,29.2 240.54,29.2 v1(240.13,28.79)
  BOTTOM w0.102: v1(216.94,4.51) 215.62,4.51 R407.1 ; CN303.1 105.25,7.72 103.34,5.81 v1(103.15,5.81)
CLICKPAD_DISABLE#_R: length 13.6
  TOP w0.076: v1(238.23,39.34) U300.D8
  TOP w0.102: v1(238.3,31.4) 238.25,31.35 R415.2 237.76,30.03 v3(237.54,29.81)
  L3 w0.076: v1(238.23,39.34) 238.17,39.34 237.79,39.71 237.39,39.71 236.88,39.21 236.71,39.21 236.25,38.75 236.25,35.56 236.5,35.32
  L3 w0.102: 236.5,35.32 237.77,34.05 237.77,32.32 237.89,32.2 237.89,31.5 237.99,31.4 v1(238.3,31.4)
CLICKPAD_INT#: length 3.1
  TOP w0.102: v2(106.37,6.79) 106.37,6.15 R4584.2 106.75,5.78 R4625.1
  BOTTOM w0.102: CN303.4 106.75,7.16 v2(106.37,6.79)
CLIK_KBL_INFO: length 190.8
  TOP w0.076: 242.13,35.72 242.13,37.86 241.8,38.19 U300.B2
  TOP w0.13: 242.13,35.72 242.13,35.13 241.57,34.56 241.57,34.07 241.86,33.78 242,33.78 242.28,33.5 R318.1 242.35,33.37 242.35,32.6 242.58,32.37 243.28,32.37 v1(243.86,31.79)
  L3 w0.102: v1(246.07,10.86) 245.46,11.47 242.64,11.47 240.28,9.11 232.76,9.11 231.2,7.55 231.2,6.26 230.97,6.02 229.94,6.02 227.83,3.91 222.74,3.91 221.48,5.17 216.57,5.17 214.83,6.91 206.34,6.91 205.21,8.03 192.27,8.03 191.63,8.68 191.38,8.68 177.59,8.68 173.68,4.76 162.43,4.76 160.6,6.59 150.93,6.59 149.79,7.74 139.82,7.74 139.72,7.84 139.22,7.84 138.22,6.85 136.16,6.85 135.75,7.25 133.81,7.25 133.61,7.05 132.19,7.05 130.84,8.4 114.14,8.4 110.53,4.79 105.89,4.79 105.84,4.84 104.12,4.84 v2(103.73,5.23)
  L6 w0.102: v1(243.86,31.79) 244.66,31.79 245.68,30.78 246.81,29.65 246.81,25.99 246.35,25.53 246.35,23.24 245.56,22.46 245.56,20.92 245.56,20.92 245.56,20.24 244.61,19.29 244.61,15.59 246.07,14.14 v1(246.07,10.86)
  BOTTOM w0.102: v2(103.73,5.23) 104.68,5.23 105.17,5.72 105.17,6.69 105.75,7.27 CN303.2
CLK_PCIE0_DN: length 173.8
  L6 w0.127: v1(260.96,13.73) 261.21,13.73 261.5,14.02 261.5,17.73 257.54,21.69 257.54,26.39 256.17,27.76 256.17,33.68 255.57,34.28 255.57,42.52 255.27,42.82 255.27,46.02 255.27,46.44 250.22,51.49 250.22,56.72 245.42,61.52 245.42,61.99 245.18,62.23 244.71,62.23 242.31,64.64 240.36,64.64 240.23,64.77 234.81,70.19 234.81,70.84 234.07,71.58 232.29,71.58 231.83,71.58 230.51,72.9 230.51,75.85 230.67,76 230.67,80.39 229.89,81.17 228.45,81.17 224.69,84.93 224.69,86.15 222.06,88.77 201.39,88.77 199,91.16 166.51,91.16 162.22,86.87 162.05,86.87 160.7,85.52 160.7,85.05 160.22,84.57 159.74,84.57 v1(159.48,84.32)
  BOTTOM w0.076: 160.03,80.88 160.03,80.86 160.05,80.83 160.05,79.52 159.24,78.71 159.24,77.01 159.06,76.83 159.06,76.36 158.95,76.25 158.86,76.25 158.76,76.35 158.76,76.48 U4555.AW2
  BOTTOM w0.119: CN1951.53 261.15,12.99 261.32,13.15 261.32,13.37 v1(260.96,13.73) ; v1(159.48,84.32) 159.75,84.58 159.91,84.58 160.03,84.46 160.03,80.88
CLK_PCIE0_DP: length 173.8
  L6 w0.127: v1(159.48,85.05) 159.74,84.8 160.13,84.8 160.47,85.15 160.47,85.61 161.96,87.1 162.12,87.1 166.41,91.39 199.1,91.39 201.48,89 222.15,89 224.91,86.24 224.91,85.02 228.54,81.4 229.98,81.4 230.9,80.48 230.9,75.9 230.74,75.75 230.74,72.99 231.93,71.81 232.2,71.81 234.17,71.81 235.04,70.94 235.04,70.29 240.46,64.86 242.4,64.86 244.81,62.46 245.27,62.46 245.65,62.08 245.65,61.61 250.45,56.81 250.45,51.58 255.5,46.54 255.5,42.91 255.8,42.61 255.8,34.37 256.4,33.78 256.4,27.85 257.77,26.48 257.77,21.79 261.73,17.82 261.73,13.74 v1(261.79,13.68)
  BOTTOM w0.076: U4555.AY3 159.23,76.32 159.23,76.76 159.4,76.94 159.4,78.64 160.22,79.46 160.22,80.83 160.25,80.86 160.25,80.88
  BOTTOM w0.119: 160.25,80.88 160.25,84.55 160,84.8 159.74,84.8 v1(159.48,85.05) ; CN1951.55 261.65,12.03 261.65,12.99 261.54,13.1 261.54,13.43 v1(261.79,13.68)
CLK_PCIE1_DN: length 122.2
  L3 w0.109: v1(220.44,85.69) 220.44,85.72 220.07,86.09 218.82,86.09 216.9,88.01 212.02,88.01 211.38,88.65 210.22,88.65 207.52,91.36 202.28,91.36 200.68,92.96 184.8,92.96 182.09,95.66 171.44,95.66 169.68,93.9 168.11,93.9 163.22,89.01 163.22,87.87 161.41,86.06 161.41,82.67 161.57,82.51 161.57,79.58 161.35,79.36 161.35,79.07 160.94,78.66 v1(160.94,78.63)
  BOTTOM w0.076: U4555.BC1 161.24,76.95 161.31,76.88 161.41,76.88 161.62,77.08 161.62,77.61 161.43,77.8 161.43,78.89 161.36,78.97 161.2,78.97 160.94,78.71 v1(160.94,78.63)
  BOTTOM w0.119: CN1400.53 211.75,53.27 212.02,53.54 212.02,54.51 212.66,55.15 215.42,55.15 216.61,56.33 218.52,56.33 219.27,57.08 219.27,59.2 219.79,59.73 219.79,64.67 220.64,65.51 221.47,65.51 222.27,66.32 222.27,75.68 219.54,78.42 219.54,79.62 219.54,81.56 220.95,82.98 v4(220.95,84.44) 220.95,85.73 220.83,85.85 220.61,85.85 v1(220.44,85.69)
CLK_PCIE1_DP: length 122.2
  L3 w0.109: v1(160.94,79.24) 161.36,79.66 161.36,82.43 161.2,82.58 161.2,86.14 163.01,87.95 163.01,89.1 168.02,94.11 169.6,94.11 171.36,95.87 182.18,95.87 184.89,93.17 200.77,93.17 202.37,91.57 207.6,91.57 210.31,88.86 211.47,88.86 212.11,88.22 216.99,88.22 218.91,86.3 v1(220.44,86.3)
  BOTTOM w0.076: U4555.BC2 161.44,76.71 161.48,76.71 161.78,77.01 161.78,77.68 161.6,77.87 161.6,78.96 161.42,79.13 161.05,79.13 v1(160.94,79.24)
  BOTTOM w0.119: v1(220.44,86.3) 220.67,86.07 220.92,86.07 221.17,85.83 221.17,82.89 v4(220.68,82.4) 219.76,81.47 219.76,79.72 219.76,78.51 222.49,75.77 222.49,66.23 221.56,65.29 220.73,65.29 220.01,64.57 220.01,59.64 219.49,59.11 219.49,56.98 218.62,56.11 216.7,56.11 215.51,54.93 212.75,54.93 212.24,54.41 212.24,53.36 212.25,53.35 CN1400.55
CLK_PCIE3_DN: length 136.2
  L6 w0.076: v2(163.17,79.24) 163.05,79.13 162.66,79.13 162.42,78.88 162.42,78.03 162.38,78 162.38,77.99
  L6 w0.127: v1(67.18,26.41) 67.36,26.58 67.36,26.83 68.69,28.16 73.08,28.16 73.5,28.16 74.16,28.82 79.89,28.82 81.02,29.95 82.35,29.95 88.73,36.34 88.92,36.34 90.7,36.34 101.82,47.46 111.5,47.46 113.47,49.42 113.47,58.55 115.83,60.91 116.17,60.91 118.73,63.47 119.24,63.47 119.77,64 119.77,66.8 122.78,69.81 122.78,72.13 124.75,74.1 128.54,74.1 131.06,76.62 137.02,76.62 137.57,77.16 138.85,77.16 139.41,76.6 161.14,76.6 162.38,77.84 162.38,77.99
  BOTTOM w0.076: v2(163.17,79.24) 163.28,79.13 163.65,79.13 164.26,78.52 164.26,76.56 164.12,76.42 164.12,76.31 U4555.BH3
  BOTTOM w0.119: CN1300.49 70.01,28.75 69.87,28.61 69.07,28.61 67.38,26.92 67.38,26.61 v1(67.18,26.41)
CLK_PCIE3_DP: length 136.2
  L6 w0.076: v1(163.02,78.58) 163.02,78.81 162.87,78.96 162.73,78.96 162.58,78.81 162.58,78.04 162.61,78.01 162.61,77.99
  L6 w0.127: v1(67.76,26.41) 67.76,26.91 68.78,27.93 72.98,27.93 73.6,27.93 74.26,28.59 79.98,28.59 81.11,29.72 82.44,29.72 88.83,36.11 90.79,36.11 101.92,47.23 111.6,47.23 113.69,49.33 113.69,58.46 115.92,60.68 116.27,60.68 118.83,63.24 119.33,63.24 120,63.91 120,66.7 123.01,69.71 123.01,72.03 124.85,73.87 128.63,73.87 131.15,76.39 137.12,76.39 137.66,76.93 138.75,76.93 139.32,76.37 161.23,76.37 162.61,77.74 162.61,77.99
  BOTTOM w0.076: v1(163.02,78.58) 163.02,78.65 163.23,78.86 163.33,78.86 163.43,78.97 163.58,78.97 164.1,78.45 164.1,76.63 163.96,76.48 163.96,76.05 U4555.BH4
  BOTTOM w0.119: v1(67.76,26.41) 67.6,26.57 67.6,26.83 69.16,28.39 69.87,28.39 70.01,28.25 CN1300.47
CLK_PCIE5_DN: length 129
  TOP w0.119: U2700.T19 v1(256.63,61.04)
  L3 w0.109: v1(256.63,61.04) 256.29,60.7 256.29,60.63 256.23,60.56 256.23,60.29 255.43,59.49 249.87,59.49 247.9,61.46 247.9,64.25 245.58,66.58 240.05,66.58 233.94,72.69 231.72,72.69 229.57,74.84 221.32,74.84 212.97,83.19 212.97,86.73 212.32,87.38 211.77,87.38 211.13,88.02 209.97,88.02 208.01,89.98 202.77,89.98 200.42,92.33 184.54,92.33 181.83,95.04 171.7,95.04 169.94,93.28 168.37,93.28 163.84,88.75 163.84,87.61 162.03,85.8 162.03,82.93 162.61,82.36 162.61,79.39 v2(161.98,78.76)
  BOTTOM w0.076: U4555.BE1 162.36,77.09 162.4,77.06 162.44,77.06 162.46,77.08 162.46,77.09 162.47,77.1 162.47,77.47 162.46,77.49 162.46,78.93 162.38,79.01 162.22,79.01 v2(161.98,78.76)
CLK_PCIE5_DP: length 129.1
  TOP w0.119: U2700.V19 v1(255.99,61.04)
  L3 w0.109: v1(255.99,61.04) 256.08,60.95 256.08,60.72 256.01,60.65 256.01,60.38 255.34,59.7 249.96,59.7 248.11,61.55 248.11,64.34 245.67,66.79 240.14,66.79 234.03,72.9 231.81,72.9 229.66,75.05 221.41,75.05 213.18,83.27 213.18,86.82 212.41,87.59 211.85,87.59 211.21,88.24 210.05,88.24 208.09,90.19 202.86,90.19 200.51,92.54 184.63,92.54 181.92,95.25 171.62,95.25 169.85,93.49 168.28,93.49 163.63,88.84 163.63,87.69 161.82,85.88 161.82,82.84 162.4,82.27 162.4,79.53 162.29,79.42 v1(161.98,79.42)
  BOTTOM w0.076: v1(161.98,79.42) 162.23,79.17 162.45,79.17 162.62,79 162.62,77.56 162.64,77.54 162.64,77.03 162.63,77.02 162.63,77.01 162.36,76.74 U4555.BE2
CLK_PCIE_XDP_DN: length 48.4
  TOP w0.119: CN4920.42 118.82,69.65 v1(118.91,69.76)
  L6 w0.127: v1(118.91,69.76) 119.11,69.53 119.54,69.53 120.7,70.7 120.7,71.71 121.28,72.29 122.01,72.29 124.48,74.76 128.26,74.76 130.85,77.34 136.81,77.34 137.29,77.82 139.12,77.82 139.69,77.26 153.71,77.26 155.56,79.11 156.51,79.11 v1(156.77,79.36)
  BOTTOM w0.076: v1(156.77,79.36) 157.05,79.08 157.44,79.08 157.62,78.9 157.62,77.97 157.14,77.48 157.14,76.95 157.17,76.92 157.24,76.92 U4555.AU1
CLK_PCIE_XDP_DP: length 48.3
  TOP w0.119: CN4920.40 118.83,69.15 118.87,69.1 v1(118.89,69.1)
  L6 w0.127: v1(118.89,69.1) 119.09,69.31 119.63,69.31 120.93,70.6 120.93,71.62 121.37,72.06 122.11,72.06 124.57,74.53 128.36,74.53 130.94,77.11 136.9,77.11 137.39,77.59 139.03,77.59 139.59,77.03 153.81,77.03 155.66,78.88 156.51,78.88 v1(156.84,78.63)
  BOTTOM w0.076: U4555.AU2 157.24,76.76 157.1,76.76 156.97,76.89 156.97,77.55 157.45,78.03 157.45,78.84 157.38,78.91 157.13,78.91 v1(156.84,78.63)
CLKIN_XTAL: length 169.1
  L3 w0.097: v2(59.36,33.47) 59.83,32.99 66.91,32.99 70.25,36.34 71.02,36.34 71.57,36.89 72.13,36.89 72.67,37.42 73.1,37.42 73.35,37.68 74.22,37.68 75.24,38.7 76.18,38.7 77.58,40.1 89.58,40.1 89.82,40.35 92.38,40.35 95.86,43.83 112.82,43.83 115.51,46.52 115.51,54.2 114.71,55 114.71,59.13 119.02,63.44 119.92,63.44 120.61,64.13 121.6,64.13 126.13,68.66 133.14,68.66 134.53,70.05 162.08,70.05 162.25,70.22 162.79,70.22 163.76,71.19 163.76,71.56 163.99,71.79 167.62,71.79 167.68,71.72 168.01,71.72 168.76,72.48 168.76,80.96 171.72,83.91 173.54,83.91 175.04,85.41 176.88,85.41 177.29,85.81 180.16,85.81 v1(180.54,85.43)
  BOTTOM w0.076: U4555.CM3 178.52,76.53 179.03,77.05 179.03,78.06 179.26,78.28
  BOTTOM w0.13: R1337.1 59.86,33.97 v2(59.36,33.47) ; 179.26,78.28 181.57,80.6 181.57,82.79 181.15,83.21 181.15,83.22 180.68,83.69 R1336.2 180.54,84.61 v1(180.54,85.43)
CLKIN_XTAL_R: length 3.2
  BOTTOM w0.13: CN1300.64 63.35,32.58 62.42,32.58 61.87,33.13 v3(61.87,33.44) 61.34,33.97 R1337.2
CLKREQ#_DGPU: length 39.4
  TOP w0.076: 182.88,56.01 182.52,55.66 176.88,55.66 176.07,56.47 v3(175.97,56.47) 175.43,57.01 175.43,58.14 v1(175,58.57)
  TOP w0.13: R4711.2 209.04,61.53 208.34,61.53 208.08,61.28 208.08,61 207.41,60.33 201.11,60.33 200.98,60.45 193.73,60.45 191.77,58.49 188.03,58.49 187.89,58.35 187.21,58.35 186.6,57.74 184.91,57.74 183.19,56.01 182.88,56.01
  BOTTOM w0.089: v1(175,58.57) U4555.CE30
CLKREQ#_SSD: length 134.8
  TOP w0.13: v1(199.23,54.94) 198.2,54.94 R4718.2
  L3 w0.097: v1(246.1,47.92) 245.89,47.92 243.32,50.49 235.48,50.49 235.16,50.16 234.37,50.16 226.04,50.16 225.94,50.27 219.71,50.27 219.56,50.27 218,51.83 217.71,51.83 210.63,51.83 207.24,55.22 200.16,55.22 200.01,55.37 199.68,55.37 199.25,54.94 v1(199.23,54.94)
  L6 w0.127: v1(175.91,57.31) 175.91,56.71 176.93,55.69 178.64,55.69 180.32,57.36 192.77,57.36 192.95,57.18 195.19,54.94 v1(199.23,54.94) ; v1(246.1,47.92) 246.1,45.73 246.78,45.05 249.46,45.05 249.84,44.67 249.84,39.17 248.98,38.31 248.98,36.2 249.11,36.07 249.58,36.07 250.12,35.52 250.12,33.55 248.01,31.44 248.01,31.44 247.48,30.9 247.48,25.7 246.92,25.14 246.92,20.79 245.49,19.36 245.49,16.66 246.82,15.33 v1(248.76,15.33)
  BOTTOM w0.089: v1(175.91,57.31) U4555.CF32
  BOTTOM w0.13: v1(248.76,15.33) 253.42,15.33 254.13,16.04 254.73,16.04 255.07,16.37 256.4,16.37 257.09,15.68 258.17,15.68 260.9,18.41 CN1951.52
CLKREQ#_TBT_D: length 11.5
  TOP w0.076: v1(254.69,66.25) U2700.Y6
  TOP w0.102: D2700.1 246.94,65.66 248.1,66.83 248.1,66.89 v2(249.12,67.91) R2728.2
  BOTTOM w0.076: v1(254.69,66.25) 254.59,66.25 253.59,67.25 251.96,67.25
  BOTTOM w0.102: v2(249.12,67.91) 249.17,67.86 250.04,67.86 250.65,67.25 251.96,67.25
CLKREQ#_TR: length 209.5
  TOP w0.102: v1(204.72,56.45) 205.13,56.89 R4725.2 ; v1(247.45,68.26) 246.94,67.75 D2700.2
  L3 w0.102: v2(196.72,56.86) 197.25,56.33 199.24,56.33 199.27,56.35 201.44,56.35 202.35,57.27 203.98,57.27 204.52,56.73 204.52,56.66 v1(204.72,56.45)
  L5 w0.102: v1(238.91,6.34) 239.09,6.52 239.09,8.35 242.01,11.27 242.01,14.1 242.19,14.27 242.19,17.71 242.19,18.05 237.93,22.31 237.62,22.31 232.53,27.4 232.36,27.4 230.76,27.4 230.2,27.95 219.54,27.95 217.48,30.01 213.25,30.01 199.28,43.98 199.28,47.01 199.48,47.21 199.48,51.04 200.47,52.03 201.96,53.53 202.73,53.53 202.83,53.63 202.83,54.42 203.71,55.31 204.25,55.31 204.72,55.78 v1(204.72,56.45)
  L6 w0.102: v1(247.45,68.26) 248.19,68.26 248.95,67.5 249.51,67.5 249.98,67.03 249.98,58.56 251.36,57.19 251.36,56.96 254.4,53.91 255.33,52.99 255.52,52.79 255.52,52.22 256.92,50.81 258.91,50.81 259.41,50.32 259.41,43.22 259.41,43.05 260.52,41.93 260.52,32.32 260.02,31.82 258.81,31.82 257.43,30.44 257.43,29.12 258.26,28.28 258.26,21.99 262.23,18.03 262.23,17.28 262.56,16.95 262.56,13.02 261.41,11.88 254.53,11.88 251.58,8.93 242.79,8.93 242.35,8.49 242.34,8.47 242.03,8.47 240.13,6.57 239.14,6.57 v1(238.91,6.34) ; v2(196.72,56.86) 194.6,56.86 193.29,58.16 180.45,58.16 179.12,56.84 176.57,56.84 176.37,57.04 176.37,57.49 v1(175.91,57.95)
  BOTTOM w0.089: U4555.CF31 v1(175.91,57.95)
CLKREQ#_WLAN: length 291.3
  TOP w0.13: R4705.2 200.18,53.79 200.02,53.95 199.62,53.95 v1(199.23,54.33)
  L6 w0.127: v1(175.04,57.9) 175.5,57.44 175.5,56.8 176.84,55.46 178.72,55.46 180.37,57.11 192.66,57.11 195.22,54.55 199.01,54.55 v1(199.23,54.33) 199.6,53.96 200.02,53.96 200.73,54.68 202.53,54.68 202.82,54.39 202.82,49.52 203.91,48.42 203.91,41.86 210.03,35.75 214.25,35.75 224.43,25.56 229.67,25.56 232.05,23.19 233.58,23.19 233.83,22.94 233.83,22.67 236.09,20.41 236.28,20.41 240.12,16.56 240.12,14.19 238.66,12.73 170.77,12.73 170.26,13.24 93.4,13.24 93.34,13.3 88.59,13.3 83.24,18.65 71.42,18.65 69.89,20.17 68.13,20.17 65.84,22.46 52.31,22.46 v2(50.88,23.89)
  BOTTOM w0.089: v1(175.04,57.9) 175.03,57.93 U4555.CE31
  BOTTOM w0.13: v2(50.88,23.89) 51,24.01 R1351.1
CLKREQ#_WWAN: length 46
  TOP w0.13: v2(198.62,53.98) 197.88,53.98 197.38,53.48 R4721.2
  L3 w0.097: v1(207.39,55.77) 207.06,55.44 200.26,55.44 200.1,55.6 199.58,55.6 199.33,55.35 199.07,55.35 198.62,54.9 v2(198.62,53.98)
  L6 w0.127: v1(175.02,57.3) 175.15,57.17 175.15,56.84 176.75,55.24 178.81,55.24 180.42,56.85 192.56,56.85 195.4,54.01 195.91,53.98 v2(198.62,53.98)
  BOTTOM w0.089: v1(175.02,57.3) 175.01,57.31 U4555.CE32
  BOTTOM w0.13: CN1400.52 211.5,57.99 208.84,55.33 207.82,55.33 v1(207.39,55.77)
CLKREQ_WLAN_R_N: length 26.4
  TOP w0.13: R1304.2 55.25,24.93 52.47,24.93 v2(51.79,25.62)
  L3 w0.097: v2(51.79,25.62) 51.84,25.56 55.41,25.56 58,28.16 64.74,28.16 65.2,27.7 67.4,27.7 v1(67.94,28.25)
  BOTTOM w0.13: R1351.2 51.78,25.61 v2(51.79,25.62) ; CN1300.53 68.7,29.75 67.94,29 v1(67.94,28.25)
CN1951_PEDET: length 13.4
  TOP w0.102: v1(265.04,13.19) 265.54,12.69 266.76,12.69 R1954.2 267.39,11.36 263.24,11.36 262.26,10.38 v3(261.87,10.38) 260.52,10.38 R1952.2 260.42,11.2 Q1951.G
  BOTTOM w0.102: CN1951.69 265.15,13.08 v1(265.04,13.19)
CNV_BRI_DT: length 19.7
  L6 w0.076: 183.18,63 179.25,63 178.28,63.97 177.88,63.97 v1(177.34,64.51)
  L6 w0.127: v1(192.78,61.28) 192.36,61.7 189.02,61.7 187.65,63.07 185.78,63.07 185.71,63 183.18,63
  BOTTOM w0.13: R1312.2 193.32,60.74 v1(192.78,61.28) 192.78,61.38 R1344.1 R1345.2 ; U4555.CJ20 v1(177.34,64.51)
CNV_BRI_DT_R: length 207.7
  L6 w0.127: v2(205.84,44.57) 205.42,45.04 205.42,54.75 204.77,55.4 203.36,55.4 203.02,55.74 202.6,55.74 201.58,56.76 201.58,57.82 200.14,59.26 194.32,59.26 v1(193.82,59.76)
  BOTTOM w0.13: v1(193.82,59.76) 193.78,59.76 R1312.1 ; CN1300.36 62.28,25.5 62.08,25.71 60.76,25.71 60.55,25.5 59.43,25.5 57.23,23.3 57.23,20.2 58.52,18.9 58.52,17.86 59,17.38 59,14.89 60.15,13.74 60.53,13.74 61.17,13.74 61.17,13.74 80.73,13.74 89.87,22.88 89.87,29.36 96.17,35.66 103.73,35.66 104.22,35.18 106.28,33.11 155.56,33.11 157.11,34.66 184.95,34.66 193.44,43.15 195.6,43.15 197.01,44.57 v2(205.84,44.57)
CNV_BRI_RSP: length 218.7
  L6 w0.076: v2(178,64.5) 178.06,64.5 179.39,63.17 182.11,63.17 182.27,63.32 183.18,63.32
  L6 w0.127: v1(205.84,45.68) 205.72,45.8 205.72,56.99 203.2,59.51 195.04,59.51 193.65,60.89 193.65,61.12 192.82,61.95 189.13,61.95 187.76,63.32 183.18,63.32
  BOTTOM w0.13: U4555.CK20 177.85,64.85 177.93,64.57 v2(178,64.5) ; v1(205.84,45.68) 197.04,45.68 195.28,43.92 193.12,43.92 184.63,35.43 156.79,35.43 155.24,33.88 106.6,33.88 105.86,34.62 104.05,36.43 95.85,36.43 89.1,29.68 89.1,23.2 80.41,14.51 60.47,14.51 59.77,15.21 59.77,17.7 59.29,18.18 59.29,19.22 58,20.52 58,21.75 58.93,22.68 59.79,22.68 60.06,22.41 R4905.1 R1313.2
CNV_BRI_RSP_R: length 2.6
  BOTTOM w0.13: R1313.1 61.59,22.34 v3(61.87,22.62) 62.49,22 CN1300.22
CNV_CLKREQ: length 279.4
  L6 w0.076: v1(176.82,59.28) 177.4,59.28 177.69,59 183.15,59
  L6 w0.127: 183.15,59 192.98,59 193.33,58.65 199.77,58.65 200.54,57.88 200.54,57.49 200.54,56.92 202.53,54.93 202.8,54.93 203.03,54.69 203.55,54.69 203.68,54.57 203.68,52.37 204.52,51.53 204.52,49.91 204.15,49.55 204.15,49.2 204.17,49.18 204.17,41.96 210.13,36 214.35,36 224.54,25.81 229.78,25.81 232.15,23.44 233.69,23.44 234.16,22.97 234.16,22.7 236.17,20.69 236.44,20.69 240.38,16.75 240.38,14.09 238.76,12.47 170.67,12.47 170.16,12.98 93.3,12.98 93.24,13.04 88.48,13.04 83.13,18.39 70.15,18.39 68.62,19.92 68.02,19.92 67.78,20.16 59.64,20.16 v1(59.08,20.72)
  BOTTOM w0.076: v1(176.82,59.28) 176.62,59.48 U4555.CH29
  BOTTOM w0.13: v1(59.08,20.72) R1332.1 60.23,20.21 R1318.1
CNV_CLKREQ_C: length 2.7
  BOTTOM w0.13: CN1300.14 61.9,20 v3(61.87,20.03) 61.86,20.04 R1318.2
CNV_RF_RESET#: length 174.6
  TOP w0.076: v1(177.73,57.31) 177.91,57.13 182.92,57.13 183.28,57.5
  TOP w0.102: v2(58.59,27.4) 58.59,26.25 57.86,25.52 57.86,21.33 v1(58.42,20.69) ; 183.28,57.5 184.5,58.72 186.19,58.72 186.81,59.33 187.49,59.33 187.62,59.47 189.77,59.47 R4970.2
  L6 w0.076: v1(177.73,57.31) 177.37,57.67 177.37,58.43 176.96,58.85 176.65,58.85 176.44,59.05 176.44,61.13 176.65,61.33 176.65,61.65 176.39,61.91 175.43,61.91 174.84,62.5 174.84,63.26 174.77,63.32 173,65.1 168.09,65.1 167.65,65.54 167.65,65.62 167.16,66.12 166.77,66.12
  L6 w0.102: v2(58.59,27.4) 59.69,26.3 64.5,26.3 65.25,26.3 66.87,24.68 67.08,24.47 68.5,24.47 69.45,23.52 83.79,23.52 92.63,32.36 92.63,33.35 102.64,43.36 114.21,43.36 117.41,46.56 117.41,53.37 121.55,57.51 121.55,58.77 127.91,65.13 129.29,65.13 129.3,65.14 134.35,65.14 135.59,63.89 138.46,63.89 139.26,64.69 141.5,64.69 142.06,64.12 149.04,64.12 150.78,65.85 154.25,65.85 154.31,65.91 163.21,65.91 163.86,66.56 164.19,66.56 164.63,66.12 166.77,66.12
  BOTTOM w0.089: v1(177.73,57.31) U4555.CJ32
  BOTTOM w0.102: v1(58.42,20.69) 58.52,20.69 59.21,20 R1319.1
CNV_RGI_DT: length 223.5
  L6 w0.076: v1(175.99,65.55) 176.61,64.92 178.31,64.92 179.3,63.93 182.15,63.93 182.5,63.58 183.18,63.58
  L6 w0.127: v2(206.5,45.68) 206.17,46.01 206.17,46.14 205.98,46.33 205.98,57.09 203.3,59.77 203.09,59.77 195.14,59.77 193.91,61 193.91,61.23 192.93,62.21 189.23,62.21 187.86,63.58 183.18,63.58
  BOTTOM w0.13: U4555.CG19 175.9,65.63 v1(175.99,65.55) ; R1314.2 R1333.2 R1309.1 58.89,23.01 57.74,21.86 57.74,20.41 59.04,19.11 59.04,18.07 59.52,17.59 59.52,15.32 59.52,15.11 60.37,14.26 80.52,14.26 89.36,23.1 89.36,29.57 95.96,36.18 103.94,36.18 104.43,35.69 106.49,33.63 155.35,33.63 156.9,35.17 184.74,35.17 193.23,43.66 195.38,43.66 196.97,45.24 206.06,45.24 v2(206.5,45.68)
CNV_RGI_DT_R: length 2.7
  BOTTOM w0.13: CN1300.32 62.46,24.5 v3(61.87,23.92) 61.46,23.5 R1314.1
CNV_RGI_RSP: length 226.3
  L6 w0.076: 182.25,64.09 180.22,64.09 179.1,65.21 178.78,65.21 178.71,65.14 177.14,65.14 v2(176.73,65.55)
  L6 w0.127: v1(206.5,44.57) 206.5,44.77 206.92,45.19 206.92,45.86 206.23,46.54 206.23,57.2 203.41,60.02 203.2,60.02 202.99,60.02 195.25,60.02 194.16,61.11 194.16,61.33 193.03,62.46 189.34,62.46 187.97,63.83 183.06,63.83 182.8,64.09 182.25,64.09
  BOTTOM w0.13: U4555.CH19 v2(176.73,65.55) ; v1(206.5,44.57) 206.08,44.99 197.07,44.99 195.49,43.4 193.33,43.4 184.84,34.92 157,34.92 155.46,33.37 106.39,33.37 105.35,34.41 105.35,34.41 104.32,35.43 103.84,35.92 96.07,35.92 89.61,29.47 89.61,22.99 80.62,14 60.26,14 59.26,15 59.26,17.48 58.78,17.97 58.78,19.01 57.48,20.3 57.48,22.71 59.28,24.51 59.63,24.51 59.74,24.62 R4908.1 60.08,24.73 R1316.2
CNV_RGI_RSP_R: length 2.4
  BOTTOM w0.13: CN1300.34 62.08,25 v3(61.87,25.21) 61.85,25.23 R1316.1
COMPARE_PWR_GOOD_3: length 40.4
  BOTTOM w0.102: 208.3,72.73 R7416.2 ; 208.3,72.73 208.3,71.27 208.28,71.25 208.28,70.91 208.77,70.42 209.56,70.42 D7400.3 ; 208.3,72.73 R7411.2 R7418.1 ; R7418.1 C7403.1 R7413.2 207.31,72.89 206.85,73.35 206.85,75.4 207.08,75.63 207.08,77.07 206.34,77.8 204.26,77.8 204.11,77.65 202.93,77.65 201.35,79.23 201.35,85.39 204.24,88.27 204.24,92.01 204.85,92.62 204.85,92.97 v3(203.95,93.86) 203.63,94.19 203.63,99.35 R7405.2 ; R7418.1 208.73,73.35 R7409.1
COMPARE_R_PWR_GOOD_3: length 2.5
  BOTTOM w0.102: R7409.2 209.82,72.91 U7400.3 ; R7409.2 209.74,73.17 v3(209.37,73.55) ; R7409.2 R7407.1
COMPARE_R_RSMRST_PG: length 1.9
  BOTTOM w0.102: R7408.2 215.99,73.19 R7406.1 215.97,73.41 215.83,73.56 U7400.5
COMPARE_RSMRST_PG: length 5
  BOTTOM w0.102: R7429.2 R7420.2 216.13,75.21 C7401.1 216.05,74.54 R7401.1 216.05,73.8 216.33,73.52 216.8,73.52 217.07,73.25 R7408.1 217.45,72.82 R7428.2 R7425.2
COMPARE_VRP3V3A_LDO: length 9.8
  BOTTOM w0.254: 212.46,73.41 212.46,73.64 212.32,73.78 212.32,74.18 212.24,74.26 C7402.2 ; C7402.2 212.24,74.56 R7410.2 ; C7402.2 R7412.2
  BOTTOM w0.381: 211.97,72.25 211.97,70.46 v3(211.86,70.35) ; 211.97,72.25 211.97,72.92 212.46,73.41 213.96,73.41 214.46,72.91 U7400.6 ; 211.97,72.25 211.97,72.26 U7400.2
CPPWR_EN: length 256.5
  TOP w0.076: v1(236.93,39.99) U300.E9
  TOP w0.102: v1(21.9,31.29) 22.31,31.7 22.89,31.7 U2501.8
  L3 w0.102: v1(103.07,33.06) 103.07,30.12 99.56,26.61 99.56,26.32 99.2,25.96 98.08,25.96 85.42,13.3 64.61,13.3 63.34,14.57 50.11,14.57 48.21,12.67 48.21,10.81 47.04,9.63 31.65,9.63 30.84,10.45 27.13,10.45 26.57,11.01 26.57,11.51 26.82,11.77 26.82,15.24 23.87,18.18 23.87,24.92 22.31,26.48 22.05,26.48 20.57,27.96 20.57,29.96 v1(21.9,31.29)
  BOTTOM w0.076: v1(236.93,39.99) 236.5,39.56 235.23,39.56 234.98,39.81 234.75,39.81 233.63,40.93 232.51,40.93
  BOTTOM w0.102: v1(103.07,33.06) 103.64,33.06 103.67,33.03 103.91,32.8 105.49,31.21 156.35,31.21 157.9,32.76 185.74,32.76 189.66,36.67 211.16,36.67 211.87,37.38 217.82,37.38 220.54,40.1 223.81,40.1 223.89,40.17 227.02,40.17 227.81,40.96 228.62,40.96 228.63,40.96 229.57,40.96 229.66,41.05 229.84,41.05 230.4,41.61 230.91,41.61 231.3,41.61 231.86,41.05 232.16,41.05 232.28,40.93 232.51,40.93
CPU_C10_GATE#: length 331.1
  TOP w0.102: v1(95.5,57.47) 95.5,56.94 79.52,40.97 79.52,38.76 80.97,37.31 80.97,35.56 80.8,35.39 80.8,26.47 81.11,26.15 81.39,26.15 81.63,25.91 81.63,20.3 81.96,19.97 81.96,18.3 v1(82.29,17.97)
  L3 w0.102: v1(95.5,57.47) 95.81,57.16 102.36,57.16 103.68,58.49 v2(107.67,58.49)
  L6 w0.102: v1(192.12,61.28) 192.12,60.88 193.98,59.02 199.92,59.02 200.91,58.03 200.91,57.07 202.69,55.3 202.95,55.3 203.18,55.06 204.18,55.06 204.55,54.7 204.55,52.03 204.89,51.69 204.89,49.63 204.97,49.54 204.97,46.34 204.55,45.92 204.55,42.11 210.28,36.37 214.51,36.37 223.58,27.3 229.54,27.3 233.02,23.81 233.84,23.81 240.75,16.91 240.75,13.93 238.92,12.1 169.78,12.1 169.43,11.75 167.39,11.75 166.52,12.61 93.15,12.61 93.09,12.67 88.33,12.67 87.7,13.3 83.03,17.97 v1(82.29,17.97)
  BOTTOM w0.076: U4555.CN27 179.71,60.8 179.94,61.03 180.03,61.07 180.22,61.07 180.31,61.03 180.32,61.03 181.42,61.03 181.54,61.15 181.97,61.15 181.97,61.14 181.98,61.14 182.2,60.92 182.2,60.91 182.82,60.29 183.78,60.29 184.63,61.15 185.32,61.15 185.84,61.67 188,61.67
  BOTTOM w0.102: D4702.1 198.79,65.68 R4563.2 197.27,64.16 195.73,64.16 195.63,64.06 195.63,59.61 194.99,58.97 192.86,58.97 191.89,59.94 191.89,60.28 192.12,60.51 v1(192.12,61.28) 191.89,61.51 190.49,61.51 190.32,61.67 188,61.67 ; R60520.1 107.54,58.61 107.54,58.61 v2(107.67,58.49)
CPU_GPP_B7: length 28.4
  TOP w0.076: v1(175.91,58.58) 175.91,58.49 176.29,58.11 176.29,56.87 176.63,56.53 176.63,56.15 176.95,55.83 178.92,55.83 v3(179.22,56.12) 179.62,56.52 183.17,56.52 183.28,56.63
  TOP w0.102: 183.28,56.63 184.76,58.11 186.45,58.11 187.06,58.72 187.74,58.72 187.87,58.86 191.61,58.86 193.58,60.82 198.95,60.82 199.31,61.17 R4798.2
  BOTTOM w0.089: v1(175.91,58.58) U4555.CF30
CPU_GPP_B18: length 3.3
  TOP w0.076: TP4504.1 174.22,61.13 174.5,60.85 174.5,59.72 v1(175,59.22)
  BOTTOM w0.076: U4555.CE29 174.74,59.48 v1(175,59.22)
CPU_GPP_H11: length 15.2
  L6 w0.076: v1(177.79,59.43) 178.06,59.16 182.8,59.16 183.18,59.54
  L6 w0.102: 183.18,59.54 183.27,59.64 190.78,59.64 v1(191.26,60.11)
  BOTTOM w0.076: U4555.CJ29 177.74,59.48 v1(177.79,59.43)
  BOTTOM w0.102: TP4501.1 191.36,60.01 v1(191.26,60.11)
CPU_GPPH20: length 2.9
  TOP w0.076: TP4506.1 174.57,61.98 174.58,61.98 174.69,61.87 175.88,61.87 v1(176.27,61.49)
  BOTTOM w0.076: v1(176.27,61.49) 176.55,61.78 U4555.CH25
CPU_POPI_RCOMP: length 1.2
  TOP w0.203: R4587.2 169,60.91 v1(168.56,60.47)
  BOTTOM w0.203: v1(168.56,60.47) 168.25,60.78 U4555.BP27
CPU_PROCHOT#: length 114.9
  TOP w0.102: R66001.1 R66104.2 101.06,89.64 v1(101.06,88.69) ; v1(186.2,108.4) 185.74,107.93 184.1,107.93 183.59,107.42 R68055.2 183.2,107.42 183.1,107.32 183.1,106.88 183.08,106.86 183.08,106.76 182.89,106.58 R68054.2
  L3 w0.102: v1(141.9,86.4) 141.9,86.48 141.57,86.81 137.84,86.81 137.51,87.13 130.78,87.13 130.56,86.92 120.86,86.92 119.86,86.92 119.8,86.97 119.43,87.35 113.85,87.35 113.3,86.8 105.12,86.8 102.85,89.07 101.53,89.07 101.15,88.69 v1(101.06,88.69) ; v1(142.11,90.31) 142.4,90.61 147.51,90.61 157.11,100.21 157.11,103.97 161.94,108.8 170.29,108.8 171.15,108.8 173.79,106.16 181.16,106.16 181.17,106.16 182.58,106.16 185.22,108.8 185.8,108.8 v1(186.2,108.4)
  BOTTOM w0.102: R4517.2 142.33,86.16 142.33,85.69 C4514.1 141.9,85.78 v1(141.9,86.4) ; R4517.2 142.99,86.82 142.99,88.25 142.11,89.13 v1(142.11,90.31) ; R4517.2 143.08,85.82 R4515.1
CPU_PROCHOT#_R: length 11.1
  BOTTOM w0.076: U4555.Y4 146.89,75.8 146.89,76.81 147.02,76.94 147.02,79.23 146.72,79.52
  BOTTOM w0.13: R4515.2 v3(143.42,84.16) 143.42,83.84 145.4,81.87 145.4,80.85 146.72,79.52
CPU_SPI0_CS1#: length 24.3
  TOP w0.102: TP4502.1 193.33,43.25 192.58,44 191.81,44 189.94,45.87 188.16,45.87 v1(186.71,47.32)
  BOTTOM w0.076: 183.95,50.99 183.8,51.14 181.86,51.14 179.59,53.42 176.76,53.42 175.98,54.2 175.98,54.65 176.02,54.77 176.02,54.95 176,55 U4555.CG35
  BOTTOM w0.102: v1(186.71,47.32) 186.63,47.4 186.63,48.31 183.95,50.99
CS_X360_DET: length 20.8
  TOP w0.076: U300.E5 v1(239.53,39.99)
  TOP w0.102: v3(239.09,27.98) 239.14,27.93 240.03,27.93 240.3,28.21 R357.1 240.39,28.26 240.72,27.93 241.17,27.93 241.44,28.21 R385.1 241.44,28.74 v1(241.5,28.8)
  L3 w0.076: 242.59,35.32 242.59,36.25 244.13,37.79 244.13,38.69 244.29,38.86 244.29,39.15 243.92,39.52 241.41,39.52 240.59,40.34 239.88,40.34 v1(239.53,39.99)
  L3 w0.102: 242.59,35.32 242.59,29.85 241.53,28.8 v1(241.5,28.8)
CSON: length 11.2
  TOP w0.102: U60000.1 196.47,105.66 C60023.2 198.95,108.14 198.95,110.4 v3(200.04,111.5) 199.92,111.61 C60021.1 R60020.1
CSOP: length 11
  TOP w0.102: U60000.2 196.02,106.06 C60023.1 197.25,107.17 198.74,108.67 v3(198.74,111.5) 198.74,112 198.74,112 C60024.1 198.19,113.13 R60018.1
CSUMA: length 17.7
  TOP w0.102: R66455.2 R66454.2 100.56,107.37 v1(100.56,107.43) 101.63,107.43 R66154.2 ; U66000.18 96.84,98.3 96.77,98.36 96.22,98.36 95.81,97.96 v1(95.75,97.96)
  L6 w0.102: v1(95.75,97.96) 95.75,101.08 100.56,105.88 v1(100.56,107.43)
CSUMB: length 14.3
  TOP w0.102: U66000.19 96.45,97.9 v1(96.39,97.96) ; v2(103.02,107.73) R66155.2
  L6 w0.102: v2(103.02,107.73) 102.96,107.73 96.39,101.16 v1(96.39,97.96)
D_COVER_OPEN: length 86.3
  TOP w0.076: 245.44,42.86 244.1,42.86 243.5,42.27 242.91,42.27 242.59,41.94 242.23,41.94 241.91,42.26 U300.H2
  TOP w0.102: 245.44,42.86 246.29,42.86 246.66,43.23 246.66,43.52 246.94,43.8 247.27,43.8 v1(247.75,44.29) 247.75,44.42 246.28,45.89 R1018.1
  L5 w0.102: v1(258.92,5.88) 258.92,6.06 255.15,9.83 250.27,9.83 249.26,10.85 249.26,13.72 250.07,14.53 251.13,14.53 252.63,16.02 252.63,19.74 257.5,24.62 257.5,29.24 255.29,31.45 253.84,31.45 252.82,30.43 252.82,29.88 251.74,28.79 250.45,28.79 248.95,30.3 245.78,30.3 245.15,29.67 245.15,28.06 244.85,27.76 243.69,27.76 243.25,28.2 243.25,30.95 243.69,31.39 244.03,31.39 245.14,32.5 245.14,36.88 246.61,38.34 246.61,40.71 248.15,42.26 248.15,43.88 v1(247.75,44.29)
  BOTTOM w0.102: v1(258.92,5.88) 258.64,5.6 258.64,3.85 R423.1 259.47,2.8 259.8,2.47 Q1004.D
DCI_STRAP: length 20.5
  TOP w0.102: v1(183.72,46.84) 183.81,46.84 186.1,44.55 v3(186.1,44.08) 186.1,43.77 R4525.2
  BOTTOM w0.076: 183.43,47.13 183.3,47.26 183.3,47.93 178.97,52.26 176.28,52.26 175.4,53.14 174.72,53.14 174.12,53.74 174.12,54.05 174.23,54.17 174.23,54.17 174.32,54.26 174.32,54.67 174.24,54.84 174.15,55.95 174.03,56.18 U4555.CC34
  BOTTOM w0.102: 183.43,47.13 v1(183.72,46.84)
DCIN: length 22.5
  TOP w0.254: U60000.17 188.53,108.46 v1(188.46,108.4)
  L3 w0.254: v1(188.46,108.4) 189.03,108.4 191.72,111.09 196.95,111.09 199.62,108.42 201.55,108.42 202.22,109.09 202.22,110.14 v1(201.8,110.56)
  BOTTOM w0.254: v1(201.8,110.56) 201.18,111.18 R60009.2 200.96,111.79 C60009.2
DCPRTC: length 2.2
  TOP w0.254: v1(167.66,62.12) 167.64,62.19 167.3,62.53 v3(167.07,62.53) 166.99,62.45 C4520.1
  BOTTOM w0.254: v1(167.66,62.12) 167.67,62.14 167.92,62.4 U4555.BP24
DDR4_DRAMRST#: length 205.5
  TOP w0.076: v2(170.44,57.92) 170.44,57.79 170.08,57.42 170.08,57.1 171.12,56.06 171.12,54.77 171.53,54.37 171.93,54.37 172.16,54.14 172.16,53.01
  TOP w0.13: 172.16,53.01 172.16,51.97 173.72,50.42 v1(173.72,48.83) ; R4553.2 196.64,12.98 v1(197.46,13.8) ; v1(121.83,13.72) 121.81,13.7 C4119.1
  L3 w0.097: v1(173.72,48.83) 174.5,48.05 174.5,45.98 176.34,44.15 210.7,44.15 211.05,43.8 230.65,24.2 230.65,19.69 230.52,19.55 230.52,13.4 230.39,13.28 197.98,13.28 v1(197.46,13.8) 197.42,13.85 196.89,13.85 196.35,13.31 149.61,13.31 148.79,12.48 146.3,12.48 145.56,13.22 122.33,13.22 v1(121.83,13.72)
  BOTTOM w0.076: U4555.BU31 v2(170.44,57.92)
  BOTTOM w0.13: CN4100.108 121.83,12.42 v1(121.83,13.72) ; CN4125.108 197.58,13.69 v1(197.46,13.8)
DDR_PG_CTRL: length 132.9
  TOP w0.102: R1013.1 134.03,9.59 133.46,9.02 133.46,8.28 v1(133.88,7.86)
  L3 w0.102: v1(123.42,56.33) 122.27,56.33 118.82,52.87 118.82,46.16 113.4,40.74 110.68,40.74 110.58,40.64 110.58,38.51 110.37,38.31 110.37,35.1 99.8,24.52 99.15,24.52 90.18,15.55 90.18,15.12 89.18,14.11 v1(88.74,14.11) ; v1(87.65,9.84) 89.28,8.22 101.67,8.22 101.67,8.22 101.83,8.22 104.81,5.25 106.01,5.25 106.06,5.2 110.36,5.2 114.05,8.88 130.97,8.88 132.39,7.46 133.44,7.46 133.85,7.86 v1(133.88,7.86)
  BOTTOM w0.076: 130.64,54.75 134.07,54.75 134.65,55.34 136.15,55.34 136.32,55.5 136.79,55.5 U4555.C35
  BOTTOM w0.102: 130.64,54.75 125.8,54.75 v3(124.96,55.59) 124.15,55.59 v1(123.42,56.33) ; v1(88.74,14.11) 88.74,9.68 88.51,9.44 88.06,9.44 v1(87.65,9.84)
DDR_PG_CTRL_R: length 2.4
  TOP w0.102: U1000.3 136.7,8.78 v3(135.96,9.51) 135.89,9.59 R1013.2
DDR_RCOMP_0: length 4.1
  TOP w0.203: R4518.1 166.41,56.91 166.82,57.32 166.82,58.96 v1(167.71,59.85)
  BOTTOM w0.2: v1(167.71,59.85) U4555.BN28
DDR_RCOMP_1: length 5.7
  TOP w0.203: R4541.1 166.03,56.54 166.03,56.94 166.52,57.44 166.52,59.3 v7(167.02,59.8) v1(167.71,60.49)
  BOTTOM w0.2: v1(167.71,60.49) U4555.BN27
DDR_RCOMP_2: length 3.3
  TOP w0.203: R4540.1 167.17,57.14 v7(167.17,57.79) 167.17,58.69 167.48,59 167.49,59 v1(167.71,59.22)
  BOTTOM w0.2: v1(167.71,59.22) U4555.BN29
DDR_VTT_PG_CTRL: length 27.6
  TOP w0.102: R1006.1 134.78,8.75 R1021.1 134.71,6.05 v1(134.52,5.86)
  L3 w0.102: v1(134.52,5.86) 134.52,5.81 136.85,3.47 152.47,3.47 153.34,2.61 155.14,2.61 155.53,2.22 v1(155.53,1.67)
  BOTTOM w0.102: R7119.1 155.83,2.31 155.53,2 v1(155.53,1.67)
DDR_VTT_PG_CTRL_R: length 2.2
  TOP w0.102: U1000.4 137.12,8.38 v3(136.37,7.63) 135.79,7.63 R1006.2
DDR_WR_C_VREF01: length 1.8
  TOP w0.254: R4136.2 131.51,42.37 v3(131.9,42.76) 131.92,42.79 C4124.2
DDR_WR_C_VREF02: length 1.6
  TOP w0.076: C4122.2 130.36,43.49 v3(130.68,43.17)
  TOP w0.254: C4122.2 129.96,42.97 129.96,42.89 R4111.2
DDR_WR_VREF01: length 19.1
  TOP w0.254: R4503.2 132.73,43.18 C4124.1 132.42,45.41 132.17,45.67 v1(130.82,45.67)
  BOTTOM w0.203: U4555.F36 138.67,54.96 138.47,54.76 138.47,54.75 138.38,54.66 138.38,54.42 137.79,53.82 136.92,53.82 136.58,53.49 134.9,53.49
  BOTTOM w0.3: 134.9,53.49 134.34,53.49 133.34,52.49
  BOTTOM w0.508: 133.34,52.49 v3(133.34,51.47) 133.34,48.18 v1(130.82,45.67)
DDR_WR_VREF02: length 19.2
  TOP w0.254: v1(130.27,44.94) 130.16,44.94 129.46,44.24 C4122.1 128.95,42.97 R4112.2
  BOTTOM w0.203: 136.46,53.91 136.66,54.12 137.67,54.12 138.09,54.54 138.09,54.87 U4555.E36
  BOTTOM w0.3: 132.27,51.99 132.27,52.73 133.46,53.91 136.46,53.91
  BOTTOM w0.508: v1(130.27,44.94) 129.97,44.94 129.46,45.44 129.46,46.24 132.27,49.05 v3(132.27,50.35) 132.27,51.99
