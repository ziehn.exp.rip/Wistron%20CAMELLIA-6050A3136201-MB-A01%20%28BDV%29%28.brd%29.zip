# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVCORE_VID0: length 20.5
  TOP w0.102: v3(182.47,40.83) 182.91,41.27 R4889.1 182.17,42.2 182.17,45.33 v1(181.27,46.23)
  BOTTOM w0.076: 181.81,48.02 178.39,51.44 175.93,51.44 175.06,52.31 174.37,52.31 173.24,53.45 U4555.CB36
  BOTTOM w0.102: v1(181.27,46.23) 181.81,46.77 181.81,47.18 181.81,47.22 181.81,48.02
PVCORE_VID1: length 19.6
  TOP w0.102: v2(181.3,46.89) 181.98,46.2 181.98,45.81 182.38,45.42 182.38,42.63 R4890.1
  BOTTOM w0.076: U4555.CB35 173,55.01 172.98,54.95 172.98,54.77 173.02,54.66 173.03,54.12 173.05,53.62 173.05,53.4 174.3,52.15 174.99,52.15 175.87,51.27 178.27,51.27 181.61,47.93
  BOTTOM w0.102: 181.61,47.93 181.61,47.21 v2(181.3,46.89)
PVPACK: length 2.5
  BOTTOM w0.254: R60019.1 82.24,24.98 ; C7502.1 84.86,24.83 ; 85.16,25.77 C60050.1
  BOTTOM w0.381: 85.23,24.38 C7502.1
  vias: v5(82.12,27.35) v5(82.11,26.56) v5(82.86,27.34) v5(82.85,26.56) v5(83.61,27.34) v5(83.59,26.56) v5(84.38,27.34) v5(84.38,26.56) v5(106.58,111.39) v5(106.6,110.66) v5(107.34,112.16) v5(107.34,111.39) v5(107.36,110.66) v5(108.1,112.16) v5(108.1,111.39) v5(108.12,110.66)
PVSYS: length 45.8
  TOP w0.254: 248.18,27.66 248.18,28.69 248.43,28.95 D68200.1 ; 248.18,27.66 R68096.1 ; 248.18,27.66 247.7,28.13 247.02,28.13 246.76,27.87 246.76,26.65 246.44,26.33 v1(246.19,26.33) 246.12,26.33 245.71,26.74 245.71,27.32 245.15,27.89 Q68102.4 ; 262.95,85.83 Q68107.1 ; v1(255.95,45.23) 255.49,45.69 Q68105.1
  L3 w0.254: v5(250.44,38.09) 250.65,38.09 252.09,39.53 252.09,41.06 v1(251.38,41.77)
  L6 w0.254: v5(250.44,36.57) 250.57,36.44 250.57,33.32 247.93,30.68 247.93,25.52 v1(247.37,24.96)
  BOTTOM w0.254: v1(202.7,109.49) 202.7,110.44 202.32,110.82 202.32,112.25 201.34,113.22 D60031.2 ; v1(246.19,26.33) 246.19,26.13 v1(247.37,24.96) ; v1(255.95,45.23) 254.83,45.23 v1(251.38,41.77)
  BOTTOM w0.381: v5(254.84,92.01) 254.25,92.6 C7628.1
  vias: v5(185.57,105.09) v5(185.95,104.46) v5(186.33,105.09) v5(186.71,104.46) v5(187.09,105.09) v5(230.07,108.85) v5(230.07,108.09) v5(230.83,108.85) v5(230.83,108.09) v5(231.59,108.09) v5(231.59,107.33) v5(249.68,38.09) v5(249.68,37.33) v5(249.68,36.57) v5(250.44,37.33) v5(254.84,91.25) v5(254.86,90.49) v5(255.58,92.04) v5(255.57,91.28) v5(255.6,90.51)
PVSYS_BUCK: length 1.9
  BOTTOM w0.254: 183.54,104.97 183.79,104.71 C7557.1 ; C7555.1 182.52,104.71 ; C7556.1 183.16,104.71
  vias: v3(181,106.69)
PVT_CS#: length 41.7
  TOP w0.076: 232.51,47.48 232.82,47.48 233.7,46.6 233.7,46.39 233.95,46.14 235.12,46.14 236.27,44.99 236.27,44.73 236.6,44.4 U300.L10
  TOP w0.13: v1(230.93,46.84) 230.93,46.94 231.48,47.48 232.51,47.48 ; U366.1 CN366.1 226.74,25.39 227.07,25.42 228.09,25.64 229.08,25.61 229.21,25.61 R355.2 229.67,25.72 230.02,25.72 230.53,25.21 231.74,25.21 232.55,26.02 232.55,26.7 230.65,28.6 230.65,29.45 229.92,30.18 227.87,32.24 227.87,32.24 227.2,32.91 v1(227.2,33.47)
  L3 w0.097: v1(230.93,46.84) 231.49,46.29 231.49,43.57 227.38,39.45 227.38,33.64 v1(227.2,33.47)
PVT_MISO: length 5
  TOP w0.13: U366.2 CN366.2 227.5,26.33 228.04,26.29 v3(229.18,26.3) R390.2
PVT_MISO2: length 6.3
  TOP w0.13: R345.1 R419.2 231.01,27.27 v3(231.01,27.09) ; R345.1 229.84,27.19 229.73,27.18 228.6,27.17 CN366.3 U366.3 ; R345.1 R344.1
PVT_MISO2_EC: length 28.8
  TOP w0.076: U300.M11 235.95,44.93 234.92,45.96 233.87,45.96 233.52,46.3 233.52,46.54 232.85,47.22 232.51,47.22
  TOP w0.13: 232.51,47.22 231.92,47.22 v2(231.59,46.89) ; v1(227.78,34.53) 227.56,34.3 226.95,34.3 226.46,33.82 226.46,32.92 227.9,31.48 229.41,29.97 229.92,29.46 229.92,28.36 R419.1
  L3 w0.097: v2(231.59,46.89) 231.71,46.77 231.71,43.66 231.71,43.47 227.6,39.36 227.6,34.72 v1(227.78,34.53)
PVT_MISO3: length 5.7
  TOP w0.13: U366.7 CN366.7 221.13,33.25 221.36,34.64 221.36,34.86 R346.1 v3(220.72,35.32) R421.1
PVT_MISO3_EC: length 33.2
  TOP w0.076: U300.L11 235.86,44.21 235.54,44.54 235.18,44.54 234.25,45.47 232.98,45.47 232.51,45.94
  TOP w0.13: 232.51,45.94 232.43,46.01 232.18,46.01 231.8,46.4 230.78,46.4 229.91,47.27 228.01,47.27 227.42,46.68 227.42,46.6 227.09,46.28 226.29,46.28 225.43,45.43 222.59,45.43 v3(222.45,45.29) 221.06,45.29 219.13,43.36 219.13,42.97 217.01,40.85 215.78,40.85 214.76,39.83 214.76,39.41 214.76,38.59 217.75,35.6 219.6,35.6 R421.2
PVT_MISO_EC: length 32.1
  TOP w0.076: U300.M12 234.53,45.63 233.09,45.63 232.69,46.04 232.69,46.29 232.51,46.47
  TOP w0.13: v1(228.42,34.53) 227.77,33.88 227.38,33.88 227.37,33.89 227.03,33.89 226.78,33.64 226.78,32.96 227.76,31.98 228.16,31.59 229.67,30.08 230.32,29.42 230.4,29.35 230.4,28.49 232.05,26.83 v3(232.05,26.33) 232.05,25.89 231.67,25.5 230.74,25.5 R390.1 ; v1(232.25,46.73) 232.51,46.47
  L3 w0.097: v1(232.25,46.73) 232.25,43.55 227.82,39.12 227.82,35.31 228.42,34.71 v1(228.42,34.53)
PVT_MOSI: length 5
  TOP w0.13: U366.5 CN366.5 v3(222.83,36.36) R305.1
PVT_MOSI_EC: length 30
  TOP w0.076: 232.51,44.84 232.64,44.84 233.52,43.96 234.24,43.96 234.63,43.56 U300.K12
  TOP w0.13: 232.51,44.84 231.88,44.84 231.35,45.38 230.36,45.38 230.14,45.59 227.85,45.59 227.52,45.26 226.71,45.26 225.86,44.4 223.01,44.4 222.6,44 v3(222.45,44) 221.21,44 220.15,42.94 220.15,42.55 217.41,39.81 216.18,39.81 215.78,39.41 215.78,39.06 218.22,36.62 220.89,36.62 R305.2
PVT_SCLK: length 4.7
  TOP w0.13: R304.1 v3(221.99,35.4) 221.92,34.9 221.73,33.76 221.73,33.19 CN366.6 U366.6
PVT_SCLK_EC: length 31.5
  TOP w0.076: U300.L12 234.92,44.21 233.98,45.15 232.86,45.15 232.66,45.35 232.51,45.35
  TOP w0.13: 232.51,45.35 232.09,45.35 231.56,45.89 230.57,45.89 230.36,46.1 227.64,46.1 227.31,45.77 226.5,45.77 225.64,44.92 222.8,44.92 222.4,44.52 221.01,44.52 219.64,43.15 219.64,42.76 217.22,40.34 215.99,40.34 215.27,39.62 215.27,38.82 v3(216.43,37.66) 217.98,36.11 220.88,36.11 220.98,36.11 R304.2
PWM#_LED: length 199.4
  TOP w0.076: v1(236.28,42.59) U300.H10
  L3 w0.076: 232.51,40.64 234.46,42.59 v1(236.28,42.59)
  L3 w0.102: v1(109.67,7.52) 113.47,11.32 134.9,11.32 135.86,10.35 144.96,10.35 145.9,9.41 150.5,9.41 151.44,10.35 156.57,10.35 157.16,10.95 159.55,10.95 159.89,10.6 166.93,10.6 167.07,10.46 167.59,10.46 167.71,10.58 170.57,10.58 170.63,10.64 171.58,10.64 171.7,10.76 196.9,10.76 196.93,10.73 202.16,10.73 202.76,10.13 229.93,10.13 230.52,10.73 235.92,10.73 240.03,14.83 240.03,21.34 233.92,27.45 232.56,27.45 231.55,28.46 231.13,28.46 230.9,28.7 230.9,29.25 229.42,30.72 229.36,30.79 229.36,36.3 232.1,39.04 232.1,40.23 232.51,40.64
  L6 w0.102: v2(131.12,2.44) 131.12,4.1 127.47,7.75 112.4,7.75 111.55,6.9 110.3,6.9 v1(109.67,7.52)
  BOTTOM w0.102: Q301.G 131.12,2.85 v2(131.12,2.44)
PWM_EC_IN: length 16.1
  TOP w0.076: v1(241.48,40.64) U300.F3
  TOP w0.102: R431.1 242.6,34.81 v3(242.06,34.28) 242.29,34.05 C305.2 242.9,33.98 R432.1 242.84,33.41 242.57,33.14 242.57,32.69 242.67,32.58 243.68,32.58 v1(243.86,32.4)
  L3 w0.076: 244.46,35.32 244.46,38.55 244.62,38.72 244.62,39.29 243.27,40.64 v1(241.48,40.64)
  L3 w0.102: 244.46,35.32 244.46,33.84 243.86,33.24 v1(243.86,32.4)
PWM_EC_OUT: length 301.1
  TOP w0.076: U300.K5 v1(240.18,43.89)
  TOP w0.102: R3024.1 22.8,18.94 23.27,18.48 23.6,18.48 23.97,18.11 25.23,18.11 25.37,17.97 v1(28.22,17.97) ; v1(25.06,19.53) 25.09,19.5 R428.1
  L3 w0.076: 245.44,45.56 241.63,45.56 241.48,45.71 241,45.71 240.88,45.58 240.88,45.58 240.18,44.88 v1(240.18,43.89)
  L3 w0.102: v2(247.37,45.53) 247.34,45.56 245.44,45.56 ; v1(28.22,17.97) 26.62,17.97 v1(25.06,19.53)
  L6 w0.102: v1(28.22,17.97) 28.22,16.95 28.21,16.95 28.21,14.5 29.84,12.87 42.58,12.87 44.86,10.58 50.41,10.58 52.12,12.29 54.13,12.29 54.49,11.93 56.18,11.93 57.55,13.3 68.6,13.3 73.38,8.52 128.34,8.52 132.37,4.48 144.23,4.48 144.39,4.65 168.65,4.65 170.85,6.85 175.49,6.85 176.86,8.22 205.38,8.22 206.43,7.17 211.33,7.17 212.58,8.42 227.05,8.42 230.27,5.2 235.77,5.2 235.95,5.02 236.59,5.02 238.64,7.07 239.92,7.07 241.82,8.98 242.13,8.98 242.58,9.43 248.58,9.43 249.44,10.3 249.44,13.49 249.48,13.53 249.48,15.69 249.09,16.07 247.04,16.07 246.16,16.94 246.16,19.08 248.05,20.97 248.05,21.83 248.38,22.16 248.38,30.16 251.31,33.09 251.31,39.2 250.54,39.97 250.54,44.99 250.54,45.24 249.03,46.75 248.54,46.75 247.37,45.58 v2(247.37,45.53)
PWM_EC_OUT_R: length 1.4
  TOP w0.102: R3024.2 22.76,19.8 U3001.1
PWR_BTN_OUT#: length 100.6
  TOP w0.076: v1(237.58,39.34) U300.D9
  TOP w0.102: R103.2 238.89,29.66 238.58,29.96 238.58,30.57 R350.2 238.89,31.42 v1(238.3,32.01)
  L3 w0.076: v1(237.58,39.34) 237.28,39.04 236.78,39.04 236.42,38.68 236.42,35.68 236.57,35.52 236.58,35.52 236.78,35.32
  L3 w0.102: 236.78,35.32 237.97,34.13 237.97,32.78 238.3,32.45 v1(238.3,32.01)
  L6 w0.076: v1(170.44,59.85) 170.88,59.41 170.88,56.3 171.69,55.49 171.9,55.49 174.86,52.54 175.29,52.54
  L6 w0.102: 175.29,52.54 187.01,52.54 188.83,50.72 191.26,50.72 192.95,52.4 193.81,52.4 197.1,49.11 200.98,49.11 201.2,49.11 203.22,47.09 203.22,41.49 208.2,36.5 v2(208.2,36.26)
  BOTTOM w0.076: v1(237.58,39.34) 237.3,39.07 235.03,39.07 234.78,39.32 234.54,39.32 234.08,39.78 233.19,39.78 232.64,40.32 232.51,40.32
  BOTTOM w0.089: U4555.BU28 v1(170.44,59.85)
  BOTTOM w0.102: 232.51,40.32 232.02,40.32 231.9,40.44 231.61,40.44 231.05,41 230.71,41 230.15,40.44 229.91,40.44 229.83,40.35 228.88,40.35 228.87,40.35 228.06,40.35 227.28,39.56 224.14,39.56 223.9,39.32 223.9,39.07 223.61,38.77 222.96,38.77 222.45,39.28 220.3,39.28 217.99,36.97 213.18,36.97 212.58,36.37 208.31,36.37 v2(208.2,36.26)
PWR_GOOD_3: length 268
  TOP w0.076: 240.28,49.09 240.84,48.53 240.84,45.54 240.8,45.5 240.8,45.37 240.5,45.08 U300.M4
  TOP w0.102: 240.28,49.09 240.28,49.37 239.61,50.04 239.61,50.74 239.03,51.32 238.38,51.32 238.02,51.68 238.02,52.42 236.8,53.64 236.8,55.01 235.05,56.76 234.22,56.76 v1(233.82,56.36) ; R4855.1 v1(106.56,93.92)
  L3 w0.102: v1(233.82,56.36) 233.47,56.36 232.8,57.03 228.4,57.03 225.86,59.57 225.29,59.57 224.78,60.09 224.25,60.09 222.96,61.38 221.98,61.38 219.7,63.66 219.54,63.66 219.33,63.87 217.25,63.87 216.15,64.98 213.1,64.98 210.41,67.66 210.41,68.95 ; v1(204.62,72.37) 204.68,72.37 206.78,70.27 206.78,69.91 207.88,68.81 210.27,68.81 210.41,68.95 ; 210.41,68.95 210.41,69.92 209.29,71.04 v1(209.29,71.08)
  L5 w0.102: v1(102.94,59.2) 103.91,60.17 103.91,62.49 100.5,65.89 100.3,65.89 99.98,66.22 99.98,69.66 101.73,71.41 101.99,71.41 110.13,79.55 110.13,86.2 110.13,88.8 109.62,89.3 109.62,90.55 107.64,92.53 107.64,92.84 v1(106.56,93.92) 106.55,93.93 106.55,103.1 107.24,103.78 107.24,104.4 109.45,106.61 109.45,106.61 112.02,109.18 121.37,109.18 123.01,107.54 127.35,107.54 127.73,107.16 130.5,107.16 131.11,107.77 135.01,107.77 135.62,107.16 138.35,107.16 138.92,107.74 138.96,107.74 139.47,108.24 144.68,108.24 145.36,108.93 145.36,111.3 147.74,113.68 157.36,113.68 161.71,109.34 171.35,109.34 173.73,111.72 177.12,111.72 179.23,109.62 191.17,109.62 191.59,109.62 193.31,111.34 194.86,111.34 195.14,111.06 199.28,111.06 199.59,111.38 202.58,111.38 203.4,110.56 204.32,110.56 204.95,109.93 204.95,109.3 204.95,109.3 204.95,109.05 204.63,108.73 204.63,108.69 204.52,108.58 204.52,93.84 205.23,93.13 205.23,93.11 206.68,91.66 206.68,88.08 204.52,85.92 204.52,84.83 208.02,81.33 208.02,73.68 209.29,72.4 v1(209.29,71.08)
  BOTTOM w0.102: R7407.2 209.31,72.07 R7404.2 ; U7400.1 210.74,71.62 R7404.2 ; v1(102.94,59.2) 103.46,58.68 R4821.1 ; R7404.2 209.29,71.6 v1(209.29,71.08) ; v1(204.62,72.37) 204.14,71.89 203.77,71.89 203.67,71.8 Q4751.5
PWR_GOOD_3_Q4751_G: length 2.1
  BOTTOM w0.102: Q4751.2 203.67,69.53 203.62,69.48 203.62,69.43 R4742.2 203.22,69.49 203.17,69.53 Q4751.3
PWRBTN#: length 27.7
  TOP w0.076: v1(240.18,41.29) U300.G5
  TOP w0.102: 240.01,30.93 240.01,31 239.57,31.43 v1(239.39,31.43) R350.1 239.78,30.48 R101.2 239.68,30.16 v3(239.06,30.16) ; 240.01,30.93 C100.1 ; 240.01,30.93 240.28,31.2 240.8,31.2 R100.2
  L6 w0.076: v1(240.18,41.29) 240.18,40.79 241.32,39.64 241.32,38.68 240.81,38.17 240.56,38.17
  L6 w0.102: 240.56,38.17 237.58,38.17 235.83,36.41 233,36.41 232.3,35.72 232.3,35.21 232.93,34.58 235.31,34.58 236.7,33.19 237.99,33.19 238.55,32.62 238.72,32.45 238.91,32.26 238.91,31.54 239.01,31.43 v1(239.39,31.43)
PWRSW_P3V3A: length 0.5
  BOTTOM w0.254: C7007.1 210.59,83.63
  vias: v3(210.66,83)
PWRSW_P3V3S: length 0.8
  BOTTOM w0.254: C7004.2 210.85,86.87 U7001.14
Q1304_G: length 2.9
  BOTTOM w0.102: Q1304.G 57.24,29.8 57.61,29.43 R1307.2 57.61,29.1 58.22,28.49 v3(59.08,28.49)
RBIAS: length 1.7
  TOP w0.076: U2700.J6 v1(259.24,66.9)
  BOTTOM w0.076: v1(259.24,66.9) 259.23,66.91 259.23,67.81 R2750.1
RECORD_MUTE_LED: length 5.9
  BOTTOM w0.102: R399.2 R411.2 R410.2 ; v3(44.93,22.77) 44.93,20.87 45.03,20.77 R410.2 ; Q303.5 46.08,19.45 46.18,19.55 46.18,20.2 46.08,20.3 45.78,20.3 45.49,20.59 R410.2
RECORD_MUTE_LED_AUDIO: length 43.1
  TOP w0.13: v1(24.02,34.34) 23.65,34.71 22.42,34.71 21.05,36.08 U500.4
  L3 w0.102: v1(47.93,33.47) 47.68,33.22 42.25,33.22 41.97,32.95 31.2,32.95 30.03,34.11 24.24,34.11 v1(24.02,34.34)
  BOTTOM w0.102: v1(47.93,33.47) 47.52,33.06 v3(47.52,31.71) 47.52,31.04 46.33,29.85 46.33,23.49 45.46,22.63 45.46,21.29 R410.1
RECORD_MUTE_LED_CNTRL: length 4.4
  BOTTOM w0.102: R364.1 47.49,16.91 47.49,16.91 48.55,17.97 R372.1 48.59,18.5 v3(48.1,18.99) 47.14,18.99 Q303.3
RECORD_MUTE_LED_CNTRL_R: length 5
  BOTTOM w0.102: CN300.8 44.29,12.87 46.48,15.06 v3(46.48,15.1) 46.78,15.1 R364.2
RECORD_MUTE_LED_PCH: length 165
  L6 w0.076: v1(175.9,59.22) 175.4,59.73 175.4,60.65 175.17,60.88 175.08,60.88 175.02,60.94 174.77,60.94 174.45,61.26 174.45,62.74 174.51,62.81 174.51,63.12 174.25,63.38 168.1,63.38 167.32,64.16 167.32,65.49 167.1,65.71 166.77,65.71
  L6 w0.102: 166.77,65.71 166.68,65.71 166.5,65.53 154.47,65.53 154.41,65.47 150.93,65.47 148.32,62.85 135.99,62.85 134.73,64.11 128.34,64.11 128.34,64.12 127.47,64.12 121.95,58.6 121.95,57.34 118.9,54.28 118.9,47.72 118.16,46.71 118.16,46.7 114.39,42.94 102.79,42.94 93.04,33.19 93.04,32.2 83.96,23.12 68.15,23.12 68.02,23.25 66.79,24.47 66.79,24.47 65.16,26.1 64.58,26.1 59.6,26.1 58.84,26.86 57.44,26.86 55.67,25.08 53.73,25.08 52.46,26.35 50.29,26.35 v1(45.95,22.01)
  BOTTOM w0.089: v1(175.9,59.22) 175.87,59.24 U4555.CF29
  BOTTOM w0.102: R411.1 45.95,21.45 v1(45.95,22.01)
RF_RESET#_C: length 4
  BOTTOM w0.102: CN1300.10 62.37,19 62.05,19.32 v3(60.8,19.32) 60.62,19.5 R1319.2
RFID_BEEP_EN#: length 16.2
  BOTTOM w0.076: U4555.CM23 179.09,63.59 179.57,63.59 179.68,63.55 179.92,63.55 180.04,63.59 180.22,63.59 180.33,63.55 181.38,63.55 181.83,64 185.39,64 185.83,63.55 188,63.55
  BOTTOM w0.102: 188,63.55 190.86,63.55 190.87,63.57 192.07,63.57 v3(192.4,63.9) 192.98,63.9 193.49,64.4 193.49,64.98 R4700.2
RFID_PRESENT: length 15.9
  BOTTOM w0.076: U4555.CN23 179.71,63.33 179.94,63.1 180.03,63.06 180.22,63.06 180.34,63.11 182.35,63.11 182.38,63.13
  BOTTOM w0.102: 182.38,63.13 182.6,63.35 v3(183.59,63.35) 183.68,63.45 185.4,63.45 185.49,63.35 190.94,63.35 190.96,63.37 192.74,63.37 193.69,64.32 193.69,64.63 194.14,65.08 R4839.2
RSENSE: length 1.8
  TOP w0.076: U2700.J5 v1(259.89,66.9)
  BOTTOM w0.076: v1(259.89,66.9) 259.89,67.03 259.52,67.4 259.52,68.02 R2750.2
RSMRST#: length 203.8
  TOP w0.076: 233.54,50.36 233.65,50.25 R330.2
  TOP w0.102: R4926.1 126.32,68.51 v1(127.07,69.25) ; v1(211.81,46.83) 211.81,46.8 211.35,46.34 209.91,46.34 209.25,47 204.92,47 203.46,45.54 196.5,45.54 195.83,46.22 194.93,46.22 194.16,46.99 192.51,46.99 190.22,49.28 178.05,49.28 v1(176.19,47.42) ; 233.54,50.36 v1(232.38,51.52)
  L3 w0.102: v1(103.17,45.98) 104.71,44.44 112.57,44.44 114.9,46.77 114.9,53.95 114.09,54.76 114.09,59.6 120.39,65.9 120.39,67.32 122.53,69.46 126.87,69.46 v1(127.07,69.25) ; v2(228.22,46.78) 227.54,47.45 216.69,47.45 216.61,47.53 216.15,47.53 215.37,46.75 214.47,46.75 213.69,47.53 212.51,47.53 v1(211.81,46.83)
  L5 w0.102: v1(232.38,51.52) 232.38,50.94 v2(228.22,46.78)
  BOTTOM w0.076: 176.57,45.9 176.57,47.04 v1(176.19,47.42) 176.19,47.68 174.03,49.84 173.26,49.84 171.64,51.46 170.93,51.46 169.3,53.09 169.08,53.25 169.07,53.28 168.91,53.42 168.88,53.47 168.83,53.52 168.81,53.61 168.8,53.61 168.8,53.62 168.68,54.03 168.59,54.45 168.59,54.63 168.61,54.68 U4555.BR36
  BOTTOM w0.102: 176.57,45.9 176.57,45.49 171.67,40.59 154.65,40.59 153.4,39.33 112.67,39.33 108.89,43.11 108.61,43.11 106.04,43.11 v1(103.17,45.98)
RSMRST#_EC: length 5.9
  TOP w0.076: U300.M10 236.6,44.87 236.6,46.06 235.96,46.7 235.96,46.93 235.17,47.73 235.11,47.73 v3(234.44,48.4)
  TOP w0.102: R330.1 R329.1 234.26,48.58 v3(234.44,48.4)
RSMRST_PG: length 65.8
  TOP w0.102: C7406.1 v1(226.36,36.9) R377.1
  L5 w0.102: v1(214.63,70.86) 214.4,71.08 213.85,71.08 213.61,70.85 213.61,63.93 214,63.54 214,63.21 213.14,62.35 213.14,62.27 210.44,59.56 210.44,46.96 210.79,46.61 210.79,45.38 210.36,44.94 210.36,38.75 209.72,38.11 209.72,37.78 213.5,34 v2(213.5,30.62)
  BOTTOM w0.102: v2(213.5,30.62) 214.77,31.89 219.4,31.89 222.88,35.37 224.31,35.37 225.39,36.45 225.92,36.45 v1(226.36,36.9) ; v1(214.63,70.86) 215.2,70.86 215.69,71.34 215.69,71.64 216.12,72.07 R7427.2 216.18,72.51 R7406.2 215.52,72.26 U7400.7
RST1#: length 3.4
  TOP w0.102: U1000.12 137.89,9.83 137.89,10.03 137.98,10.12 138.79,10.12 139.42,9.49 v3(139.72,9.49) 140.06,9.15 R1005.1
RST2: length 182.3
  TOP w0.102: U1000.9 138.93,9.18 139.32,8.79 139.32,7.37 v1(139.47,7.23) 139.68,7.23 R1004.1
  L5 w0.102: v1(221.31,58) 223.83,55.48 223.83,53.61 225.9,51.54 225.9,48.05 225.04,47.18 225.04,46.56 221.36,42.87 221.36,33.5 226.09,28.77 230.54,28.77 231.05,28.25 233.39,28.25 239.09,22.56 239.09,22.3 243,18.39 243,17.38 243,17.38 243,13.94 242.82,13.76 242.82,10.93 240.26,8.36 240.26,5.62 239.82,5.19 239.82,4.39 239.59,4.15 238.91,4.15 238.14,4.93 228.2,4.93 227.98,5.15 227.31,5.15 227.08,4.93 221.43,4.93 218.23,8.12 215.66,8.12 214.22,9.56 200.88,9.56 199.51,8.19 184.83,8.19 182.41,10.61 170.47,10.61 169.63,9.77 165.52,9.77 164.38,8.63 161.94,8.63 161.3,9.26 151.24,9.26 150.06,8.08 143.44,8.08 142.59,7.23 v1(139.47,7.23)
  BOTTOM w0.102: D1000.2 220.91,58 v1(221.31,58)
RST2_D: length 20.3
  TOP w0.102: v1(214.8,49.39) 214.8,47.87 R1007.1 214.57,47.42 214.55,47.32 Q1001.5 Q1001.2
  L5 w0.102: v2(221.31,59.27) 219.73,57.7 219.73,52.68 216.43,49.38 216.43,48.54 216.19,48.3 215.86,48.3 214.8,49.35 v1(214.8,49.39)
  BOTTOM w0.102: D1000.3 221.38,59.35 v2(221.31,59.27)
RTC_DET#: length 31.3
  TOP w0.102: v1(193.32,54.29) 194.23,54.29 v3(195.53,53) 195.53,52.82 196.08,52.27 R4520.2
  L6 w0.076: 180.05,52.75 176.18,52.75 176.09,52.84 174.66,54.28 172.08,56.85 172.08,57.33 171.72,57.69 171.72,58.14 171.81,58.23 171.81,58.75 v1(171.34,59.22)
  L6 w0.102: 180.05,52.75 186.7,52.75 188.83,54.88 190.56,54.88 191.14,54.29 v1(193.32,54.29)
  BOTTOM w0.089: v1(171.34,59.22) U4555.BV29
RTC_X1: length 45.2
  L3 w0.097: v1(167.65,57.89) 167.49,57.72 167.49,57.67 167.31,57.49 167.31,56.99 169.62,54.67 172.01,54.67 175.68,51 175.96,50.72 185.55,50.72 188.53,47.74 189.82,47.74 189.82,47.74 196.39,47.74 196.95,48.3 197.38,48.73 202,48.73 203.3,50.02 v2(203.3,50.03)
  BOTTOM w0.13: v2(203.3,50.03) 203.51,49.82 203.51,49.82 C4767.2 204.56,49.82 R4862.1 204.82,49.83 X4750.4 ; U4555.BN31 v1(167.65,57.89)
RTC_X2: length 44
  L3 w0.097: v1(167.7,57.31) 167.7,56.9 169.15,55.44 171.28,55.44 171.55,55.17 172.18,55.17 176.16,51.2 185.75,51.2 188.73,48.21 189.63,48.21 189.63,48.21 196.19,48.21 197.18,49.21 201.81,49.21 203.29,50.69 v1(203.3,50.69)
  BOTTOM w0.13: v1(203.3,50.69) 203.36,50.69 203.59,50.46 C4788.2 204.69,50.46 R4862.2 204.97,50.73 X4750.1 ; U4555.BN32 v1(167.7,57.31)
RTCRST#: length 115.4
  TOP w0.102: Q1001.3 215.05,45.36 214,44.31 v1(213.51,44.31) 213.1,44.72 213.1,44.97 212.46,45.61 211.75,45.61 211.42,45.94 209.75,45.94 209.09,46.6 205.09,46.6 203.63,45.14 196.33,45.14 195.66,45.81 194.76,45.81 193.99,46.58 192.35,46.58 190.06,48.87 178.86,48.87 177.61,47.62 177.61,47.33 v1(177.06,46.79)
  L3 w0.102: v1(257.76,45.76) 256.44,47.08 253.82,47.08 251.97,48.93 249.46,48.93 248.52,49.87 246.36,49.87 242.93,53.3 235.35,53.3 234.1,52.05 233.37,52.05 233.05,52.38 231.41,52.38 230.95,51.91 225.87,51.91 225.81,51.96 225.81,51.96 225.35,52.42 225.35,52.43 225.09,52.68 223.63,52.68 v2(223.22,52.27)
  L5 w0.102: v1(213.51,44.31) 213.64,44.31 215.69,46.37 215.69,46.78 216.16,47.25 218.2,47.25 v2(223.22,52.27)
  BOTTOM w0.076: v1(177.06,46.79) 177.47,47.18 177.47,47.55 177.22,47.8 176.76,47.8 175.28,49.29 175.04,49.29 174.17,50.17 173.4,50.17 171.78,51.79 171.07,51.79 169.46,53.39 169.45,53.39 169.36,53.45 169.36,53.46 169.17,53.63 169.12,53.73 169.1,53.82 169.1,54.24 169.12,54.32 169.12,55.94 169,56.18 U4555.BR34
  BOTTOM w0.102: CN4941.9 258.12,45.87 258.01,45.76 v1(257.76,45.76) ; R4845.2 223.69,52.74 v2(223.22,52.27) 223.03,52.47 221.26,52.47 221.13,52.34 221.13,51.93 C4768.1
RTD3_CIO_PWR_EN: length 86.7
  TOP w0.102: U2702.2 248.66,75.24 R2709.1 248.66,76.61 248.56,76.71 245.94,76.71 244.73,75.51 244.73,74.98 243.38,73.64 243.38,70.97 237.25,64.84 235.11,64.84 v3(234.25,65.71) 232.4,67.55 221,67.55 220.03,66.58 216.88,66.58 216.77,66.46 216.01,65.71 212.63,65.71 212.07,66.27 210.7,66.27 210.26,65.82 209.16,65.82 208.61,65.27 206.28,65.27 v1(205.84,64.84)
  L3 w0.076: v1(175.46,64.51) 176.01,65.06 178.4,65.06 178.75,65.41 180.51,65.41
  L3 w0.102: v1(205.84,64.84) 205.53,64.53 205.06,64.53 204.96,64.63 203.43,64.63 202.62,63.82 198.73,63.82 198.68,63.87 198.66,63.87 198.37,64.16 196.42,64.16 195.21,65.38 182.54,65.38 182.17,65.01 181.5,65.01 181.1,65.41 180.51,65.41
  BOTTOM w0.089: U4555.CF20 v1(175.46,64.51)
RTD3_CIO_PWR_EN_BUF: length 19.1
  TOP w0.076: v1(256.63,66.9) U2700.T5
  TOP w0.102: R2701.2 247.44,74.37 U2702.4 ; R2701.2 247.29,74.47 247.01,74.74 247.01,75.78 v3(247.44,76.21) 247.49,76.27 R2709.2 ; R2701.2 247.16,74.29 R2712.2 247.33,73.68 247.39,73.68 247.49,73.57 247.49,73.13 247.48,73.11 247.57,73.01 v1(247.57,72.28)
  BOTTOM w0.076: 251.96,69.83 254.9,69.83 257.1,67.63 257.1,67.25 256.75,66.9 v1(256.63,66.9)
  BOTTOM w0.102: 251.96,69.83 251.95,69.83 251.05,70.72 251.05,71.01 250.03,72.02 247.82,72.02 v1(247.57,72.28)
RTD3_USB_PWR_EN: length 85.6
  TOP w0.102: v1(208.51,64.12) 209.47,65.09 212.03,65.09 212.16,65.22 216.1,65.22 216.18,65.3 216.82,65.93 219.7,65.93 231.2,65.93 232.12,65.01 v2(233.02,65.01)
  L3 w0.076: v1(176.09,63.47) 176.58,63.95 180.51,63.95
  L3 w0.102: 180.51,63.95 180.69,63.95 181.71,62.93 185.42,62.93 185.94,63.44 193.88,63.44 193.97,63.35 194.04,63.35 194.42,62.97 195.24,62.97 195.63,63.35 197.52,63.35 197.82,63.06 198.34,63.06 198.38,63.02 198.41,63.02 198.42,63.01 200.57,63.01 201.23,62.35 203.07,62.35 203.27,62.14 204.39,62.14 205,62.75 205.95,62.75 207.73,64.53 208.1,64.53 v1(208.51,64.12)
  L5 w0.102: v2(233.02,65.01) 234.36,63.67 242.27,63.67 v1(246.86,68.26)
  BOTTOM w0.076: R2727.1 252.77,64.73 252.63,64.59 252.32,64.59 251.96,64.95
  BOTTOM w0.089: U4555.CG22 v1(176.09,63.47)
  BOTTOM w0.102: 251.96,64.95 249.44,67.48 247.66,67.48 246.87,68.26 v1(246.86,68.26)
RTD3_WAKE#: length 10.9
  TOP w0.076: v3(179.65,72.38) 179.81,72.53 181.32,72.53 v1(181.69,72.17) 182.23,72.71 186.09,72.71 R4512.2
  BOTTOM w0.076: v1(181.69,72.17) 181.32,72.53 180.91,72.53 180.71,72.33 180.3,72.33 180.29,72.34 180.04,72.47 179.53,72.47 U4555.CN8
SA0_DIM0: length 7.1
  TOP w0.102: R4101.1 160.73,18.13 R4103.2 161.82,17.93 161.82,14.52 v1(161.06,13.76)
  BOTTOM w0.102: CN4100.256 160.88,13.57 v1(161.06,13.76)
SA0_DIM1: length 3.4
  TOP w0.102: R4125.1 238.02,14.24 v2(237.39,13.76)
  BOTTOM w0.127: CN4125.256 236.59,12.39 236.59,13.44 236.91,13.76 v2(237.39,13.76)
SA1_DIM0: length 5.1
  TOP w0.102: v2(165.45,11.01) 165.58,10.88 R4100.1
  BOTTOM w0.102: v2(165.45,11.01) 164.09,12.37 CN4100.260
SA1_DIM1: length 3.2
  TOP w0.102: v1(238.27,13.65) 238.95,13.65 R4126.2
  BOTTOM w0.13: v1(238.27,13.65) 238.02,13.65 237.58,13.21 CN4125.260
SC_PWRSV#: length 181.4
  TOP w0.076: 183.28,58.36 182.67,57.74 181.01,57.74 179.9,58.86 177.19,58.86 v1(176.8,58.46)
  TOP w0.102: 183.28,58.36 184.25,59.33 185.94,59.33 186.55,59.94 187.23,59.94 R4749.2 ; v1(68.17,24.07) 67.97,23.87 67.97,19.69 62.16,13.88 54.48,13.88 54,13.4 54,12.38 54.71,11.67 v1(57.86,11.67)
  L6 w0.076: 166.77,65.91 167.13,65.91 167.48,65.56 167.48,64.87 168.17,64.18 173.29,64.18 173.31,64.21 173.66,64.21 174.68,63.19 174.68,62.74 174.61,62.67 174.61,61.33 174.83,61.11 175.78,61.11 176.28,60.62 176.28,58.99 v1(176.8,58.46)
  L6 w0.102: v1(68.17,24.07) 68.92,23.32 83.87,23.32 92.83,32.28 92.83,33.27 102.72,43.16 114.3,43.16 118.02,46.87 118.03,46.87 118.04,46.89 118.04,46.89 118.69,47.78 118.69,54.37 121.75,57.42 121.75,58.68 127.39,64.32 128.69,64.32 128.71,64.3 134.81,64.3 135.41,63.7 141.48,63.7 142.14,63.04 148.24,63.04 150.86,65.66 154.33,65.66 154.39,65.72 166.4,65.72 166.6,65.91 166.77,65.91
  BOTTOM w0.076: U4555.CH30 v1(176.8,58.46)
  BOTTOM w0.102: CN200.5 59.25,10.26 58.8,10.71 58.8,11.83 TP853.1 58.09,11.67 v1(57.86,11.67)
SCAN_3S_IN<0>: length 241.1
  TOP w0.076: U300.A2 241.8,36.04 241.36,35.6
  TOP w0.102: v1(38.24,11.26) 36.96,12.54 36.96,14.96 36.96,15.13 39.3,17.47 39.3,18.27 41.76,20.73 42.1,20.73 42.34,20.49 42.34,20.16 42.58,19.92 42.95,19.92 v1(43.35,20.32) 43.35,21.68 42.34,22.7 v2(42.34,23.64) ; 241.36,35.6 240.4,34.64 240.02,34.64 v1(239.92,34.54)
  L3 w0.102: v1(97.73,26.57) 85.07,13.91 64.57,13.91 63.48,15 49.95,15 44.99,10.04 39.46,10.04 v1(38.24,11.26)
  BOTTOM w0.102: RS300.1 42.43,23.73 v2(42.34,23.64) ; v1(97.73,26.57) 98.34,25.96 100.03,25.96 102.41,23.59 134.86,23.59 135.51,22.94 137.42,22.94 137.65,22.71 143.78,22.71 144.43,22.06 174.09,22.06 175.36,23.34 218.71,23.34 218.73,23.36 224.86,23.36 230.05,28.55 230.05,28.81 233.58,32.35 234.55,32.35 234.65,32.45 234.95,32.45 235.71,33.21 237.34,33.21 238.06,33.93 239.31,33.93 v1(239.92,34.54) ; D302.6 43.71,20.68 v1(43.35,20.32)
SCAN_3S_IN<1>: length 248.9
  TOP w0.076: 239.54,35.32 239.94,35.72 240.15,35.72 240.58,36.15 240.58,36.39 240.87,36.68 240.87,37.4 240.98,37.51 240.98,37.55 U300.A3
  TOP w0.102: 239.54,35.32 239.01,34.79 238.82,34.79 v1(238.75,34.72) ; v1(39.46,11.26) 39.05,10.85 38.07,10.85 36.03,12.89 31.19,12.89 30.88,13.21 30.88,13.54 32.36,15.03 33.48,15.03 v1(36.36,17.91)
  L3 w0.102: v1(39.46,11.26) 40.27,10.45 44.82,10.45 51.4,17.02 58.42,17.02 59.17,16.27 62.78,16.27 64.74,14.31 84,14.31 96.87,27.18 98.34,27.18 v1(98.95,26.57)
  BOTTOM w0.102: v1(98.95,26.57) 100,26.57 102.57,24 135.03,24 135.67,23.35 137.59,23.35 137.82,23.11 143.95,23.11 144.6,22.47 173.92,22.47 175.19,23.74 218.54,23.74 218.56,23.76 224.69,23.76 229.64,28.72 229.64,28.98 233.41,32.76 234.38,32.76 234.48,32.86 234.78,32.86 235.54,33.62 235.74,33.62 235.74,33.62 237.17,33.62 238.28,34.72 v1(238.75,34.72) ; v1(36.36,17.91) 36.66,17.91 37.68,18.92 37.81,18.92 39.42,20.53 v3(39.42,20.59) 39.42,21.4 40.32,22.31 D302.3 41.93,24.34 42.03,24.44 RS300.2
SCAN_3S_IN<2>: length 228.6
  TOP w0.102: v1(238.75,35.54) 239.3,36.09 240,36.09 240.21,36.3 240.21,36.55 240.5,36.84 U300.A4 ; v1(42.34,25.08) 45.06,25.08 45.34,24.8 46.1,24.8 46.56,24.34 46.56,24.05 47.17,23.45 v3(47.17,19.19) v1(47.17,18.1)
  L3 w0.102: v1(47.17,18.1) 47.71,18.65 53.22,18.65 53.83,18.05 59.44,18.05 59.54,17.95 65.98,17.95 68.6,15.33 83.58,15.33 95.72,27.47 95.72,27.63 96.7,28.6 99.46,28.6 99.56,28.5 v1(99.56,27.59)
  BOTTOM w0.076: 236.57,35.32 237.02,35.76 237.27,35.76 237.39,35.88 237.94,35.88 238.29,35.54 v1(238.75,35.54)
  BOTTOM w0.102: D304.6 42.69,16.03 43.06,16.4 43.06,17.31 43.25,17.5 45.06,17.5 45.34,17.77 45.34,17.79 45.58,18.03 47.09,18.03 v1(47.17,18.1) ; RS300.3 v1(42.34,25.08) ; v1(99.56,27.59) 99.85,27.59 102.83,24.6 135.28,24.6 135.93,23.96 137.84,23.96 138.08,23.72 144.2,23.72 144.85,23.08 173.66,23.08 174.94,24.35 218.29,24.35 218.31,24.37 224.43,24.37 229.03,28.97 229.03,29.24 233.16,33.36 234.12,33.36 234.23,33.47 234.53,33.47 235.29,34.23 235.48,34.23 236.57,35.32
SCAN_3S_IN<3>: length 245.8
  TOP w0.076: 240.69,37.24 240.69,37.46 240.82,37.58 240.82,38 241.15,38.33 U300.B3
  TOP w0.102: v1(40.07,11.26) 41.13,12.33 v3(41.13,15.56) 41.13,17.31 v1(41.73,17.91) 41.93,17.7 41.93,17.65 41.93,17.65 42.14,17.45 42.29,17.3 43.4,17.3 43.76,17.65 43.76,18.07 44,18.31 44.05,18.31 45.79,20.06 45.79,21.41 45.54,21.66 45.54,22.18 46.45,23.09 46.45,23.87 46.36,23.97 46.36,24.25 46.01,24.6 42.25,24.6 41.93,24.92 41.93,25.29 v1(42.34,25.69) ; v1(236.57,34.46) 237.44,34.46 238.11,35.13 239.07,35.13 239.83,35.9 240.08,35.9 240.4,36.22 240.4,36.47 240.69,36.76 240.69,37.24
  L3 w0.102: v1(40.07,11.26) 40.68,10.65 44.74,10.65 51.32,17.23 58.5,17.23 59.26,16.47 62.87,16.47 64.82,14.52 83.92,14.52 96.99,27.59 v1(97.12,27.59)
  BOTTOM w0.102: v1(236.57,34.46) 236.29,34.46 235.66,33.82 235.46,33.82 234.69,33.06 234.39,33.06 234.29,32.96 233.33,32.96 229.44,29.07 229.44,28.8 224.6,23.97 218.48,23.97 218.45,23.95 175.11,23.95 173.83,22.67 144.68,22.67 144.04,23.31 137.91,23.31 137.67,23.55 135.76,23.55 135.11,24.2 102.66,24.2 99.88,26.98 97.73,26.98 v1(97.12,27.59) ; D304.3 41.15,17.33 v1(41.73,17.91) ; v1(42.34,25.69) 42.37,25.72 RS300.4
SCAN_3S_IN<4>: length 226.1
  TOP w0.076: 240.18,37.34 240.18,38.04 U300.B4
  TOP w0.102: v1(45.92,26.63) 45.94,26.63 48.56,24.01 v3(48.56,22.82) 48.56,20.4 49.12,19.84 49.12,19.4 v1(47.83,18.1) 47.42,17.7 47,17.7 46.67,18.03 44.29,18.03 v1(44.17,17.91) ; v1(239.84,36.45) 240.3,36.91 240.3,37.22 240.18,37.34
  L3 w0.102: v1(98.95,27.59) 98.95,28.3 98.85,28.4 96.78,28.4 95.93,27.54 95.93,27.39 83.66,15.13 68.51,15.13 65.89,17.74 59.46,17.74 59.36,17.85 53.74,17.85 53.14,18.45 48.17,18.45 v1(47.83,18.1)
  BOTTOM w0.076: v1(239.84,36.45) 239.44,36.04 237.32,36.04 237.2,35.93 236.5,35.93 235.89,35.32
  BOTTOM w0.102: D303.6 43.71,18.36 v1(44.17,17.91) ; 235.89,35.32 235.18,34.61 235.16,34.61 234.95,34.41 234.24,34.41 234.16,34.33 233.84,34.33 228.83,29.32 228.83,29.06 224.35,24.58 218.22,24.58 218.2,24.55 174.86,24.55 173.58,23.28 144.93,23.28 144.29,23.92 138.16,23.92 137.92,24.16 136.01,24.16 135.36,24.81 102.91,24.81 99.73,27.99 99.39,27.99 98.98,27.59 v1(98.95,27.59) ; RS300.6 45.73,26.44 v1(45.92,26.63)
SCAN_3S_IN<5>: length 243
  TOP w0.076: U300.C3 241.15,38.92 241.48,38.59 241.48,37.58 241.64,37.43 241.64,36.31 240.65,35.32
  TOP w0.102: v1(38.85,11.26) 37.16,12.95 37.16,15.04 39.51,17.39 39.51,17.9 v1(41.93,20.32) ; v1(240.23,35.05) 240.37,35.05 240.65,35.32
  L3 w0.102: v1(98.34,26.57) 97.93,26.98 96.95,26.98 84.09,14.11 64.66,14.11 63.56,15.2 49.87,15.2 44.91,10.24 39.86,10.24 v1(38.85,11.26)
  L6 w0.102: v2(45.92,25.97) 45.25,25.97 41.93,22.66 v1(41.93,20.32)
  BOTTOM w0.102: v2(45.92,25.97) 45.67,25.72 RS300.7 ; D303.3 v1(41.93,20.32) ; v1(240.23,35.05) 239.68,35.05 238.76,34.13 237.97,34.13 237.26,33.42 235.62,33.42 234.86,32.65 234.56,32.65 234.46,32.55 233.5,32.55 229.85,28.9 229.85,28.63 224.77,23.56 218.64,23.56 218.62,23.54 175.28,23.54 174,22.26 144.51,22.26 143.87,22.91 137.74,22.91 137.5,23.14 135.59,23.14 134.94,23.79 102.49,23.79 100.12,26.16 98.75,26.16 v1(98.34,26.57)
SCAN_3S_IN<6>: length 223.3
  TOP w0.076: U300.C4 v1(240.83,38.69)
  TOP w0.102: v1(45.92,25.31) 46.77,24.47 46.77,24.13 47.75,23.15 47.75,20.64 v1(48.71,19.67)
  L3 w0.102: v1(48.71,19.67) 48.92,19.47 65.1,19.47 65.6,19.47 68.93,16.14 83.24,16.14 94.91,27.81 94.91,27.96 96.36,29.42 96.55,29.42 96.95,29.82 98.51,29.82 98.75,29.58 98.75,29.16 99.1,28.81 100.65,28.81 v1(101.15,29.31) ; v1(45.92,25.31) 46.53,25.92 46.53,27.18 47.5,28.16 v2(47.5,30.16)
  BOTTOM w0.076: 232.51,36.75 232.74,36.51 235.19,36.51 236.21,37.53 237.35,37.53 237.37,37.52 238.61,37.52 238.99,37.9 239.69,37.9 240.1,38.31 240.44,38.31 v1(240.83,38.69)
  BOTTOM w0.102: v1(101.15,29.31) 104.03,26.43 136.04,26.43 136.69,25.79 138.6,25.79 138.83,25.55 144.96,25.55 145.61,24.9 172.91,24.9 174.18,26.18 216.57,26.18 221.52,31.14 224.53,31.14 225.49,32.1 225.49,32.82 229.51,36.84 229.92,36.84 229.93,36.84 232.41,36.84 232.51,36.75 ; RS300.8 45.59,25.08 v1(45.92,25.31) ; D301.3 v2(47.5,30.16)
SCAN_3S_IN<7>: length 234.1
  TOP w0.076: v1(240.18,38.69) U300.C5
  TOP w0.102: v1(45.84,24.2) 46.25,23.79 46.25,23.42 46.01,23.18 43.97,23.18 43.88,23.27 43.54,23.27 43.3,23.03 43.3,22.7 45.18,20.82 v1(45.18,20.32) 44.37,19.51 41.9,19.51 40.12,17.73 40.12,17.12 38.05,15.05 v2(38.05,14.39)
  L3 w0.102: v1(99.63,30.43) 99.23,30.84 96.35,30.84 93.89,28.39 93.89,28.23 82.82,17.16 72.89,17.16 69.89,20.16 68.65,20.16 68.15,20.16 66.27,22.04 54.21,22.04 53.9,22.34 48.14,22.34 46.12,20.32 v1(45.18,20.32)
  BOTTOM w0.076: v1(240.18,38.69) 239.55,38.06 238.92,38.06 238.54,37.68 237.44,37.68 237.42,37.7 236.14,37.7 235.12,36.68 233.05,36.68 232.68,37.05 232.51,37.05
  BOTTOM w0.102: CN300.20 38.29,14.16 v2(38.05,14.39) ; RS300.9 45.59,24.44 v1(45.84,24.2) ; 232.51,37.05 229.84,37.05 229.84,37.04 229.43,37.04 225.29,32.9 225.29,32.18 224.45,31.34 222.07,31.34 221.44,31.34 216.48,26.38 174.1,26.38 172.82,25.11 145.69,25.11 145.05,25.75 138.92,25.75 138.68,25.99 136.77,25.99 136.12,26.64 104.44,26.64 101.26,29.82 100.94,29.82 100.77,29.99 100.08,29.99 v1(99.63,30.43)
SCAN_3S_OUT<0>: length 259.5
  TOP w0.076: v1(239.26,36.45) 239.39,36.58 239.39,37.44 239.52,37.57 239.52,38.03 U300.B5
  L3 w0.102: v1(27.84,11.26) 28.24,10.85 35.8,10.85 36.82,11.87 45.38,11.87 51.15,17.63 59.28,17.63 59.38,17.54 65.81,17.54 68.43,14.92 83.75,14.92 96.13,27.31 96.13,27.46 96.87,28.2 97.98,28.2 v1(98.34,27.84)
  L6 w0.102: v1(246.19,29.51) 246.07,29.51 245.09,30.48 243.46,30.48 242.27,31.67 242.27,32.69 241.65,33.32 240.45,33.32 239.26,34.51 239.26,36.21 v1(239.26,36.45)
  BOTTOM w0.076: v1(239.26,36.45) 239.02,36.21 237.25,36.21 237.13,36.1 236.36,36.1 235.58,35.32
  BOTTOM w0.102: 235.58,35.32 234.95,34.69 234.23,34.69 234.15,34.61 234.07,34.53 233.75,34.53 228.63,29.41 228.63,29.14 224.27,24.78 218.14,24.78 218.12,24.76 174.77,24.76 173.5,23.48 145.02,23.48 144.37,24.13 138.24,24.13 138.01,24.36 136.1,24.36 135.45,25.01 103,25.01 99.81,28.2 98.7,28.2 v1(98.34,27.84) ; R339.1 257.93,31.61 257.74,31.61 255.12,29 254.89,29 252.78,26.88 251.66,26.88 250.73,27.81 250.27,27.81 249.7,27.24 v3(249.09,27.24) 248.46,27.24 v1(246.19,29.51) ; CN300.41 27.79,11.31 27.79,11.31 v1(27.84,11.26)
SCAN_3S_OUT<1>: length 250
  TOP w0.076: 238.87,36.94 238.87,38.03 U300.B6
  TOP w0.102: 238.87,36.94 237.7,35.77 237.7,35.68 v1(237.53,35.51)
  L3 w0.102: v1(97.73,27.59) 97.32,27.99 96.95,27.99 96.33,27.37 96.33,27.22 83.83,14.72 64.91,14.72 62.95,16.68 59.34,16.68 58.59,17.43 51.23,17.43 45.47,11.67 45.3,11.67 45.3,11.67 37.19,11.67 v2(36.79,11.26)
  L6 w0.102: v1(246.19,28.86) 246.09,28.86 244.66,30.28 243.38,30.28 241.15,32.51 240.98,32.51 239.28,34.2 238.55,34.2 237.53,35.22 v1(237.53,35.51)
  BOTTOM w0.076: 236.85,35.32 237.04,35.51 v1(237.53,35.51)
  BOTTOM w0.102: R338.1 258.36,31.41 257.85,31.41 255.23,28.79 254.98,28.79 252.87,26.68 251.15,26.68 250.73,26.27 249.02,26.27 246.41,28.88 246.21,28.88 v1(246.19,28.86) ; CN300.23 v2(36.79,11.26) ; 236.85,35.32 236.77,35.24 236.77,35.24 235.56,34.02 235.37,34.02 234.61,33.26 234.31,33.26 234.21,33.16 233.24,33.16 229.24,29.15 229.24,28.89 224.52,24.17 218.39,24.17 218.37,24.15 175.02,24.15 173.75,22.87 144.77,22.87 144.12,23.52 137.99,23.52 137.76,23.75 135.84,23.75 135.2,24.4 102.74,24.4 99.96,27.18 98.14,27.18 v1(97.73,27.59)
SCAN_3S_OUT<2>: length 263.5
  TOP w0.076: v1(234.83,35.4) 235.25,35.82 235.85,35.82 236.11,36.07 236.99,36.07 238.22,37.31 238.22,38.04 U300.B7
  L3 w0.102: v2(28.5,11.26) 29.8,12.56 42.09,12.56 42.26,12.56 46.35,16.66 46.35,18.44 47.18,19.27 65.18,19.27 65.52,19.27 68.85,15.94 83.33,15.94 95.11,27.73 95.11,27.88 96.45,29.21 96.92,29.21 v1(97.12,29.42)
  L6 w0.102: v1(246.2,27.56) 246.18,27.56 245.37,28.38 245.37,28.68 244.17,29.87 243.21,29.87 240.98,32.1 240.81,32.1 239.11,33.8 238.38,33.8 236.78,35.4 v1(234.83,35.4)
  BOTTOM w0.076: 234.75,35.32 v1(234.83,35.4)
  BOTTOM w0.102: v1(246.2,27.56) 247.15,27.56 248.85,25.86 250.9,25.86 251.31,26.27 253.03,26.27 255.07,28.31 255.37,28.31 258.06,31 259.78,31 R336.1 ; v2(28.5,11.26) 28.29,11.47 CN300.40 ; v1(97.12,29.42) 98.14,28.4 99.9,28.4 103.08,25.21 135.53,25.21 136.18,24.57 138.09,24.57 138.33,24.33 144.46,24.33 145.1,23.69 173.41,23.69 174.69,24.96 218.03,24.96 218.05,24.98 224.18,24.98 228.42,29.22 228.42,29.49 233.67,34.74 233.99,34.74 234.22,34.96 234.4,34.97 234.75,35.32
SCAN_3S_OUT<3>: length 257.3
  TOP w0.076: U300.B8 237.58,38.05 237.58,37.6 237.38,37.4 237.2,37.4 235.79,35.98 234.77,35.98 234.21,35.42 v1(234.21,35.41)
  L3 w0.102: v1(97.73,29.42) 97.32,29.01 96.53,29.01 95.32,27.8 95.32,27.64 83.41,15.74 68.76,15.74 65.44,19.06 65.27,19.06 47.26,19.06 46.56,18.36 46.56,16.57 42.26,12.28 35.73,12.28 34.71,11.26 v2(33.79,11.26)
  L6 w0.102: v1(234.21,35.41) 234.6,35.8 236.66,35.8 238.46,34 239.2,34 240.89,32.3 241.06,32.3 243.29,30.08 244.26,30.08 246.15,28.18 v1(246.19,28.18)
  BOTTOM w0.076: v1(234.21,35.41) 234.21,35.41 234.12,35.32
  BOTTOM w0.102: v1(246.19,28.18) 246.82,28.18 248.94,26.07 250.82,26.07 251.23,26.48 252.95,26.48 255.06,28.59 255.32,28.59 257.93,31.21 259.13,31.21 259.13,31.21 R337.1 ; 234.12,35.32 233.79,34.99 233.64,34.99 228.22,29.57 228.22,29.31 224.1,25.19 217.97,25.19 217.95,25.16 174.6,25.16 173.33,23.89 145.19,23.89 144.54,24.53 138.41,24.53 138.18,24.77 136.27,24.77 135.62,25.42 103.17,25.42 99.98,28.6 98.54,28.6 v1(97.73,29.42) ; CN300.29 v2(33.79,11.26)
SCAN_3S_OUT<4>: length 225
  TOP w0.076: v1(238.23,38.69) U300.C7
  L3 w0.102: v2(35,13.37) 41.04,13.37 43.76,16.1 43.76,18.07 44,18.31 45.36,18.31 48.05,20.99 53.8,20.99 54.72,20.08 64.85,20.08 65.86,20.08 65.86,20.08 66.07,20.08 68.53,17.62 71.85,17.62 72.72,16.75 82.99,16.75 94.3,28.06 94.3,28.22 96.51,30.43 98.76,30.43 99.37,29.82 99.92,29.82 100.11,30.01 100.77,30.01 v1(101.19,30.43)
  BOTTOM w0.076: v1(238.23,38.69) 237.57,38.03 235.95,38.03 234.96,37.04 233.23,37.04 232.81,37.45 232.51,37.45
  BOTTOM w0.102: v2(35,13.37) 34.79,13.16 CN300.27 ; v1(101.19,30.43) 101.22,30.43 101.63,30.02 101.89,30.02 104.87,27.04 136.29,27.04 136.94,26.4 138.85,26.4 139.09,26.16 145.22,26.16 145.86,25.51 172.65,25.51 173.93,26.79 216.31,26.79 223.47,33.95 225.76,33.95 229.26,37.45 229.67,37.45 229.67,37.45 232.51,37.45
SCAN_3S_OUT<5>: length 237
  TOP w0.076: U300.C6 v1(239.53,38.69)
  L3 w0.102: v1(100.24,30.43) 99.84,30.03 99.45,30.03 98.85,30.63 96.43,30.63 94.1,28.3 94.1,28.15 82.91,16.96 72.8,16.96 71.94,17.82 68.62,17.82 66.15,20.28 65.94,20.28 64.76,20.28 64.76,20.28 54.8,20.28 53.89,21.2 47.96,21.2 45.28,18.52 41.76,18.52 41.32,18.07 41.32,17.74 41.43,17.63 41.43,14.05 40.95,13.58 35.47,13.58 35.27,13.78 34.83,13.78 34.59,13.54 34.59,13.21 34.35,12.97 28,12.97 v2(27.59,13.37)
  BOTTOM w0.076: 232.51,37.25 232.71,37.25 233.12,36.84 235,36.84 236.02,37.86 237.49,37.86 237.5,37.85 238.47,37.85 238.85,38.23 239.07,38.23 v1(239.53,38.69)
  BOTTOM w0.102: v1(100.24,30.43) 100.62,30.43 101.02,30.03 101.34,30.03 104.53,26.84 136.21,26.84 136.86,26.19 138.77,26.19 139,25.96 145.13,25.96 145.78,25.31 172.74,25.31 174.01,26.59 216.4,26.59 223.56,33.75 225.84,33.75 229.34,37.25 229.75,37.25 229.76,37.25 232.51,37.25 ; CN300.39 28.79,13.27 28.68,13.37 v2(27.59,13.37)
SCAN_3S_OUT<6>: length 227.6
  TOP w0.076: U300.C8 v1(237.58,38.69)
  L3 w0.102: v1(97.73,31.65) 97.32,31.24 96.18,31.24 93.49,28.55 93.49,28.4 82.65,17.57 73.05,17.57 70.06,20.56 69.72,20.56 69.72,20.56 68.48,20.56 68.48,20.56 68.31,20.56 66.43,22.44 54.45,22.44 53.86,23.03 48.45,23.03 48.2,22.77 44.77,22.77 42.93,20.93 41.85,20.93 41.68,20.93 40.92,20.17 40.92,17.57 41.02,17.46 41.02,14.22 40.78,13.98 36.19,13.98 v2(35.79,14.39)
  BOTTOM w0.076: 232.51,38.06 233.11,38.06 233.18,38.13 235.81,38.13 235.88,38.19 237.08,38.19 v1(237.58,38.69)
  BOTTOM w0.102: CN300.25 v2(35.79,14.39) ; v1(97.73,31.65) 98.34,31.04 102.05,31.04 105.44,27.65 136.55,27.65 137.19,27.01 139.1,27.01 139.34,26.77 145.47,26.77 146.12,26.12 172.4,26.12 173.68,27.4 216.06,27.4 223.22,34.56 225.51,34.56 229.01,38.06 229.42,38.06 229.42,38.06 232.51,38.06
SCAN_3S_OUT<7>: length 258.9
  TOP w0.076: U300.B9 236.93,38.04 236.93,37.59 235.79,36.45 235.66,36.45 235.52,36.31 234.37,36.31 233.88,35.82 233.26,35.82 v1(232.91,35.47) 232.77,35.32
  TOP w0.102: R380.1 232.72,35.27 232.77,35.32
  L3 w0.102: v1(98.34,29.42) 97.73,28.81 96.61,28.81 95.52,27.71 95.52,27.56 83.5,15.53 68.68,15.53 65.35,18.86 47.35,18.86 46.76,18.27 46.76,16.49 42.35,12.07 36.1,12.07 v2(35.29,11.26)
  L6 w0.102: v1(246.19,26.94) 245.15,27.99 245.15,28.61 244.09,29.67 243.12,29.67 240.9,31.9 240.73,31.9 239.03,33.59 238.29,33.59 236.9,34.99 233.38,34.99 233.12,35.25 233.12,35.26 v1(232.91,35.47)
  BOTTOM w0.076: v1(232.91,35.47) 232.91,35.32
  BOTTOM w0.102: CN300.26 v2(35.29,11.26) ; v1(98.34,29.42) 98.95,28.81 100.06,28.81 103.25,25.62 135.7,25.62 136.35,24.97 138.26,24.97 138.5,24.74 144.63,24.74 145.27,24.09 173.24,24.09 174.52,25.37 217.86,25.37 217.89,25.39 224.01,25.39 228.02,29.39 228.02,29.84 232.91,34.74 232.91,35.32 ; v1(246.19,26.94) 247.48,26.94 248.77,25.66 250.99,25.66 251.4,26.07 253.12,26.07 255.08,28.03 255.4,28.03 258.17,30.8 260.21,30.8 R335.1
SCAN_3S_OUT<8>: length 226
  TOP w0.076: U300.C9 v1(236.93,38.69)
  L3 w0.102: v1(98.67,31.65) 98.06,31.04 96.26,31.04 93.69,28.47 93.69,28.32 82.74,17.36 72.97,17.36 69.97,20.36 69.8,20.36 68.57,20.36 68.23,20.36 66.35,22.24 54.36,22.24 53.78,22.82 48.54,22.82 48.28,22.57 44.85,22.57 43.01,20.73 41.76,20.73 41.12,20.09 41.12,17.65 41.22,17.55 41.22,14.14 40.87,13.78 35.55,13.78 35.35,13.98 34.74,13.98 34.18,13.42 v1(34.18,13.37)
  BOTTOM w0.076: v1(236.93,38.69) 236.6,38.36 235.81,38.36 235.74,38.29 233.11,38.29 233.08,38.27 232.51,38.27
  BOTTOM w0.102: 232.51,38.27 229.34,38.27 229.33,38.26 228.92,38.26 225.42,34.76 223.14,34.76 219.65,31.28 215.16,31.28 213.8,29.91 213.21,29.91 212.04,31.08 158.6,31.08 157.05,29.53 103.85,29.53 102.14,31.24 99.08,31.24 v1(98.67,31.65) ; CN300.28 34.29,13.27 v1(34.18,13.37)
SCAN_3S_OUT<9>: length 221.7
  TOP w0.076: v1(234.16,37.62) 234.48,37.3 235.36,37.3 235.62,37.56 235.62,37.89 235.78,38.05 236.09,38.05 236.27,38.22 236.27,38.57 236.6,38.91 U300.C10
  L3 w0.102: v1(97.12,31.65) 96.92,31.45 96.09,31.45 83.02,18.38 80.71,18.38 80.52,18.19 76.46,18.19 75.96,18.19 75.46,18.19 73.19,18.19 70.61,20.77 69.64,20.77 68.4,20.77 66.52,22.65 54.53,22.65 53.95,23.23 49.44,23.23 48.37,23.23 48.11,22.98 44.68,22.98 42.85,21.14 41.93,21.14 41.93,21.14 41.6,21.14 40.62,20.16 v2(40.62,14.39)
  BOTTOM w0.076: v1(234.16,37.62) 233.82,37.96 233.24,37.96 233.14,37.86 232.51,37.86
  BOTTOM w0.102: v2(40.62,14.39) 40.29,14.06 CN300.16 ; 232.51,37.86 229.51,37.86 229.5,37.86 229.09,37.86 225.59,34.36 223.3,34.36 216.15,27.2 173.76,27.2 172.48,25.92 146.03,25.92 145.39,26.57 139.26,26.57 139.02,26.8 137.11,26.8 136.46,27.45 105.36,27.45 101.97,30.84 97.93,30.84 v1(97.12,31.65)
SCAN_3S_OUT<10>: length 220.5
  TOP w0.076: v1(232.62,38.66) 233.18,38.15 235.06,38.15 235.17,38.05 235.43,38.05 235.75,38.36 U300.B11
  L3 w0.102: v1(100.17,31.65) 99.85,31.97 99.82,31.97 99.73,32.06 99.44,32.06 99.03,32.46 96.25,32.46 82.77,18.99 80.45,18.99 80.27,18.8 76.21,18.8 73.44,18.8 68.98,23.26 54.21,23.26 54.03,23.43 52.44,23.43 51.27,24.6 49.45,24.6 48.03,23.18 44.6,23.18 42.76,21.34 42.02,21.34 41.51,21.34 40.08,19.91 40.08,18.66 v1(36.29,14.87)
  BOTTOM w0.076: 232.51,38.49 v1(232.62,38.66)
  BOTTOM w0.102: 232.51,38.49 232.48,38.47 229.25,38.47 229.25,38.46 227.98,38.46 227.74,38.22 227.12,38.22 225.54,36.65 225.3,36.65 224.22,35.57 222.8,35.57 219.32,32.09 214.68,32.09 214.02,31.43 212.55,31.43 212.3,31.69 158.34,31.69 156.8,30.14 104.1,30.14 102.29,31.96 102.15,32.09 100.61,32.09 v1(100.17,31.65) ; v1(36.29,14.87) 36.29,14.28 CN300.24
SCAN_3S_OUT<11>: length 232.2
  TOP w0.076: 232.51,36.03 232.63,36.15 233.31,36.15 234.08,36.92 235.66,36.92 236.27,37.53 236.27,37.99 236.43,38.16 236.43,38.2 U300.B10
  TOP w0.102: 232.51,36.03 232.29,35.8 231.65,35.8 231.39,35.55 v1(230.4,35.55)
  L3 w0.102: v1(99.97,29.42) 99.56,29.01 99.19,29.01 98.95,29.25 98.95,29.67 98.59,30.03 96.87,30.03 96.46,29.62 96.28,29.62 94.71,28.05 94.71,27.9 83.16,16.35 72.53,16.35 71.67,17.21 68.36,17.21 65.9,19.67 65.69,19.67 54.55,19.67 53.63,20.59 48.21,20.59 46.15,18.53 46.15,16.74 42.18,12.77 28.68,12.77 v2(27.18,11.26)
  BOTTOM w0.102: v1(99.97,29.42) 100.03,29.42 103.42,26.03 135.87,26.03 136.52,25.38 138.43,25.38 138.67,25.14 144.8,25.14 145.44,24.5 173.07,24.5 174.35,25.77 216.74,25.77 221.54,30.58 224.94,30.58 226.34,31.97 227.53,31.97 230,34.43 230,35.14 v1(230.4,35.55) ; v2(27.18,11.26) 27.29,11.37 CN300.42
SCAN_3S_OUT_R_<0>: length 3.1
  BOTTOM w0.102: CN375.17 258.3,33.35 v3(258.37,33.29) 258.39,33.26 R339.2
SCAN_3S_OUT_R_<1>: length 3.2
  BOTTOM w0.102: CN375.18 258.8,34.65 v3(259.05,34.41) 259.03,34.38 259.03,34.38 R338.2
SCAN_3S_OUT_R_<2>: length 4
  BOTTOM w0.102: CN375.20 259.8,34.95 v3(260.35,34.41) 260.52,34.23 260.52,32.24 R336.2
SCAN_3S_OUT_R_<3>: length 3.6
  BOTTOM w0.102: R337.2 v3(259.66,33.29) 259.53,33.42 259.53,34.61 259.3,34.84 CN375.19
SCAN_3S_OUT_R_<7>: length 5.3
  BOTTOM w0.102: v3(261.26,30.82) 261.26,31.9 261.14,32.01 R335.2 260.93,32.23 260.83,32.33 260.83,34.61 260.3,35.13 CN375.21
SCL_BAT_CHG: length 294.6
  TOP w0.076: 232.51,39.56 232.53,39.59 233.85,39.59 234.5,38.94 234.61,38.94 234.63,38.96 v1(234.63,38.96) 234.64,38.96 234.69,39.01 U300.C12
  TOP w0.13: v2(189.09,105.93) 189.25,105.93 189.78,106.46 U60000.22 ; R307.1 232.12,39.56 232.51,39.56
  L3 w0.097: v1(87.02,31.49) 87.53,30.98 93.55,30.98 96.3,33.73 98.09,33.73 v1(98.95,32.87)
  L6 w0.127: v1(220.77,79.78) 220.04,79.78 219.44,79.18 219.44,78.94 216.72,76.22 216.72,70.46 216.33,70.07 216.33,68.31 218.09,66.54 218.09,65.84 218.91,65.03 218.91,64.16 218.3,63.55 218.3,62.21 220.19,60.32 220.19,60.11 220.19,57.5 219.2,56.51 219.2,49.72 221.68,47.25 221.68,46.6 223.21,45.07 223.21,41.2 223.67,40.74 224.7,40.74 225.61,39.83 233.05,39.83 233.12,39.75 233.55,39.75 234.34,38.96 v1(234.63,38.96)
  BOTTOM w0.076: v1(234.63,38.96) 233.98,39.61 233.12,39.61 233.1,39.63 232.51,39.63
  BOTTOM w0.13: v2(189.09,105.93) 189.09,104.73 189.22,104.6 194.46,104.6 195.48,105.63 197.25,105.63 198.16,106.53 202.54,106.53 205.46,103.62 209.68,103.62 211.78,105.71 218.56,105.71 220.65,107.8 225.87,107.8 226.12,107.55 226.12,97.45 225.87,97.2 224.76,97.2 221.91,94.36 220.37,94.36 219.38,93.37 219.38,89.52 220.78,88.12 220.78,87.53 221.93,86.37 221.93,82.57 221.19,81.83 221.19,80.2 v1(220.77,79.78) ; v1(98.95,32.87) 99.23,33.15 102.37,33.15 104.88,30.64 156.59,30.64 158.14,32.19 212.5,32.19 212.59,32.1 213.98,32.1 214.48,32.59 219.11,32.59 222.59,36.07 224.02,36.07 225.1,37.15 225.34,37.15 226.91,38.72 227.17,38.72 228.42,39.98 229.03,39.98 229.03,39.99 229.98,39.99 230.07,40.07 231.75,40.07 232.08,39.74 232.08,39.74 232.19,39.63 232.51,39.63 ; v1(87.02,31.49) 87.02,30.11 R6050.1
SCL_BAT_R_CHG: length 17.3
  BOTTOM w0.13: CN6050.5 81.1,22.21 82.37,20.94 86.17,20.94 87.83,22.6 87.83,25.85 87.22,26.46 TP6051.1 87.09,26.96 C7501.2 87.85,27.86 87.98,27.99 D7505.2 87.66,29.21 R6050.2
SCL_P: length 200.8
  TOP w0.076: 239.21,50.36 239.21,50.34 239.23,50.32 239.23,49.17 239.34,49.05 239.34,48.07 239.5,47.91 239.5,47.48 239.84,47.15 239.84,46.48 240.04,46.28 240.04,45.7 239.53,45.19 239.53,44.58 239.2,44.25 U300.L6
  TOP w0.102: v1(228.24,62.5) 228.86,61.87 228.86,61.33 231.07,59.12 232.56,59.12 233.41,58.27 233.41,56.19 233.65,55.95 235.29,55.95 236.39,54.85 236.39,53.47 237.61,52.25 237.61,51.51 238.21,50.92 238.65,50.92 239.21,50.36
  L3 w0.102: v1(221.21,77.66) 221.78,77.66 222.14,78.02 222.14,87.5 217.58,92.06 217.58,92.79 216.84,93.54 216.84,94.57 213.81,97.6 213.81,99.26 213.34,99.73 211.81,99.73 210.73,98.65 210.73,96.72 209.13,95.12 200.06,95.12 v1(197.56,97.63)
  L6 w0.102: v1(221.21,77.66) 221.19,77.65 221.19,74.9 223.9,72.19 223.9,67.74 228.24,63.4 v1(228.24,62.5) ; v1(101.7,88.05) 102.92,89.27 109.56,89.27 111.34,91.05 121.91,91.05 126.02,95.16 127.92,95.16 128.55,95.8 156.44,95.8 161.69,101.06 164.46,101.06 166.33,99.19 166.75,99.19 168.89,99.19 173.14,103.44 181.24,103.44 183.93,100.75 183.94,100.75 184.91,99.79 195.82,99.79 197.15,98.46 197.15,98.03 v1(197.56,97.63)
  BOTTOM w0.102: R66004.1 101.75,91.83 v3(101.75,91.02) 101.75,90.46 102.38,89.83 102.38,88.74 v1(101.7,88.05)
SCR_RST#: length 1.6
  BOTTOM w0.102: CN200.6 58.75,10.22 TP851.1
SDA_BAT_CHG: length 296.5
  TOP w0.076: U300.B12 235.28,38.34 234.21,38.34 v1(233.85,38.7) 233.8,38.65 233.2,38.65 232.99,38.86 232.99,38.98 232.84,39.13 232.51,39.13
  TOP w0.13: v1(188.43,105.93) 188.43,106.16 188.91,106.64 189.6,106.64 189.82,106.86 U60000.21 ; 232.51,39.13 232.22,39.13 R306.1
  L3 w0.097: v1(86.36,31.49) 87.17,30.67 93.56,30.67 96.39,33.5 97.66,33.5 v1(98.29,32.87)
  L6 w0.127: v1(233.85,38.7) 233.85,39.09 233.44,39.5 233.02,39.5 232.94,39.57 225.51,39.57 224.59,40.49 223.57,40.49 222.96,41.1 222.96,41.31 222.96,41.31 222.96,44.96 221.42,46.5 221.42,47.14 218.94,49.62 218.94,56.62 219.94,57.61 219.94,60.21 218.04,62.11 218.04,63.65 218.65,64.26 218.65,64.93 217.84,65.74 217.84,66.44 216.07,68.2 216.07,70.18 216.46,70.57 216.46,76.33 219.19,79.05 219.19,79.29 219.94,80.04 220.26,80.04 220.77,80.55 v1(220.77,80.76)
  BOTTOM w0.076: 232.51,39.37 233.61,39.37 233.96,39.03 233.96,38.8 v1(233.85,38.7)
  BOTTOM w0.13: v1(86.36,31.49) 86.36,30.34 R6051.1 ; 232.51,39.37 232.09,39.37 231.64,39.82 230.17,39.82 230.09,39.73 229.13,39.73 229.13,39.73 229.03,39.72 228.53,39.72 227.27,38.47 227.02,38.47 225.44,36.9 225.2,36.9 224.12,35.82 222.7,35.82 219.22,32.34 214.58,32.34 214.09,31.84 212.48,31.84 212.4,31.93 158.24,31.93 156.7,30.38 104.78,30.38 102.27,32.89 99.57,32.89 99.12,32.45 98.71,32.45 v1(98.29,32.87) ; v1(188.43,105.93) 188.43,104.48 188.56,104.35 194.57,104.35 195.59,105.37 197.36,105.37 198.27,106.28 202.44,106.28 205.36,103.36 205.57,103.36 205.57,103.36 209.79,103.36 211.89,105.45 218.67,105.45 220.76,107.54 225.77,107.54 225.86,107.45 225.86,97.55 225.77,97.46 224.65,97.46 221.81,94.61 220.26,94.61 219.12,93.47 219.12,89.42 220.52,88.01 220.52,87.42 221.68,86.27 221.68,82.68 220.77,81.77 v1(220.77,80.76)
SDA_BAT_R_CHG: length 16.5
  BOTTOM w0.13: R6051.2 85.36,29.21 D7504.2 85.04,27.99 85.17,27.86 C7500.2 TP6050.1 86.3,26.49 86.76,26.49 87.5,25.74 87.5,22.63 86.14,21.27 82.57,21.27 82.35,21.5 CN6050.4
