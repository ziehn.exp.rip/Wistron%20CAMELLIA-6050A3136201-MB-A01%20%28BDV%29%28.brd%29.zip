# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_COMP: length 2.8
  TOP w0.13: v1(174.29,74.69) 174.43,74.84 174.43,76.05 R4756.1 174.85,76.09 v3(175.18,76.42)
  BOTTOM w0.13: U4555.CC5 v1(174.29,74.69)
USB30_RX1_C_DN_DB: length 9.5
  TOP w0.119: C9225.2 41.59,70.7 41.59,70.92 v3(42.14,71.46) 41.59,72.01 41.59,72.36 41.33,72.62 41.33,73.71 42.54,74.92 42.54,77.9 42.68,78.04 U9203.23
USB30_RX1_C_DP_DB: length 9.5
  TOP w0.119: U9203.22 42.18,78.04 42.32,77.9 42.32,75.01 41.11,73.8 41.11,72.52 41.37,72.26 41.37,72 v3(40.84,71.46) 41.37,70.93 41.37,70.64 C9224.2
USB30_RX1_DN: length 209.6
  L6 w0.076: 172.36,76.14 172.36,76.12 172.33,76.08 172.33,75.16 172.09,74.91 172.09,73.98 172.21,73.86 172.32,73.86 172.47,74.01 v1(172.47,74.09)
  L6 w0.127: 172.36,76.14 172.36,77.98 172.63,78.25 172.63,80.75 170.27,83.11 157.05,83.11 153.7,86.45 147.57,86.45 146.97,87.05 144.42,87.05 143.76,87.71 130.54,87.71 127.93,85.11 120.1,85.11 115.98,80.99 114.9,80.99 114.77,80.86 109.79,75.88 109.79,74.84 102.56,67.61 102.56,61.21 100.47,59.12 99.67,59.12 80.81,40.26 79.41,40.26 76.87,37.72 75.27,37.72 74.77,37.22 71.65,37.22 70.52,36.1 67.59,36.1 66.23,34.73 63.47,34.73 63.09,34.36 60.59,34.36 59.78,35.17 48.94,35.17 47.99,36.12 46.22,36.12 45.11,37.24 27.4,37.24 27.38,37.23 21.16,37.23 20.52,37.86 12.44,37.86 11.46,36.88 10.92,36.88 10.8,37.01 10.8,37.09 v1(11.06,37.35)
  BOTTOM w0.076: U4555.CB5 173,74.39 173,74.18 172.92,74.11 172.48,74.11 v1(172.47,74.09)
  BOTTOM w0.119: CN2500.13 10.25,43.42 10.11,43.28 10.11,41.09 TP2509.1 10.11,40.04 10.11,39.93 10.87,39.17 10.87,38.58 10.79,38.5 10.79,37.62 v1(11.06,37.35)
USB30_RX1_DN_DB: length 5.7
  TOP w0.119: v2(41.84,68.19) 41.62,68.4 41.62,69.15 C9225.1
  BOTTOM w0.119: CN9202.18 41.25,71.42 41.11,71.28 41.11,70.46 41.58,69.98 41.58,68.44 v2(41.84,68.19)
USB30_RX1_DP: length 209.5
  L6 w0.076: 172.13,76.14 172.13,76.12 172.17,76.08 172.17,75.23 171.92,74.98 171.92,73.91 172.43,73.4 v1(172.47,73.4)
  L6 w0.127: 172.13,76.14 172.13,78.08 172.4,78.34 172.4,80.65 170.17,82.88 156.95,82.88 153.61,86.22 147.47,86.22 146.87,86.82 144.33,86.82 143.67,87.48 130.63,87.48 128.03,84.88 120.19,84.88 116.08,80.76 115,80.76 110.02,75.78 110.02,74.75 102.79,67.52 102.79,61.12 100.56,58.89 99.76,58.89 80.9,40.03 79.51,40.03 76.97,37.49 75.36,37.49 74.86,36.99 71.74,36.99 70.62,35.87 67.69,35.87 66.32,34.5 63.56,34.5 63.19,34.13 60.5,34.13 59.69,34.94 48.85,34.94 47.89,35.89 46.13,35.89 46.06,35.96 45.01,37.01 27.49,37.01 27.48,37 21.06,37 20.43,37.63 12.54,37.63 11.56,36.65 10.83,36.65 10.57,36.91 10.57,37.19 v1(10.41,37.35)
  BOTTOM w0.076: v1(172.47,73.4) 172.89,73.82 U4555.CB6
  BOTTOM w0.119: v1(10.41,37.35) 10.57,37.51 10.57,38.6 10.65,38.67 10.65,39.08 9.89,39.84 9.89,40.04 TP2510.1 9.89,41.09 9.89,43.28 9.75,43.42 CN2500.14
USB30_RX1_DP_DB: length 5.7
  TOP w0.119: v1(41.09,68.19) 41.4,68.51 41.4,69.15 C9224.1
  BOTTOM w0.119: v1(41.09,68.19) 41.36,68.47 41.36,69.89 40.89,70.37 40.89,71.28 40.75,71.42 CN9202.17
USB30_RX1_RE_DN_DB: length 23.5
  TOP w0.119: v1(44.08,83.86) 44.43,84.21 44.43,84.39 44.13,84.69 43.63,84.69 43.41,84.47 43.24,84.47 43.02,84.69 42.87,84.69 42.68,84.49 42.48,84.49 42.29,84.69 42.17,84.69 41.89,84.41 D9203.1 D9203.10 39.95,84.41 39.81,84.55 39.64,84.55 39.56,84.47 39.56,83.76 38.69,82.9 36.84,82.9 36.25,82.31 34.35,82.31 v4(33.83,81.8) 33.41,81.38 32.12,81.38 31.33,80.59 30.8,80.59 30.68,80.47 CN9201.5 ; U9203.8 42.68,83.13 42.54,83.27 42.54,83.59 v2(42.81,83.86)
  L3 w0.109: v2(42.81,83.86) 42.64,83.86 42.32,83.54 42.32,83.34 42.69,82.97 44.19,82.97 44.53,83.3 44.53,83.49 44.16,83.86 v1(44.08,83.86)
USB30_RX1_RE_DP_DB: length 23.5
  TOP w0.119: v1(42.06,83.86) 42.32,83.59 42.32,83.27 42.18,83.13 U9203.9 ; v2(44.74,83.86) 44.65,83.94 44.65,84.48 44.22,84.91 D9203.2 D9203.9 39.95,84.91 39.81,84.77 39.55,84.77 39.34,84.56 39.34,83.86 38.6,83.12 36.75,83.12 36.16,82.54 34.26,82.54 33.32,81.6 32.03,81.6 31.24,80.81 30.8,80.81 30.68,80.93 CN9201.6
  L3 w0.109: v1(42.06,83.86) 42.11,83.8 42.11,83.26 42.61,82.76 44.28,82.76 44.74,83.22 v2(44.74,83.86)
USB30_RX2_C_DN_DB: length 8.8
  TOP w0.119: U9201.23 39.76,96.71 39.62,96.57 39.62,93.29 40.84,92.08 40.84,91.51 v3(41.37,90.97) 40.84,90.43 40.84,89.98 C9211.2
USB30_RX2_C_DP_DB: length 8.7
  TOP w0.119: U9201.22 39.26,96.71 39.4,96.57 39.4,93.2 40.62,91.98 40.62,91.49 v3(40.1,90.97) 40.62,90.46 40.62,89.98 C9212.2
USB30_RX2_DN: length 207.2
  L6 w0.076: 170.85,76.07 170.86,76.06 170.86,76.01 171.16,75.71 171.16,73.1 171.96,72.29 172.09,72.29 172.47,72.67 v1(172.47,72.76)
  L6 w0.127: v1(14.87,34.53) 14.61,34.27 14.61,34.08 14.74,33.95 15.81,33.95 16.96,32.81 18.62,32.81 19.46,33.64 33.85,33.64 34.91,34.7 44.84,34.7 47.29,32.25 69.84,32.25 72.1,34.51 80.48,34.51 82.95,36.98 82.95,37.77 85.68,40.5 87.76,40.5 89.17,41.91 89.26,41.91 104.77,57.43 104.77,67.02 111.86,74.11 111.86,75.07 114.03,77.24 114.88,77.24 115.8,78.17 122.17,78.17 122.8,78.8 123.4,78.8 123.73,79.13 126.92,79.13 129.89,82.1 131.22,82.1 133.71,84.58 140.69,84.58 141.12,85.01 142.93,85.01 143.47,84.47 152.88,84.47 156.23,81.13 165.79,81.13 165.88,81.04 165.88,81.04 170.85,76.07
  BOTTOM w0.076: v1(172.47,72.76) 172.22,72.52 U4555.BY8
  BOTTOM w0.119: CN2500.4 14.75,43.42 14.47,43.14 14.47,42.29 14.79,41.96 TP2503.1 14.73,41.56 14.73,34.68 v1(14.87,34.53)
USB30_RX2_DN_DB: length 21
  TOP w0.119: C9211.1 40.84,88.46 40.84,88.19 41.07,87.96 v1(41.07,87.92)
  L6 w0.127: v1(41.07,87.92) 40.85,87.71 40.85,85.35 39.55,84.05 39.55,82.54 40.2,81.89 40.2,78.58 42.35,76.44 43.25,76.44 45.61,74.07 45.61,73.77 v1(45.87,73.51)
  BOTTOM w0.119: v1(45.87,73.51) 45.61,73.25 45.61,72.72 45.75,72.58 CN9202.27
USB30_RX2_DP: length 207.2
  L6 w0.076: 170.69,75.91 170.7,75.89 170.74,75.89 170.99,75.65 170.99,73.03 171.89,72.13 v1(172.47,72.13)
  L6 w0.127: 170.69,75.91 165.7,80.9 156.13,80.9 152.79,84.24 143.37,84.24 142.83,84.78 141.22,84.78 140.79,84.36 133.8,84.36 131.32,81.87 129.99,81.87 127.01,78.9 123.83,78.9 123.5,78.57 122.9,78.57 122.27,77.94 115.89,77.94 114.97,77.01 114.12,77.01 112.09,74.98 112.09,74.01 105,66.93 105,57.33 89.35,41.68 89.27,41.68 87.86,40.27 85.78,40.27 83.18,37.68 83.18,36.88 80.58,34.28 72.2,34.28 69.94,32.02 47.2,32.02 44.75,34.47 35,34.47 33.95,33.42 19.56,33.42 18.72,32.58 16.86,32.58 15.72,33.72 14.65,33.72 14.39,33.98 14.39,34.27 v1(14.13,34.53)
  BOTTOM w0.076: U4555.BY9 172.21,71.87 v1(172.47,72.13)
  BOTTOM w0.119: CN2500.5 14.25,42.35 TP2504.1 14.07,41.76 14.27,41.76 14.51,41.51 14.51,34.92 v1(14.13,34.53)
USB30_RX2_DP_DB: length 21
  TOP w0.119: C9212.1 40.62,88.46 40.62,88.13 v2(40.41,87.92)
  L6 w0.127: v2(40.41,87.92) 40.62,87.71 40.62,85.45 39.33,84.15 39.33,82.44 39.98,81.79 39.98,78.49 42.26,76.21 43.16,76.21 45.39,73.98 45.39,73.77 v1(45.13,73.51)
  BOTTOM w0.119: v1(45.13,73.51) 45.39,73.25 45.39,72.72 45.25,72.58 CN9202.26
USB30_RX2_RE_DN_DB: length 18
  TOP w0.119: U9201.8 39.76,101.78 v1(39.98,102) ; CN9200.5 30.68,100.37 30.8,100.49 31.29,100.49 32.07,101.27 32.94,101.27 33.67,101.99 35.88,101.99 36.93,103.04 39.32,103.04 39.46,102.9 D9200.10 D9200.1 41.4,102.9 41.54,103.04 41.73,103.04 v1(41.99,102.78)
  L3 w0.109: v1(39.98,102) 39.9,102 39.53,102.37 39.53,102.71 40.01,103.2 41.57,103.2 v1(41.99,102.78)
USB30_RX2_RE_DP_DB: length 18
  TOP w0.119: U9201.9 39.16,101.35 39.16,101.85 v1(39.32,102) ; v1(41.99,103.52) 41.73,103.26 41.54,103.26 41.4,103.4 D9200.2 D9200.9 39.46,103.4 39.32,103.26 36.84,103.26 35.79,102.21 33.58,102.21 32.85,101.49 31.98,101.49 31.2,100.71 30.8,100.71 30.68,100.83 CN9200.6
  L3 w0.109: v1(39.32,102) 39.32,102.8 39.93,103.41 41.88,103.41 v1(41.99,103.52)
USB30_TX1_C_DN_DB: length 9
  TOP w0.119: C9222.2 39.82,70.7 v4(39.82,74.94) 39.82,76.22 41.04,77.44 41.04,77.9 41.18,78.04 U9203.20
USB30_TX1_C_DP_DB: length 8.9
  TOP w0.119: C9223.2 39.6,70.64 39.6,76.31 v4(40.16,76.87) 40.82,77.54 40.82,77.9 40.68,78.04 U9203.19
USB30_TX1_DN: length 208.3
  L6 w0.076: v1(171.98,79.89) 171.66,79.89 171.59,79.97 171.59,80.81 171.15,81.24 171.15,81.29 171.14,81.3
  L6 w0.127: v1(9.93,37.84) 9.98,37.78 9.98,36.35 10.1,36.22 12.01,36.22 12.53,36.74 14.63,36.74 14.93,36.44 24.56,36.44 25.2,35.8 26.89,35.8 27.67,36.58 44.83,36.58 45.75,35.66 45.95,35.46 47.71,35.46 48.67,34.51 59.43,34.51 60.24,33.69 66.64,33.69 68.38,35.43 70.8,35.43 71.92,36.56 76.65,36.56 79.69,39.6 81.42,39.6 100.03,58.21 100.81,58.21 103.45,60.85 103.45,67.57 110.45,74.57 110.45,75.6 115.18,80.33 116.26,80.33 120.37,84.45 128.21,84.45 130.81,87.05 143.49,87.05 144.3,86.24 144.3,86.23 144.74,85.79 153.43,85.79 156.77,82.45 169.99,82.45 171.14,81.3
  BOTTOM w0.076: v1(171.98,79.89) 172.17,79.7 172.43,79.7 172.6,79.53 172.6,78.18 172.38,77.96 172.38,77.56 172.54,77.4 172.55,77.25 172.55,77.04 172.52,76.94 172.52,76.73 172.55,76.63 172.55,76.38 172.45,76.14 172.39,76.08 172.39,75.48 U4555.CA4
  BOTTOM w0.119: v1(9.93,37.84) 9.72,38.04 9.72,38.44 TP2511.1 9.47,39.57 9.47,39.77 8.73,40.5 8.73,43.98 CN2500.16
USB30_TX1_DN_DB: length 5.6
  TOP w0.119: C9222.1 39.85,69.15 39.85,68.45 v2(40.08,68.21)
  BOTTOM w0.119: CN9202.15 39.75,71.42 39.61,71.28 39.61,69.7 39.85,69.46 39.85,68.45 v2(40.08,68.21)
USB30_TX1_DP: length 208.3
  L6 w0.076: v1(171.98,79.31) 171.98,79.36 171.61,79.73 171.59,79.73 171.42,79.9 171.42,80.74 171.03,81.13 170.99,81.13 170.97,81.14
  L6 w0.127: v1(9.49,37.4) 9.75,37.15 9.75,36.25 10.01,35.99 12.1,35.99 12.62,36.51 14.53,36.51 14.84,36.21 24.46,36.21 25.11,35.57 26.98,35.57 27.76,36.35 44.74,36.35 45.59,35.49 45.85,35.23 46.4,35.23 47.62,35.23 48.57,34.28 59.33,34.28 60.14,33.47 66.74,33.47 68.48,35.21 70.89,35.21 72.02,36.33 76.74,36.33 79.78,39.37 81.52,39.37 100.12,57.98 100.9,57.98 103.68,60.75 103.68,67.47 110.68,74.47 110.68,75.51 115.27,80.1 116.35,80.1 120.47,84.22 128.3,84.22 130.91,86.82 143.39,86.82 144.07,86.15 144.07,86.13 144.64,85.56 153.33,85.56 156.68,82.22 169.9,82.22 170.97,81.14
  BOTTOM w0.076: v1(171.98,79.31) 172.21,79.54 172.36,79.54 172.44,79.46 172.44,78.25 172.21,78.03 172.21,77.49 172.38,77.33 172.39,77.24 172.39,77.07 172.35,76.97 172.35,76.7 172.39,76.6 172.39,76.42 172.31,76.23 172.22,76.15 172.22,75.96 U4555.CA3
  BOTTOM w0.119: CN2500.17 8.25,43.42 8.51,43.15 8.51,40.41 9.24,39.68 9.24,39.48 9.5,39.22 9.5,38.95 TP2512.1 9.38,38.42 9.5,38.3 9.5,37.41 v1(9.49,37.4)
USB30_TX1_DP_DB: length 5.6
  TOP w0.119: C9223.1 39.62,69.15 39.62,68.5 v1(39.34,68.21)
  BOTTOM w0.119: v1(39.34,68.21) 39.62,68.5 39.62,69.37 39.39,69.6 39.39,71.28 39.25,71.42 CN9202.14
USB30_TX1_RE_C_DN_DB: length 15.1
  TOP w0.119: C9214.2 43.15,86.84 43.15,86.32 42.74,85.91 D9203.4 D9203.7 39.95,85.91 39.81,86.05 39.07,86.05 38.36,86.76 v4(36.75,86.76) 33.54,86.76 32.83,86.05 31.75,86.05 31.22,86.59 30.8,86.59 30.68,86.47 CN9201.8
USB30_TX1_RE_C_DP_DB: length 15.1
  TOP w0.119: C9215.2 42.66,87.02 42.87,86.81 42.87,86.72 42.93,86.65 42.93,86.41 42.65,86.13 42.17,86.13 41.89,86.41 D9203.5 D9203.6 39.95,86.41 39.81,86.27 39.17,86.27 v4(38.82,86.62) 38.46,86.98 v4(33.98,86.98) 33.44,86.98 32.74,86.27 31.85,86.27 31.31,86.81 30.8,86.81 30.68,86.93 CN9201.9
USB30_TX1_RE_DN_DB: length 8.6
  TOP w0.119: v2(43.22,88.86) 43,88.63 43,88.2 C9214.1 ; U9203.11 41.18,83.13 41.04,83.27 41.04,83.67 v1(41.23,83.86)
  L3 w0.109: v1(41.23,83.86) 41.01,84.07 41.01,85.87 43,87.85 43,88.64 v2(43.22,88.86)
USB30_TX1_RE_DP_DB: length 8.7
  TOP w0.119: U9203.12 40.68,83.13 40.82,83.27 40.82,83.62 v1(40.58,83.86) ; C9215.1 42.77,88.2 42.77,88.65 v1(42.56,88.86)
  L3 w0.109: v1(40.58,83.86) 40.8,84.07 40.8,85.95 42.78,87.94 42.78,88.64 v1(42.56,88.86)
USB30_TX2_C_DN_DB: length 8.4
  TOP w0.119: C9210.2 38.35,89.84 38.35,90.36 v3(38.83,90.84) 38.3,91.37 38.3,95.7 38.12,95.88 38.12,96.57 38.26,96.71 U9201.20
USB30_TX2_C_DP_DB: length 8.5
  TOP w0.119: C9209.2 38.13,89.86 38.13,90.27 v3(37.56,90.84) 38.08,91.37 38.08,95.61 37.9,95.79 37.9,96.57 37.76,96.71 U9201.19
USB30_TX2_DN: length 204.6
  L6 w0.127: v1(171.04,79.41) 170.96,79.49 169.22,79.49 167.15,81.56 156.4,81.56 153.06,84.9 143.65,84.9 143.1,85.45 140.94,85.45 140.52,85.02 133.53,85.02 132.07,83.56 120.74,83.56 116.62,79.44 115.54,79.44 111.34,75.23 111.34,74.88 111.34,74.2 104.34,67.2 104.34,59.28 102.38,57.32 100.4,57.32 82.02,38.95 82.02,38.68 80.94,37.6 79.74,37.6 77.82,35.67 72.29,35.67 72.04,35.42 72.04,35.31 69.41,32.68 47.47,32.68 44.46,35.69 35.13,35.69 34.06,34.62 27.49,34.62 27.35,34.76 22.02,34.76 21.56,35.22 14.45,35.22 13.81,35.85 12.98,35.85 12.8,35.68 12.8,35.45 v1(13.06,35.19)
  BOTTOM w0.076: v1(171.04,79.41) 171.22,79.59 171.37,79.59 171.43,79.53 171.43,78.5 171.86,78.07 171.86,77.01 172.07,76.8 172.07,76.57 U4555.CA2
  BOTTOM w0.119: CN2500.7 13.25,43.44 13.07,43.26 13.07,41 TP2505.1 13.1,39.91 13.1,38.03 12.46,37.38 12.46,37.04 12.82,36.68 12.82,35.43 v1(13.06,35.19)
USB30_TX2_DN_DB: length 20.2
  TOP w0.119: v1(38.55,87.89) 38.35,88.1 38.35,88.46 38.55,88.67 C9210.1
  L6 w0.127: v1(38.55,87.89) 38.31,87.65 38.31,86.22 37.99,85.89 37.99,79.87 42.08,75.78 42.46,75.78 44.11,74.12 44.11,73.77 v1(44.37,73.51)
  BOTTOM w0.119: CN9202.24 44.25,72.58 44.11,72.72 44.11,73.25 v1(44.37,73.51)
USB30_TX2_DP: length 204.6
  L6 w0.127: v1(171.04,80) 171.03,80 170.75,79.72 169.31,79.72 167.24,81.79 156.5,81.79 153.15,85.13 143.74,85.13 143.2,85.67 140.85,85.67 140.42,85.24 133.43,85.24 131.97,83.78 120.65,83.78 116.53,79.67 115.45,79.67 111.11,75.33 111.11,74.78 111.11,74.29 104.11,67.3 104.11,59.37 102.28,57.55 100.3,57.55 81.8,39.04 81.8,38.78 80.84,37.82 79.65,37.82 77.72,35.9 72.19,35.9 71.82,35.52 71.82,35.4 69.32,32.91 47.57,32.91 44.56,35.92 35.03,35.92 33.97,34.85 27.59,34.85 27.45,34.99 22.12,34.99 21.66,35.45 14.54,35.45 13.91,36.08 12.88,36.08 12.57,35.77 12.57,35.45 v1(12.32,35.2)
  BOTTOM w0.076: v1(171.04,80) 171.28,79.76 171.44,79.76 171.6,79.6 171.6,78.57 172.02,78.14 172.02,77.26 U4555.CA1
  BOTTOM w0.119: v1(12.32,35.2) 12.6,35.48 12.6,36.58 12.24,36.95 12.24,37.48 12.88,38.12 12.88,39.92 TP2506.1 12.85,40.93 12.85,43.32 12.75,43.42 CN2500.8
USB30_TX2_DP_DB: length 20.3
  TOP w0.119: C9209.1 37.92,88.67 38.13,88.46 38.13,88.15 v2(37.87,87.89)
  L6 w0.127: v2(37.87,87.89) 38.08,87.67 38.08,86.31 37.76,85.98 37.76,79.78 41.98,75.55 42.37,75.55 43.89,74.03 43.89,73.77 v1(43.63,73.51)
  BOTTOM w0.119: CN9202.23 43.75,72.58 43.89,72.72 43.89,73.25 v1(43.63,73.51)
USB30_TX2_RE_C_DN_DB: length 13.7
  TOP w0.119: CN9200.8 30.68,106.37 30.8,106.49 31.22,106.49 31.82,105.89 32.88,105.89 33.65,106.66 35.82,106.66 37.28,105.2 37.28,104.82 37.56,104.54 39.31,104.54 39.45,104.4 D9200.7 D9200.4 41.59,104.4 C9201.2
USB30_TX2_RE_C_DP_DB: length 13.7
  TOP w0.119: CN9200.9 30.68,106.83 30.8,106.71 31.31,106.71 31.91,106.11 32.79,106.11 33.56,106.88 35.91,106.88 37.5,105.29 37.5,104.91 37.65,104.76 39.38,104.76 39.52,104.9 D9200.6 D9200.5 41.59,104.9 C9202.2
USB30_TX2_RE_DN_DB: length 12.4
  TOP w0.119: U9201.11 38.26,101.8 38.12,101.94 38.12,102.31 v1(38.41,102.6) ; v1(43.56,106.73) 43.56,104.79 43.27,104.5 42.93,104.5 C9201.1
  L3 w0.109: v1(43.56,106.73) 43.29,106.46 43.29,106.19 41.94,104.84 40.75,104.84 40.01,104.11 38.89,104.11 38.17,103.39 38.17,102.84 v1(38.41,102.6)
USB30_TX2_RE_DP_DB: length 12.4
  TOP w0.119: U9201.12 37.76,101.8 37.9,101.94 37.9,102.29 v2(37.66,102.52) ; C9202.1 43.01,104.72 43.18,104.72 43.34,104.88 43.34,106.36 42.97,106.73 v1(42.81,106.73)
  L3 w0.109: v1(42.81,106.73) 43.08,106.46 43.08,106.28 41.86,105.05 40.66,105.05 39.93,104.32 38.8,104.32 37.96,103.48 37.96,102.82 v2(37.66,102.52)
USB_A_A_DE0: length 16.4
  TOP w0.102: U9201.16 36.5,99 36.3,99.2 34.42,99.2 v1(33.97,98.74) ; TP9200.1 v1(42.34,91.12)
  L3 w0.102: v1(42.34,91.12) 42.34,91.91 35.1,99.15 34.37,99.15 v1(33.97,98.74)
USB_A_A_DE1: length 2.7
  TOP w0.102: R9207.1 36.23,98 U9201.18 37.01,96.74 v3(36.78,96.51)
USB_A_A_EQ0: length 3
  TOP w0.102: v3(34.36,98.11) 34.55,98.29 35.55,98.29 R9210.2 36.25,98.5 U9201.17
USB_A_A_EQ1: length 16.5
  TOP w0.102: U9201.15 36.91,99.4 34.01,99.4 v1(33.36,98.74) ; TP9201.1 v1(42.34,93.16)
  L3 w0.102: v1(42.34,93.16) 41.38,93.16 35.18,99.35 33.97,99.35 v1(33.36,98.74)
USB_A_B_DE0: length 2
  TOP w0.102: R9212.2 42.25,98.49 41.74,99 U9201.3
USB_A_B_DE1: length 4.1
  TOP w0.102: U9201.6 41.23,100.5 41.88,101.16 v3(41.88,101.49) 42.33,101.49 42.74,101.07 R9214.2 R9203.1
USB_A_B_EQ0: length 2.2
  TOP w0.102: R9211.2 42.78,97.65 41.93,98.5 U9201.2
USB_A_B_EQ1: length 1.8
  TOP w0.102: U9201.4 41.53,99.5 41.65,99.38 R9213.2
USB_A_I2C_EN: length 3.5
  TOP w0.102: R9215.2 42.2,96.05 v3(41.4,96.05) 41.32,96.05 40.26,97.11 U9201.24
USB_A_REXT: length 2.9
  TOP w0.102: R9202.1 42.6,101.97 40.86,101.97 40.53,101.64 40.41,101.64 40.26,101.49 U9201.7
USB_A_TEST: length 1.1
  TOP w0.102: U9201.14 36.12,100 R9208.2
USB_B_A_DE0: length 12.4
  TOP w0.102: v1(39.16,80.23) 39.27,80.33 U9203.16 ; v1(38.24,70.39) 38.24,71.23 TP9204.1
  L3 w0.102: v1(38.24,70.39) 38.34,70.49 38.34,71.02 39.67,72.35 39.67,79.72 v1(39.16,80.23)
USB_B_A_DE1: length 4.8
  TOP w0.102: v3(37.91,77.21) R9224.1 37.91,78.05 R9222.2 38.52,78.32 39.52,78.32 39.93,78.74 U9203.18
USB_B_A_EQ0: length 2.8
  TOP w0.102: U9203.17 39.51,79.83 39.04,79.36 39.04,79.21 v3(38.81,78.98) 38.75,78.98 R9221.2
USB_B_A_EQ1: length 13.9
  TOP w0.102: TP9203.1 v1(37.65,69.71) ; U9203.15 39.16,80.83 38.73,80.41 38.73,79.8 v1(38.78,79.75)
  L3 w0.102: v1(37.65,69.71) 37.65,70.61 39.47,72.43 39.47,79.06 v1(38.78,79.75)
USB_B_B_DE0: length 6.1
  TOP w0.102: v3(47.95,77.56) 48.05,77.66 48.05,78.84 47.46,79.43 R9227.2 46.95,79.43 46.29,80.1 44.7,80.1 44.46,80.33 U9203.3
USB_B_B_DE1: length 4.4
  TOP w0.102: U9203.6 44.99,81.83 v3(45.06,81.9) 45.9,81.9 R9220.1 46.4,81.4 47.1,81.4 47.2,81.51 47.2,81.85 47.21,81.86 R9229.2
USB_B_B_EQ0: length 4.4
  TOP w0.102: v3(46.66,77.56) 46.48,77.74 46.48,78.97 R9226.2 45.62,79.83 U9203.2
USB_B_B_EQ1: length 2.1
  TOP w0.102: U9203.4 44.85,80.83 v3(45.06,80.63) 45.14,80.71 R9228.2
USB_B_I2C_EN: length 5.4
  TOP w0.102: U9203.24 43.19,78.57 R9225.2 45.02,77.87 46.5,76.39 v3(47.22,76.39)
USB_B_REXT: length 5.1
  TOP w0.102: U9203.7 43.34,82.74 R9219.1 45.26,83.45 45.57,83.45 45.8,83.69 45.8,84.02 v3(44.6,85.23)
USB_B_TEST: length 2.6
  TOP w0.102: R9223.2 38.35,80.71 v3(38.4,80.76) 38.79,81.15 39.23,81.15 39.41,81.33 U9203.14
USB_CHARGER_STATUS#: length 324.4
  TOP w0.102: R2513.2 v1(246.2,42.43) 246.38,42.61 R315.1 ; R2420.1 v1(254.22,30.99) ; U2501.9 v1(22.48,31.29)
  L5 w0.102: v1(22.48,31.29) 22.48,30.65 20.09,28.26 20.09,22.28 19.71,21.9 19.71,17.42 20.94,16.19 24.6,16.19 24.68,16.11 26.5,16.11 28.01,14.59 28.01,14.11 31.65,10.48 36.8,10.48 38.07,11.75 48.54,11.75 49.04,11.24 50.44,11.24 52.5,13.3 59.43,13.3 59.84,12.89 78.12,12.89 82.72,8.29 98.9,8.29 99.69,9.08 124.81,9.08 125.77,8.12 132.24,8.12 132.39,8.27 136.54,8.27 138.6,6.21 141.36,6.21 141.43,6.29 142.8,6.29 143.78,7.27 149.65,7.27 150.53,6.39 163.29,6.39 165.86,8.96 182.92,8.96 184.49,7.38 185.17,7.38 199.85,7.38 201.22,8.75 213.88,8.75 217.95,4.68 217.95,4.51 219.12,3.34 239.92,3.34 240.64,4.06 240.64,4.22 240.64,4.85 241.07,5.28 241.07,8.03 242.86,9.82 248.83,9.82 249.06,10.05 249.06,13.9 249.94,14.78 251.09,14.78 252.42,16.11 252.42,19.83 257.3,24.7 257.3,28.99 255.3,30.99 v1(254.22,30.99) 251.82,28.59 250.36,28.59 248.98,29.97 245.75,29.97 245.36,29.57 245.36,27.98 244.93,27.55 243.6,27.55 243.04,28.11 243.04,32.44 243.68,33.07 244.19,33.07 244.86,33.74 244.86,35.15 244.9,35.2 244.9,37.5 243.46,38.94 243.46,39.55 245.53,41.62 245.55,41.62 245.79,41.86 245.79,42.03 v1(246.2,42.43)
USB_CHARGER_STATUS#_PD: length 5.8
  TOP w0.076: U2403.L10 259.07,29.42 258.8,29.68 258.8,29.69 258.8,30 258.65,30.15
  TOP w0.102: v3(254.5,31.84) 254.8,31.84 R2420.2 255.8,30.84 257.96,30.84 258.65,30.15
USB_CHARGER_STATUS#_R: length 4
  TOP w0.076: R2513.1 244.45,42.43 243.31,41.29 242.3,41.29 242.28,41.31 242.27,41.31 241.97,41.61 U300.G2
USB_ID: length 1.2
  TOP w0.076: R4504.1 174.8,73.19 v1(175.23,72.76)
  BOTTOM w0.089: U4555.CE8 v1(175.23,72.76)
USB_P1_CH_DN: length 26.3
  TOP w0.119: v1(10.73,33.56) 10.95,33.78 11.67,33.78 11.77,33.88 15.62,33.88 16.92,32.59 19.89,32.59 21.18,31.3 21.18,29.95 21.48,29.65 U2501.11
  BOTTOM w0.119: v1(10.73,33.56) 11.38,33.56 11.86,34.04 11.86,36.73 11.81,36.77 11.81,39.58 11.63,39.77 11.63,41.46 TP2507.1 11.61,42.48 11.61,43.28 11.75,43.42 CN2500.10
USB_P1_CH_DP: length 26.3
  TOP w0.119: v1(10.73,34.22) 10.95,34 11.58,34 11.68,34.1 15.72,34.1 17.01,32.81 19.98,32.81 21.41,31.39 21.41,30.04 21.57,29.87 21.72,29.87 22,30.15 U2501.10
  BOTTOM w0.119: v1(10.73,34.22) 10.73,34.15 11.1,33.78 11.29,33.78 11.64,34.13 11.64,36.64 11.59,36.68 11.59,39.49 11.41,39.67 11.41,41.42 TP2508.1 11.39,42.49 11.39,43.28 11.25,43.42 CN2500.11
USB_P1_DN: length 189.1
  TOP w0.119: U2501.2 26.04,29.65 26.26,29.87 27.41,29.87 27.49,29.94 29.91,29.94 30.99,28.86 32.46,28.86 32.96,29.37 33.24,29.37 33.66,29.78 v1(33.75,29.78)
  L3 w0.109: v1(33.75,29.78) 33.65,29.78 33.28,29.41 33.28,29.24 33.6,28.92 34.97,28.92 36.82,30.77 44.77,30.77 45.35,31.35 68.41,31.35 71.45,34.38 72.39,34.38 73.95,35.94 75.96,35.94 77.81,37.79 92.75,37.79 97.01,42.06 101.39,42.06 101.93,42.6 113.33,42.6 116.74,46.01 116.74,54.53 122.02,59.81 122.02,61.42 128.03,67.42 141.46,67.42 142.8,68.77 146.35,68.77 146.77,68.35 152.83,68.35 153.02,68.16 165.83,68.16 168.62,70.96 171.86,70.96 173.02,72.12 173.02,74.95 176.65,78.58 176.65,79.07 176.59,79.13 v1(175.93,79.13)
  BOTTOM w0.076: U4555.CE3 174.57,75.66 174.64,75.59 174.77,75.59 174.84,75.66 174.84,75.84 174.84,75.84 174.84,76.02 174.91,76.2 175,76.39 175,76.64 174.95,76.78 174.95,76.91 174.97,76.98 174.98,77.01 175,77.07 175,78.9 175.68,79.58 175.9,79.58 176.09,79.39 176.09,79.28 v1(175.93,79.13)
USB_P1_DN_DB: length 41.1
  TOP w0.119: v1(33.93,104.43) 33.75,104.26 33.49,104.26 33.37,104.38 33.37,105.47 33.76,105.85 33.93,105.85 L9200.4
  L6 w0.127: v1(42.87,73.51) 42.82,73.51 42.51,73.82 42.51,74.41 36.1,80.82 36.1,91.06 37.48,92.44 37.48,101.45 36.58,102.35 36.58,103.46 35.99,104.05 34.3,104.05 33.93,104.42 v1(33.93,104.43)
  BOTTOM w0.119: v1(42.87,73.51) 42.61,73.25 42.61,72.72 42.75,72.58 CN9202.21
USB_P1_DP: length 189.2
  TOP w0.119: v1(33.07,29.78) 32.37,29.09 31.08,29.09 30,30.17 27.39,30.17 27.32,30.09 26.11,30.09 26.04,30.15 U2501.3
  L3 w0.109: v1(33.07,29.78) 33.07,29.15 33.51,28.71 35.06,28.71 36.91,30.56 44.86,30.56 45.43,31.14 68.5,31.14 71.54,34.17 72.48,34.17 74.04,35.73 76.04,35.73 77.9,37.58 92.84,37.58 97.1,41.85 101.48,41.85 102.02,42.39 113.42,42.39 116.95,45.92 116.95,54.44 122.23,59.72 122.23,61.33 128.12,67.21 141.54,67.21 142.88,68.55 146.27,68.55 146.68,68.14 152.74,68.14 152.93,67.95 165.91,67.95 168.71,70.75 171.95,70.75 173.23,72.03 173.23,74.87 176.86,78.49 176.86,79.16 v2(176.41,79.61)
  BOTTOM w0.076: U4555.CE4 174.42,75.48 174.3,75.69 174.3,76.02 174.48,76.19 174.73,76.19 174.83,76.43 174.83,76.61 174.78,76.75 174.78,76.94 174.83,77.07 174.84,77.09 174.84,78.97 175.61,79.74 175.97,79.74 176.1,79.61 v2(176.41,79.61)
USB_P1_DP_DB: length 41.2
  TOP w0.119: v1(33.93,103.82) 33.72,104.04 33.4,104.04 33.15,104.28 33.15,105.56 33.69,106.1 33.91,106.1 L9200.3
  L6 w0.127: v1(42.13,73.51) 42.28,73.67 42.28,74.31 35.87,80.73 35.87,91.15 37.25,92.53 37.25,101.36 36.35,102.26 36.35,103.36 35.89,103.82 v1(33.93,103.82)
  BOTTOM w0.119: v1(42.13,73.51) 42.39,73.25 42.39,72.72 42.25,72.58 CN9202.20
USB_P1_L_DN_DB: length 8.5
  TOP w0.119: L9200.1 34.58,105.75 34.7,105.87 34.85,105.87 34.99,106.01 35.07,106.01 35.19,105.89 35.19,105.56 35.02,105.38 34.9,105.38 34.82,105.3 34.82,104.83 D9201.10 D9201.1 34.91,103.34 35.03,103.22 35.03,102.98 34.91,102.86 33.84,102.86 32.99,103.71 32,103.71 31.88,103.83 31.88,104.3 CN9200.2
USB_P1_L_DP_DB: length 8.4
  TOP w0.119: L9200.2 35.16,106.23 35.41,105.98 D9201.9 D9201.2 35.41,103.34 35.25,103.18 35.25,102.89 35,102.64 33.75,102.64 32.89,103.49 32.3,103.49 32.18,103.37 CN9200.3
USB_P2_DN: length 73.9
  L6 w0.127: v1(220.89,101.38) 221.12,101.14 221.88,101.14 222.14,100.88 222.14,99.61 221.86,99.34 214.9,99.34 213.85,100.39 203.76,100.39 202.23,98.86 202.23,98.64 v1(202.56,98.31)
  BOTTOM w0.076: U4555.CE1 174.67,77.27 174.67,79.21 177.05,81.59 177.05,81.77 177.08,81.8 177.08,81.82
  BOTTOM w0.119: v1(220.89,101.38) 221.13,101.14 221.51,101.14 221.65,101.28 L3000.2 ; v1(202.56,98.31) 202.49,98.31 202.12,97.95 202.12,88.23 199.57,85.68 198.35,85.67 197.67,84.99 195.34,84.99 194.75,84.39 187.24,84.39 186.83,83.99 184.65,83.99 183.46,85.18 183.46,86.04 183.04,86.46 178.55,86.46 177.08,84.99 177.08,81.82
USB_P2_DP: length 74
  L6 w0.127: v1(201.9,98.31) 202,98.41 202,98.95 203.67,100.62 213.95,100.62 214.99,99.57 221.77,99.57 221.91,99.71 221.91,100.79 221.78,100.92 221.12,100.92 v1(220.89,100.68)
  BOTTOM w0.076: U4555.CE2 174.54,76.54 174.54,76.77 174.41,76.9 174.41,76.9 174.3,77.01 174.3,77.32 174.51,77.52 174.51,79.28 176.89,81.66 176.89,81.77 176.86,81.8 176.86,81.82
  BOTTOM w0.119: L3000.1 221.65,100.78 221.51,100.92 221.13,100.92 v1(220.89,100.68) ; 176.86,81.82 176.86,85.08 178.46,86.68 183.13,86.68 183.68,86.13 183.68,85.27 184.74,84.21 186.74,84.21 187.14,84.61 v4(193.67,84.61) 194.65,84.61 195.25,85.21 197.58,85.21 198.09,85.72 198.26,85.89 199.47,85.9 201.9,88.32 v1(201.9,98.31)
USB_P2_L_DN: length 2.6
  BOTTOM w0.119: L3000.3 222.89,101.28 223.03,101.14 223.69,101.14 223.72,101.11 224.11,101.11 224.25,101.25 CN3001.8
USB_P2_L_DP: length 2.6
  BOTTOM w0.119: CN3001.7 224.25,100.75 224.11,100.89 223.62,100.89 223.59,100.92 223.03,100.92 222.89,100.78 L3000.4
USB_P3_DN: length 172.5
  L3 w0.109: v1(63.9,11.94) 64.07,11.94 64.48,12.35 64.76,12.35 65.1,12.69 86.44,12.69 88.49,14.73 88.92,14.73 89.56,15.37 89.56,15.81 98.9,25.14 99.54,25.14 109.75,35.36 109.75,38.56 109.96,38.77 109.96,41.13 110.19,41.36 113.15,41.36 117.37,45.58 117.37,53.61 122.65,58.89 122.65,61.16 128.09,66.6 141.82,66.6 142.02,66.39 149.01,66.39 149.36,66.04 159.33,66.04 160.14,66.85 167.09,66.85 167.33,67.09 167.33,67.26 168.29,68.23 168.29,68.25 168.94,68.9 168.94,69.97 169.3,70.33 172.15,70.33 173.68,71.87 173.68,74.95 174.04,75.3 174.54,75.3 174.57,75.27 175.37,75.27 175.37,75.28 175.39,75.28 176.81,76.71 176.81,77.07 179.47,79.73 179.47,79.89 179.36,80 v1(178.86,80)
  BOTTOM w0.076: v1(178.86,80) 178.91,80.05 178.91,80.58 178.88,80.61 178.61,80.61 176.98,78.98 176.98,78.7 175.61,77.32 175.61,77.09 175.67,76.93 175.67,76.74 175.61,76.6 175.61,76.42 175.69,76.24 175.74,76.19 175.8,76.19 175.9,76.09 175.9,75.89 U4555.CG3
  BOTTOM w0.119: CN200.4 59.75,10.18 60,10.43 60,10.57 59.46,11.11 TP852.1 60.37,12.12 61.63,12.12 62.43,11.32 64.04,11.32 64.16,11.44 64.16,11.68 v1(63.9,11.94)
USB_P3_DP: length 172.5
  L3 w0.109: v1(64.65,11.94) 65.18,12.47 86.53,12.47 88.57,14.52 89.01,14.52 89.77,15.29 89.77,15.72 98.98,24.93 99.63,24.93 109.96,35.27 109.96,38.48 110.17,38.68 110.17,41.04 110.28,41.15 113.23,41.15 117.58,45.5 117.58,53.52 122.86,58.8 122.86,61.07 128.17,66.39 141.73,66.39 141.94,66.18 148.92,66.18 149.28,65.83 159.41,65.83 160.22,66.63 167.18,66.63 167.54,67 167.54,67.18 168.5,68.14 168.5,68.17 169.15,68.82 169.15,68.96 169.15,69.88 169.39,70.12 172.23,70.12 173.89,71.78 173.89,74.86 174.13,75.09 174.46,75.09 174.48,75.06 175.46,75.06 175.46,75.07 175.47,75.07 177.02,76.62 177.02,76.98 179.68,79.64 179.68,79.97 179.3,80.36 v1(179.3,80.43)
  BOTTOM w0.076: U4555.CG4 175.88,75.42 175.61,75.69 175.61,76.01 175.56,76.14 175.55,76.15 175.45,76.39 175.45,76.63 175.5,76.77 175.5,76.9 175.44,77.06 175.44,77.39 176.82,78.77 176.82,79.05 178.54,80.77 178.95,80.77 v1(179.3,80.43)
  BOTTOM w0.119: CN200.3 60.25,10.28 60.22,10.31 60.22,10.71 TP855.1 60.27,11.47 60.27,11.71 60.46,11.9 61.53,11.9 62.34,11.1 64.13,11.1 64.38,11.35 64.38,11.67 v1(64.65,11.94)
USB_P4_DN: length 222.5
  L3 w0.109: v1(8.23,35.74) 7.98,35.99 7.98,36.23 8.09,36.34 11.28,36.34 11.69,35.93 14.9,35.93 16.05,34.78 16.05,34.37 18.43,31.99 23.21,31.99 24.47,33.25 29.72,33.25 30.85,32.12 40.91,32.12 41.28,31.76 68.24,31.76 72.14,35.66 73.09,35.66 73.78,36.35 75.78,36.35 77.64,38.21 92.47,38.21 96.73,42.47 101.22,42.47 101.76,43.01 113.16,43.01 116.33,46.18 116.33,54.54 115.53,55.34 115.53,57.89 120.95,63.31 121.94,63.31 126.47,67.84 133.48,67.84 134.87,69.23 146.48,69.23 146.94,68.76 153,68.76 153.19,68.58 164.47,68.58 166.07,70.17 166.67,70.17 166.76,70.09 166.76,69.7 v1(166.72,69.67)
  L6 w0.127: v2(175.14,80.73) 175.15,80.74 175.15,81.27 175.05,81.37 174.85,81.37 174.29,80.81 174.29,75.27 173.88,74.86 173.88,71.93 172.1,70.14 168.09,70.14 167.82,69.87 167.5,69.87 167.32,69.69 166.75,69.69 v1(166.72,69.67)
  BOTTOM w0.076: U4555.CD3 174.04,76.15 174.15,76.15 174.3,76.3 174.3,76.71 174.14,76.87 174.14,77.38 174.24,77.49 174.24,77.61 174.14,77.71 174.14,77.86 174.24,77.96 174.24,78.12 174.14,78.22 174.14,78.37 174.24,78.47 174.24,78.58 174.14,78.68 174.14,78.8 174.26,78.93 174.26,79.03 174.14,79.16 174.14,79.29 174.22,79.37 174.22,79.48 174.14,79.57 174.14,79.71 174.2,79.77 174.2,79.92 174.34,80.06 174.34,80.17 174.2,80.3 174.2,80.48 174.91,81.19 175.1,81.19 175.17,81.13 175.17,80.75 v2(175.14,80.73)
  BOTTOM w0.119: CN2500.19 7.25,43.42 6.97,43.14 6.97,42.38 7.03,42.32 7.03,41.29 8.46,39.87 8.46,37.74 7.99,37.28 7.99,35.98 v1(8.23,35.74)
USB_P4_DN_DB: length 15.2
  TOP w0.119: v1(38.89,84.77) 38.63,84.51 38.41,84.51 38.2,84.72 38.2,84.73 38.11,84.82 L9201.4
  L3 w0.109: v1(38.89,84.77) 39.19,84.46 39.33,84.46 39.56,84.23 39.56,83.08 38.11,81.62 38.11,74.07 v1(38.23,73.95)
  BOTTOM w0.119: v1(38.23,73.95) 37.94,73.66 37.94,72.84 38.17,72.61 38.17,72.08 CN9202.12
USB_P4_DP: length 222.5
  L3 w0.109: v1(167.15,70.1) 167.04,70.1 166.76,70.38 165.98,70.38 164.38,68.79 153.28,68.79 153.09,68.97 147.03,68.97 146.57,69.44 134.78,69.44 133.4,68.05 126.38,68.05 121.85,63.52 120.86,63.52 115.32,57.98 115.32,55.25 116.12,54.46 116.12,46.26 113.07,43.22 101.67,43.22 101.14,42.68 96.65,42.68 92.38,38.42 77.55,38.42 75.7,36.56 73.69,36.56 73,35.87 72.05,35.87 68.15,31.97 41.36,31.97 41,32.33 30.94,32.33 29.81,33.47 24.39,33.47 23.12,32.2 18.52,32.2 16.26,34.46 16.26,34.87 14.99,36.14 11.77,36.14 11.37,36.55 8.01,36.55 7.77,36.31 7.77,35.89 7.77,35.88 v1(7.63,35.74)
  L6 w0.127: v1(167.15,70.1) 167.73,70.1 168,70.37 172.01,70.37 173.66,72.02 173.66,74.96 174.06,75.36 174.06,80.9 174.76,81.6 175.15,81.6 175.54,81.21 v1(175.62,81.21)
  BOTTOM w0.076: v1(175.62,81.21) 175.32,81.21 175.17,81.36 174.84,81.36 174.04,80.55 174.04,79.84 173.97,79.77 173.97,76.57 173.74,76.34 173.74,75.8 U4555.CD4
  BOTTOM w0.119: CN2500.20 6.75,42.29 6.81,42.22 6.81,41.2 8.24,39.77 8.24,37.83 7.77,37.37 7.77,35.88 v1(7.63,35.74)
USB_P4_DP_DB: length 15.2
  TOP w0.119: v1(38.89,84.02) 38.61,84.29 38.32,84.29 37.95,84.65 37.76,84.65 L9201.3
  L3 w0.109: v2(37.48,73.95) 37.64,73.95 37.89,74.2 37.89,81.7 39.35,83.16 39.35,84.14 39.24,84.25 39.12,84.25 v1(38.89,84.02)
  BOTTOM w0.119: CN9202.11 37.86,72.11 37.86,72.6 37.72,72.75 37.72,73.71 v2(37.48,73.95)
USB_P4_L_DN_DB: length 7.6
  TOP w0.119: L9201.1 37.66,85.46 37.47,85.46 37.44,85.49 37.42,85.49 37.26,85.65 D9202.10 D9202.1 34.74,85.65 34.6,85.51 34.34,85.51 33.89,85.06 33.89,84.4 33.3,83.81 32.3,83.81 32.18,83.93 CN9201.2
USB_P4_L_DP_DB: length 7.6
  TOP w0.119: L9201.2 37.38,85.22 37.16,85.43 36.96,85.43 36.59,85.06 36.24,85.06 D9202.9 D9202.2 34.74,85.15 34.6,85.29 34.43,85.29 34.11,84.97 34.11,84.31 33.39,83.59 32.3,83.59 32.18,83.47 CN9201.3
USB_P5_DN: length 151.6
  TOP w0.076: U2403.A7 260.74,24.16 260.74,24 259.77,23.03 259.73,23.03 259.71,23.02
  TOP w0.119: v1(248.83,17.94) 248.97,17.94 249.39,18.35 249.56,18.35 249.92,18.71 v4(252.8,18.71) 257.84,18.71 259.39,20.26 259.39,22.7 259.71,23.02
  L6 w0.076: 175.86,75.65 175.86,75.63 175.83,75.6 175.83,75.34 175.77,75.28 175.77,74.48 175.82,74.43 175.91,74.43 v1(176.15,74.67)
  L6 w0.127: v1(248.83,17.94) 248.97,17.94 249.38,18.36 249.65,18.36 250.2,18.9 250.2,22.18 249.11,23.27 249.11,29.75 250.62,31.27 251.25,31.27 252.16,32.18 252.16,41.1 251.89,41.36 251.89,45.04 246.85,50.09 246.85,53.33 240.51,59.67 234.33,59.67 228.42,65.58 228.42,67.62 228.42,68.55 222.06,74.92 222.06,80.09 220.83,81.32 216.79,81.32 216.44,80.98 213.03,80.98 212.69,81.32 210.64,81.32 206.43,81.32 206.04,81.7 196.98,81.7 196.04,82.64 195.6,82.64 194.66,83.58 183.36,83.58 178.7,78.92 178.09,78.92 175.86,76.69 175.86,75.65
  BOTTOM w0.076: U4555.CG5 175.76,74.39 175.99,74.39 176.15,74.56 v1(176.15,74.67)
USB_P5_DP: length 151.5
  TOP w0.076: 259.87,22.86 259.88,22.88 259.88,22.92 260.9,23.93 260.9,24.16 U2403.A6
  TOP w0.119: v1(249.56,17.94) 249.56,18.04 250.01,18.49 v4(254.71,18.49) 257.94,18.49 259.61,20.17 259.61,22.6 259.87,22.86
  L6 w0.076: v1(176.15,74.03) 175.91,74.27 175.75,74.27 175.61,74.41 175.61,75.35 175.66,75.4 175.66,75.6 175.63,75.63 175.63,75.65
  L6 w0.127: v1(249.56,17.94) 250.43,18.81 250.43,22.27 249.34,23.36 249.34,29.66 250.72,31.04 251.34,31.04 252.38,32.08 252.38,41.19 252.12,41.46 252.12,45.14 247.08,50.18 247.08,53.42 240.6,59.89 234.42,59.89 228.65,65.67 228.65,67.71 228.65,68.65 222.28,75.01 222.28,80.18 220.92,81.55 216.69,81.55 216.35,81.21 213.12,81.21 212.78,81.55 210.73,81.55 206.52,81.55 206.14,81.93 197.08,81.93 196.14,82.87 195.7,82.87 194.76,83.81 183.27,83.81 178.61,79.15 177.99,79.15 175.63,76.78 175.63,75.65
  BOTTOM w0.076: U4555.CG6 v1(176.15,74.03)
USB_P6_DN: length 133.2
  TOP w0.076: 256.73,27.24 256.78,27.24 256.85,27.16 258.29,27.16 258.29,27.16 258.4,27.16 U2403.G11
  TOP w0.119: 256.73,27.24 256.39,27.24 255.75,27.88 254.67,27.88 254.56,27.77 252.79,27.77 v1(252.52,28.04)
  L6 w0.127: v1(176.16,82.76) 176.16,82.69 176.52,82.33 178.23,82.33 180.37,84.47 195.16,84.47 195.7,83.94 198.07,83.94 199.41,82.59 206.41,82.59 206.79,82.21 211.01,82.21 211.01,82.21 213.05,82.21 213.4,81.87 216.08,81.87 216.42,82.21 221.19,82.21 222.95,80.46 222.95,75.28 229.31,68.92 229.31,65.94 234.7,60.56 240.88,60.56 247.74,53.7 247.74,50.45 252.78,45.41 252.78,41.73 253.08,41.43 253.08,29.78 252.07,28.77 252.07,27.93 252.19,27.8 252.4,27.8 252.52,27.93 v1(252.52,28.04)
  BOTTOM w0.076: U4555.CC1 173.64,77.37 173.64,80.72 174.71,81.78 174.71,81.82 174.72,81.84
  BOTTOM w0.119: v1(176.16,82.76) 176.16,82.68 175.87,82.4 175.29,82.4 174.72,81.84
USB_P6_DP: length 133.2
  TOP w0.076: U2403.F11 258.4,27 258.22,27 258.22,27 256.75,27 256.73,27.02
  TOP w0.119: 256.73,27.02 256.3,27.02 255.66,27.66 254.76,27.66 254.65,27.55 252.79,27.55 v1(252.52,27.29)
  L6 w0.127: v1(252.52,27.29) 252.52,27.42 252.37,27.57 252.1,27.57 251.84,27.83 251.84,28.86 252.85,29.88 252.85,41.33 252.55,41.64 252.55,45.32 247.51,50.36 247.51,53.6 240.78,60.33 234.6,60.33 229.08,65.85 229.08,68.83 222.72,75.19 222.72,80.36 221.1,81.98 216.51,81.98 216.17,81.64 213.3,81.64 212.96,81.98 210.91,81.98 206.7,81.98 206.32,82.36 199.32,82.36 197.97,83.71 195.6,83.71 195.07,84.24 180.47,84.24 178.32,82.1 v2(176.16,82.1)
  BOTTOM w0.076: U4555.CC2 173.81,76.88 173.81,80.65 174.83,81.67 174.87,81.67 174.88,81.68 174.88,81.68
  BOTTOM w0.119: 174.88,81.68 175.38,82.18 176.07,82.18 v2(176.16,82.1)
USB_P7_DN: length 134.2
  TOP w0.119: D2202.1 231.72,6.63 ; 231.72,6.63 231.73,6.63 231.9,6.47 232.23,6.47 232.35,6.35 232.35,6.09 232.59,5.84 234.2,5.84 v1(234.26,5.77) ; 231.72,6.63 231.96,6.87 232.22,6.87 232.34,6.99 232.34,7.34 232.6,7.6 235.52,7.6 236.51,8.59 240.28,8.59 244.3,12.61 244.3,17.59 238.94,22.95 238.23,22.95 233.52,27.66 233.52,29.95 233.4,30.07 233.2,30.07 v1(232.97,29.83)
  L6 w0.076: 179.46,71.33 179.37,71.33 179.33,71.3 177.31,71.3 176.7,71.92 176.7,72.4 176.53,72.58 176.34,72.58 v2(176.15,72.76)
  L6 w0.127: v1(232.97,29.83) 233.54,29.83 233.98,30.27 233.98,31.06 233.23,31.8 231.64,31.8 231.22,32.23 228.05,32.23 227.64,32.64 226.86,32.64 226.37,33.12 226.37,33.41 224.02,35.76 221.58,35.76 219.92,37.42 219.92,40.08 216.13,43.88 215.11,43.88 214.84,44.15 214.84,46.63 211.55,49.91 211.55,53.99 211.74,54.18 211.74,59.73 210.73,60.74 210.73,63.43 208.77,65.38 207.79,65.38 206.39,66.78 205.63,66.78 205.63,66.78 205.21,66.78 203.66,68.33 203.09,68.89 203.01,68.94 201.15,68.94 187.91,68.94 185.12,71.73 181.95,71.73 181.55,71.33 179.46,71.33
  BOTTOM w0.076: U4555.CG8 v2(176.15,72.76)
  BOTTOM w0.119: CN2200.6 235.83,7.8 235.83,5.72 235.65,5.53 235.21,5.53 234.97,5.77 v1(234.26,5.77)
USB_P7_DP: length 134.1
  TOP w0.119: v1(232.97,30.49) 233.17,30.29 233.5,30.29 233.74,30.04 233.74,27.75 238.32,23.17 239.03,23.17 244.52,17.68 244.52,12.52 240.37,8.37 236.6,8.37 235.62,7.38 232.69,7.38 232.56,7.25 232.56,7.02 232.68,6.9 232.88,6.9 233.09,6.68 D2201.1 233.09,6.58 233,6.49 232.69,6.49 232.57,6.37 232.57,6.18 232.69,6.06 233.88,6.06 v2(234.26,6.44)
  L6 w0.076: v1(176.15,72.08) 176.15,72.26 176.3,72.41 176.46,72.41 176.53,72.34 176.53,71.85 177.25,71.13 179.42,71.13 179.45,71.1 179.46,71.1
  L6 w0.127: 179.46,71.1 181.64,71.1 182.04,71.5 185.03,71.5 187.82,68.71 199.12,68.71 202.96,68.71 203.5,68.17 205.11,66.55 205.73,66.55 206.3,66.55 207.69,65.15 208.68,65.15 210.5,63.33 210.5,60.65 211.52,59.63 211.52,54.27 211.32,54.08 211.32,49.82 214.61,46.53 214.61,44.05 215.01,43.65 216.03,43.65 219.69,39.99 219.69,37.32 221.48,35.54 223.93,35.54 226.15,33.32 226.15,33.03 226.76,32.41 227.54,32.41 227.95,32 231.12,32 231.55,31.57 233.14,31.57 233.75,30.96 233.75,30.37 233.45,30.06 233.33,30.06 232.97,30.43 v1(232.97,30.49)
  BOTTOM w0.076: v1(176.15,72.08) 175.91,72.08 U4555.CG9
  BOTTOM w0.119: CN2200.5 235.15,7.78 235.15,7.27 235.27,7.15 235.49,7.15 235.61,7.03 235.61,6.8 235.48,6.66 235.48,6.5 235.61,6.36 235.61,5.87 235.49,5.75 235.3,5.75 235.06,5.99 234.63,5.99 234.26,6.36 v2(234.26,6.44)
USB_P9_DN: length 64.8
  L3 w0.076: 179.16,73.24 179.15,73.24 179.12,73.24 178.53,73.83 177.91,73.83 177.08,74.67 v2(177.07,74.67)
  L3 w0.109: v1(200.9,71.3) 200.7,71.5 200.7,71.74 199.82,72.62 198.69,72.62 198.45,72.38 198.45,70.51 198.69,70.27 202.25,70.27 202.36,70.17 202.36,69.96 202.25,69.85 198.14,69.85 198.03,69.96 198.03,71.93 197.8,72.16 197.42,72.16 197.19,71.93 197.19,69.97 197.08,69.86 196.87,69.86 196.76,69.97 196.76,72.69 196.53,72.92 195,72.92 194.77,72.69 194.77,70.02 194.66,69.91 194.46,69.91 194.35,70.02 194.35,72.54 194.11,72.77 193.73,72.77 193.5,72.54 193.5,70 193.39,69.89 193.19,69.89 193.08,70 193.08,71.93 192.85,72.16 186.52,72.16 186.06,72.61 183.41,72.61 183.24,72.79 180.71,72.79 180.48,72.56 180.48,71.14 180.37,71.03 180.17,71.03 180.06,71.14 180.06,72.34 179.16,73.24
  BOTTOM w0.076: U4555.CH5 v2(177.07,74.67)
  BOTTOM w0.119: R1406.2 202.41,63.74 202.41,65.43 201.77,66.07 201.77,68.21 201.58,68.39 201.58,69.05 200.9,69.73 v1(200.9,71.3)
USB_P9_DP: length 64.6
  L3 w0.076: v1(177.08,74.01) 177.17,74.1 177.41,74.1 177.84,73.67 178.46,73.67 179.01,73.13 179.01,73.09 179.01,73.09
  L3 w0.109: 179.01,73.09 179.85,72.25 179.85,71.05 180.08,70.82 180.46,70.82 180.69,71.05 180.69,72.47 180.8,72.58 183.15,72.58 183.32,72.4 185.98,72.4 186.43,71.95 192.76,71.95 192.87,71.84 192.87,69.91 193.1,69.68 193.48,69.68 193.71,69.91 193.71,72.45 193.82,72.56 194.03,72.56 194.14,72.45 194.14,69.93 194.37,69.7 194.75,69.7 194.98,69.93 194.98,72.6 195.09,72.71 196.44,72.71 196.55,72.6 196.55,69.89 196.78,69.65 197.16,69.65 197.4,69.89 197.4,71.84 197.51,71.95 197.71,71.95 197.82,71.84 197.82,69.87 198.05,69.64 202.34,69.64 202.57,69.87 202.57,70.25 202.34,70.49 198.77,70.49 198.67,70.59 198.67,72.3 198.77,72.41 199.73,72.41 200.49,71.65 200.49,71.5 v1(200.3,71.3)
  BOTTOM w0.076: U4555.CH6 v1(177.08,74.01)
  BOTTOM w0.119: v1(200.3,71.3) 200.32,71.3 200.68,70.93 v4(200.68,70.37) 200.68,69.64 201.36,68.96 201.36,68.3 201.55,68.11 201.55,65.98 202.19,65.34 202.19,63.98 201.9,63.69 R1405.2
USB_P9_R_DN: length 11.7
  BOTTOM w0.119: R1406.1 202.25,62.98 202.25,62.05 v4(201.93,61.73) 201.64,61.43 201.64,55.46 200.61,54.43 200.61,53.46 200.75,53.32 CN1400.9
USB_P9_R_DP: length 11.7
  BOTTOM w0.119: R1405.1 202.03,62.99 202.03,62.14 201.78,61.89 201.42,61.53 201.42,55.55 200.39,54.52 200.39,53.46 200.25,53.32 CN1400.7
USB_P10_C_DN: length 14.1
  BOTTOM w0.119: CN1300.5 70.01,17.75 69.73,17.47 69.5,17.47 69.24,17.73 69.24,18.38 69.48,18.62 69.48,18.97 69.24,19.22 69.24,19.86 69.46,20.08 69.46,20.32 69.24,20.54 69.24,22.29 71.11,24.16 71.77,24.16 71.96,24.16 72.2,24.4 72.2,24.68 73.06,25.54 73.06,25.81 73.2,25.95 73.4,25.95 73.52,26.07 73.52,26.27 73.74,26.49 73.97,26.49 74.09,26.37 R1339.1
USB_P10_C_DP: length 14.1
  BOTTOM w0.119: R1338.1 73.97,26.71 73.65,26.71 72.84,25.9 72.84,25.63 71.97,24.77 71.97,24.49 71.87,24.39 71.02,24.39 69.02,22.38 69.02,17.64 69.4,17.25 CN1300.3
USB_P10_DN: length 143.5
  L6 w0.127: v1(75.64,25.8) 75.65,25.8 76.07,25.38 76.36,25.38 76.64,25.1 84.48,25.1 92.01,32.62 92.01,33.61 102.38,43.98 113.38,43.98 116.79,47.39 116.79,54.2 120.93,58.34 120.93,59.03 127.98,66.08 131.8,66.08 135.07,69.35 161.99,69.35 162.16,69.19 165.46,69.19 167.22,70.94 167.77,70.94 167.99,70.72 169.13,70.72 169.19,70.79 171.75,70.79 172.46,71.49 172.73,71.49 173.1,71.87 173.1,75.1 173.43,75.43 173.43,80.88 173.12,81.19 173.12,82.08 173.25,82.21 173.4,82.21 v2(173.83,81.77)
  BOTTOM w0.076: 173.25,81.45 173.25,81.43 173.22,81.4 173.22,78.83 173.33,78.73 173.33,78.6 173.22,78.5 173.22,78.33 173.37,78.18 173.37,77.57 173.17,77.37 173.17,77.1 173.22,76.96 173.22,76.72 173.17,76.59 173.17,76.43 173.2,76.36 173.24,76.27 173.44,76.07 U4555.CC3
  BOTTOM w0.119: R1339.2 74.59,26.28 74.93,26.62 75.81,26.62 76.03,26.39 76.03,26.16 75.66,25.8 v1(75.64,25.8) ; v2(173.83,81.77) 173.65,81.96 173.64,81.96 173.55,82.04 173.37,82.04 173.25,81.92 173.25,81.45
USB_P10_DP: length 143.5
  L6 w0.127: v1(173.83,82.43) 173.16,82.43 172.89,82.17 172.89,81.09 173.2,80.78 173.2,75.52 172.87,75.2 172.87,71.96 172.64,71.72 172.37,71.72 171.66,71.01 169.1,71.01 169.03,70.95 168.08,70.95 167.87,71.17 167.12,71.17 165.37,69.41 162.25,69.41 162.09,69.58 134.98,69.58 131.7,66.31 127.88,66.31 120.7,59.12 120.7,58.44 116.56,54.3 116.56,47.49 113.28,44.21 102.28,44.21 91.78,33.71 91.78,32.72 84.39,25.33 76.73,25.33 76.26,25.8 v1(76.25,25.8)
  BOTTOM w0.076: 173.03,81.45 173.03,81.43 173.06,81.4 173.06,78.26 173.21,78.11 173.21,77.64 173,77.44 173,77.07 173.05,76.93 173.05,76.75 173,76.62 173,76.39 173.04,76.31 173.08,76.23 173.08,76.2 173.1,76.17 173.17,76.02 173.17,75.74 U4555.CC4
  BOTTOM w0.119: R1338.2 75.9,26.84 76.25,26.49 v1(76.25,25.8) ; v1(173.83,82.43) 173.66,82.26 173.28,82.26 173.03,82.01 173.03,81.45
USB_VBUSSENSE: length 2.7
  TOP w0.076: R4505.1 v3(173.86,75.38) 173.86,74.47 v1(174.29,74.03)
  BOTTOM w0.089: U4555.CC6 v1(174.29,74.03)
V_ADP_ADC4: length 19.1
  TOP w0.102: v3(246.73,25.21) 246.73,24.61 C68098.1 246.05,23.92 245.35,23.92 244.44,24.83 v1(243.94,24.83) ; v3(246.73,25.21) 245.99,25.21 R68094.1 ; v3(246.73,25.21) 246.73,25.27 R68095.2 ; R302.1 246.6,36.28 v1(246.71,36.39)
  L3 w0.102: v1(243.94,24.83) 245.13,26.02 245.13,29.61 246.61,31.09 246.61,36.28 v1(246.71,36.39)
VADPBL: length 11
  TOP w0.254: Q68103.3 259.47,97.21 259.97,96.71 259.97,94.4 258.85,93.28 256.05,93.28 255.04,94.3 253.87,94.3
  vias: v3(254.48,95.32)
VBIOS_SEL0: length 10.2
  BOTTOM w0.076: U4555.CP20 180.06,65.1 180.33,64.93 180.61,64.93 180.79,65.11 181.31,65.11 181.47,64.95 186.67,64.95 187.18,65.46 188,65.46
  BOTTOM w0.102: TP4523.1 189.42,65.46 188,65.46
VBIOS_SEL1: length 24.3
  L3 w0.076: v1(178,65.55) 178.65,65.55 178.72,65.62 180.51,65.62
  L3 w0.102: v1(200.1,64.23) 199.35,64.98 195.9,64.98 195.29,65.59 182.46,65.59 182.09,65.22 181.58,65.22 181.19,65.62 180.51,65.62
  BOTTOM w0.076: U4555.CK19 v1(178,65.55)
  BOTTOM w0.102: v1(200.1,64.23) 199.96,64.36 TP4524.1
VBIOS_SEL2: length 22.1
  L3 w0.076: v1(176.09,66.58) 176.47,66.96 178.16,66.96 178.68,66.44 180.51,66.44
  L3 w0.102: 180.51,66.44 182.09,66.44 182.33,66.19 195.92,66.19 v1(196.21,65.9)
  BOTTOM w0.089: v1(176.09,66.58) 176.07,66.64 U4555.CG17
  BOTTOM w0.102: v1(196.21,65.9) 195.8,66.32 TP4525.1
VGT_VCCSENSE: length 74.1
  TOP w0.13: v1(96.11,108.8) 96.11,108.55 R66819.2
  L3 w0.097: v1(131.08,86.4) 131.08,86.04 130.91,85.87 119.87,85.87 119.5,86.24 119.12,86.61 114.15,86.61 113.61,86.07 104.81,86.07 103.37,87.51 100.63,87.51 100.31,87.83 100.12,87.83 100.12,87.83 99.35,87.83 96.32,90.86 96.32,94.2 97.02,94.89 97.02,95.07 97.02,100.21 95.63,101.6 95.63,108.32 v1(96.11,108.8)
  BOTTOM w0.076: 137.36,77.63 137.7,77.29 137.7,77.04 137.52,76.86 137.4,76.86 137.25,76.71 137.25,76.37 137.44,76.19 137.72,76.19 U4555.E3
  BOTTOM w0.13: v1(131.08,86.4) 131.27,86.21 131.27,84.67 130.98,84.39 R4528.1 131.27,83.97 131.27,79.93 133.35,77.85 137.14,77.85 137.36,77.63
VGT_VSSSENSE: length 74.2
  TOP w0.13: R66821.2 95.57,108.73 v1(95.5,108.8)
  L3 w0.097: v1(95.5,108.8) 95.4,108.71 95.4,101.51 96.79,100.12 96.79,94.98 96.1,94.29 96.1,90.77 99.26,87.61 100.21,87.61 100.54,87.29 103.28,87.29 104.72,85.85 113.7,85.85 114.24,86.39 119.03,86.39 119.78,85.64 125.77,85.64 131.24,85.64 131.74,86.14 v2(131.74,86.4)
  BOTTOM w0.076: U4555.D2 137.94,76.87 138.16,76.87 138.33,77.04 138.33,77.28 137.58,78.04 136.73,78.04 136.7,78.07
  BOTTOM w0.13: v2(131.74,86.4) 131.74,86.36 131.53,86.14 131.53,84.65 131.79,84.39 R4529.1 131.53,84.04 131.53,80.03 133.49,78.07 136.7,78.07
VID0_VCC_PRIM: length 130.1
  TOP w0.102: R61403.2 180.85,98.24 v1(180.78,98.3) ; v1(209.37,40.2) 209.21,40.04 208.67,40.04 208.47,40.23 208.08,40.23 207.36,39.51 190.41,39.51 190.04,39.87 185,39.87 v3(183.94,40.93) R4889.2
  L5 w0.102: v1(209.37,40.2) 209.7,40.53 209.7,44.41 209.96,44.67 209.96,45.01 209.7,45.27 209.7,60.33 211.6,62.24 211.6,65.3 210.94,65.96 210.94,75.91 210.13,76.72 209.81,76.72 208.6,77.94 208.6,90.31 205.64,93.28 205.64,93.3 204.95,93.98 204.95,104.84 v1(205.36,105.25)
  L6 w0.102: v1(205.36,105.25) 205.36,104.01 198.57,97.22 195.29,97.22 192.92,99.58 182.95,99.58 181.67,98.3 v1(180.78,98.3)
  BOTTOM w0.102: U61400.4 180.48,97.21 180.78,97.51 v1(180.78,98.3) 181.15,98.67 R61424.1
VID0_VCCIO: length 3.5
  BOTTOM w0.102: U60500.4 103.71,56.13 103.45,56.39 103.32,56.39 102.64,57.08 R60524.1 102.62,57.29 v3(101.8,57.29) 101.16,57.29 R7008.2
VID1_VCC_PRIM: length 131.1
  TOP w0.102: v1(208.84,40.44) 208.83,40.44 208,40.44 207.27,39.71 190.49,39.71 190.13,40.08 185.61,40.08 183.58,42.1 R4890.2 ; v2(180.12,98.3) 180.21,98.3 180.61,97.9 180.89,97.9 R61404.2
  L5 w0.102: v1(208.84,40.44) 209.5,41.1 209.5,44.33 209.15,44.67 209.15,45.01 209.5,45.36 209.5,60.42 210.97,61.89 210.97,65.65 210.74,65.88 210.74,75.82 210.05,76.52 209.73,76.52 208.39,77.85 208.39,78.02 208.39,78.02 208.39,90.23 205.43,93.19 205.43,93.21 204.75,93.9 204.75,105.5 v1(204.92,105.68)
  L6 w0.102: v2(180.12,98.3) 180.21,98.3 180.61,97.9 181.56,97.9 183.04,99.38 192.84,99.38 195.2,97.02 198.65,97.02 205.76,104.13 205.76,105.42 205.52,105.65 205.5,105.68 v1(204.92,105.68)
  BOTTOM w0.102: U61400.3 179.96,97.71 180.17,97.92 180.17,98.25 v2(180.12,98.3)
VID1_VCCIO: length 5.5
  BOTTOM w0.102: U60500.3 103.21,56.24 102.64,56.81 100.89,56.81 R7007.2 99.91,57.22 99.91,57.22 R60525.1 98.93,56.53 v3(98.93,56.53)
VIDALERT#: length 10.4
  BOTTOM w0.076: U4555.AA3 147.76,75.9 147.98,76.42 147.98,76.61 147.93,76.75 147.83,76.86 147.61,76.86 147.45,77.01 147.45,79.73 146.33,80.86
  BOTTOM w0.13: 146.33,80.86 146.27,80.92 146.27,82.23 145.33,83.17 v3(145.33,84.16) R4596.1
VORTNA: length 4
  TOP w0.13: U66000.9 99.17,102.11 98.14,103.14 v3(98.14,103.7) 97.86,103.98 R66831.1
VORTNB: length 7.8
  TOP w0.13: R66821.1 95.52,107.3 95.52,102.66 97.22,100.96 U66000.13
VOSENA: length 3.8
  TOP w0.13: U66000.8 99.57,102.4 98.75,103.22 R66829.1
VOSENB: length 7.7
  TOP w0.13: U66000.12 97.56,101.05 96.61,101.99 95.78,102.83 95.78,106.16 v3(96.16,106.54) 96.16,107.05 R66819.1
VR_SVID_ALERT#: length 57.4
  TOP w0.13: v1(99.32,94.13) 99.57,94.38 U66000.29
  L3 w0.097: v1(145.38,86.4) 145.38,86.12 145.38,86.12 145.12,85.87 144.6,85.87 144.26,86.21 144.26,86.8 143.45,87.61 138.18,87.61 138.17,87.62 137.85,87.94 130.44,87.94 130.23,87.73 120.52,87.73 120.19,87.73 120.14,87.78 119.76,88.15 113.51,88.15 112.97,87.61 105.45,87.61 103.04,90.02 98.77,90.02 97.78,91 97.78,92.95 98.76,93.93 99.12,93.93 v1(99.32,94.13)
  BOTTOM w0.13: R4596.2 v1(145.38,86.4) R4594.1
VR_SVID_CLK: length 64.7
  TOP w0.13: R66102.1 v1(97.3,91.97) 97.15,91.82 R66101.2
  L3 w0.097: v2(146.04,86.4) 146.04,86.22 145.29,85.47 144.43,85.47 143.8,86.1 143.8,86.6 143.19,87.21 138.01,87.21 137.68,87.54 130.61,87.54 130.39,87.32 120.69,87.32 120.02,87.32 119.97,87.38 119.6,87.75 113.68,87.75 113.13,87.21 105.28,87.21 102.88,89.62 98.6,89.62 97.3,90.91 v1(97.3,91.97)
  BOTTOM w0.076: U4555.AA1 147.72,80.09 146.85,80.95
  BOTTOM w0.13: v2(146.04,86.4) 145.95,86.31 145.95,83.25 146.7,82.49 146.7,81.1 146.85,80.95
VR_SVID_DATA: length 63
  TOP w0.13: R66100.2 98.04,91.82 v1(98.19,91.97) R66103.1
  L3 w0.097: v2(144.72,86.4) 144.72,87.02 143.72,88.02 138.34,88.02 138.01,88.34 130.28,88.34 130.06,88.13 120.36,88.13 120.3,88.18 119.93,88.55 113.35,88.55 112.8,88.01 105.62,88.01 103.21,90.42 99.03,90.42 98.19,91.26 v1(98.19,91.97)
  BOTTOM w0.076: U4555.AA2 147.23,77 147.23,79.52 145.84,80.91
  BOTTOM w0.13: v2(144.72,86.4) 144.81,86.31 144.81,85.47 R4595.1 144.31,83.57 145.83,82.05 145.83,80.92 145.84,80.91
VRA1V5_FB: length 4.4
  BOTTOM w0.254: U61700.5 224.22,90.93 R61701.1 R61700.2 224.97,91.69 225.23,91.44 226.32,91.44 226.57,91.69 C61705.2
VRA1V05A_FB: length 3.9
  BOTTOM w0.254: U60900.11 168.38,100.42 v3(168.7,100.75) 168.88,100.57 R60901.1 169.54,100.64 C60920.2 169.61,101.49 R60900.2
VRA1V05A_FF: length 3.8
  BOTTOM w0.254: C60920.1 169.6,102.33 v3(170.38,102.33) 170.69,102.02 172.56,102.02 172.81,101.76 R60920.1
VRA1V05A_ILMT: length 3.5
  BOTTOM w0.254: R60905.1 168.7,102.47 v3(168.7,102.05) 168.1,101.44 168.1,101.07 167.91,100.87 U60900.10
VRA1V05A_SNB: length 1.9
  BOTTOM w0.254: v3(161.62,95.42) 161.67,95.36 C60916.1 R60916.2
VRA1V05A_VOUT: length 15.6
  L5 w0.254: v2(168.48,89.16) 170.15,90.84 170.15,97.36 170.82,98.04 170.82,98.63 172.49,100.29 v1(172.49,100.38)
  BOTTOM w0.254: R60900.1 R60920.2 171.96,100.91 v1(172.49,100.38) ; PAD60900.3 v2(168.48,89.16)
