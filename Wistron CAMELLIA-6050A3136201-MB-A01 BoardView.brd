# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_ESPI_<3>: length 117.8
  TOP w0.076: 176.35,53.45 175.95,53.45 174.44,54.97 173.09,54.97 R4849.2 ; v1(243.1,49.98) 243.51,49.57 243.51,49.16 243.11,48.76 243.11,46.75 242.93,46.57 242.93,44.66 242.48,44.21 U300.L1
  TOP w0.13: 176.35,53.45 183.59,53.45 185,54.86 186.39,54.86 187.17,55.64 187.47,55.64 188.08,56.26 188.76,56.26 188.86,56.36 196.93,56.36 197.07,56.51 199.88,56.51 200.25,56.14 201.08,56.14 201.68,55.55 203.37,55.55 203.73,55.19 v3(206.68,55.19) 215.34,55.19 215.8,55.65 215.8,56.87 216.1,57.16 216.22,57.28 216.22,58.37 216.96,59.12 216.96,59.12 217.26,59.41 219.99,59.41 220.58,60 220.58,62.44 220.88,62.74 220.88,62.74 222.35,64.21 230.49,64.21 233.3,61.4 233.3,60.31 234.2,59.4 236.18,59.4 238.55,57.03 238.55,56.62 239.15,56.02 239.15,54.46 240.04,53.57 240.74,52.86 241.15,52.86 242.1,51.92 242.1,51.68 243.1,50.67 v1(243.1,49.98)
  L6 w0.127: v1(246.17,33.42) 245.88,33.42 244.5,34.8 244.5,39.04 243.75,39.79 243.75,41.98 243.25,42.48 243.25,45.47 243.04,45.69 243.04,47.34 242.68,47.69 242.68,49.54 242.95,49.81 242.95,49.82 v1(243.1,49.98)
  BOTTOM w0.13: R358.1 250.63,32.48 248.36,32.48 247.67,33.17 247.51,33.33 246.28,33.33 246.19,33.42 v1(246.17,33.42)
LPC_ESPI_CLK: length 129.8
  TOP w0.076: R4850.2 171.98,54.8 174.13,54.8 175.92,53.01 ; U300.M1 242.45,46.56 242.78,46.88 242.78,47.83 242.67,47.94 242.67,49.75 v1(242.44,49.98)
  TOP w0.13: v1(242.44,49.98) 242.44,50.61 241.58,51.46 241.58,51.71 240.94,52.35 240.53,52.35 239.83,53.06 238.64,54.25 238.64,55.81 238.04,56.41 238.04,56.82 235.97,58.89 233.99,58.89 232.79,60.1 232.79,61.19 230.27,63.7 v3(227.5,63.7) 222.56,63.7 221.09,62.22 221.09,59.79 220.2,58.9 217.47,58.9 216.73,58.16 216.73,57.07 216.31,56.65 216.31,55.44 215.55,54.68 203.52,54.68 203.16,55.04 201.47,55.04 200.87,55.63 200.04,55.63 199.67,56 197.28,56 197.14,55.85 189.08,55.85 188.97,55.75 188.29,55.75 187.68,55.13 187.38,55.13 186.6,54.35 185.21,54.35 183.8,52.94 175.99,52.94 175.92,53.01
  L6 w0.127: v1(246.2,31.87) 245.99,31.87 245.35,32.5 245.35,33.16 243.42,35.09 243.42,35.72 242.92,36.22 242.92,37.4 242.75,37.57 242.75,45.26 242.53,45.48 242.53,47.13 241.84,47.81 241.84,49.62 242.2,49.98 v1(242.44,49.98)
  BOTTOM w0.13: v1(246.2,31.87) 246.3,31.77 246.41,31.77 247.38,30.8 248.65,30.8 250.59,28.86 251.34,28.86 251.88,29.39 253.22,29.39 253.91,30.08 253.91,30.08 254.33,30.49 254.43,30.49 255.55,31.61 255.55,33.88 255.55,34.76 255.3,35 CN375.11
LPC_ESPI_R_<0>: length 4.8
  BOTTOM w0.13: CN375.10 254.8,34.67 255.03,34.45 255.03,32.31 v3(254.89,32.17) 254.53,31.82 R319.2
LPC_ESPI_R_<1>: length 4
  BOTTOM w0.13: CN375.9 254.3,34.43 v3(254.3,34.43) 254.64,34.09 254.64,32.67 254.39,32.42 R323.2
LPC_ESPI_R_<2>: length 3.6
  BOTTOM w0.13: R340.2 252.78,32.53 v3(253.49,33.24) 253.78,33.53 253.78,34.65 253.8,34.67 CN375.8
LPC_ESPI_R_<3>: length 4.5
  BOTTOM w0.13: CN375.7 253.3,34.73 v3(253.01,34.43) 253.01,34.2 252.74,33.93 252.74,33.2 252.44,32.89 251.94,32.89 251.91,32.92 251.56,32.92 251.22,32.58 R358.2
LPC_ESPI_RESET#: length 127.6
  TOP w0.076: U300.K3 241.26,43.56 241.58,43.88 241.67,43.88 241.67,43.88 242.57,43.88 243.1,44.41 243.1,46.51 243.27,46.68 243.27,48.59 243.35,48.67 v1(243.94,48.67)
  TOP w0.13: R4806.1 172.5,61.16 v1(173.18,60.49)
  L3 w0.076: v1(173.18,60.49) 172.64,59.96 172.64,57.88 173.23,57.3 173.23,56.94 174.34,55.82 176.25,55.82 176.67,55.41 177.77,55.41 178.99,54.19
  L3 w0.097: v1(243.94,48.67) 241.9,48.67 241.27,49.29 240.84,49.29 240.55,49.29 240.06,49.79 235.77,49.79 235.16,49.17 231.48,49.17 231.28,48.98 223.23,48.98 222.94,48.69 218.6,48.69 217.56,49.73 216.19,49.73 215.43,50.49 210.18,50.49 207.84,52.84 206.58,52.84 202.25,52.84 202.18,52.91 201.55,52.91 200.84,52.21 197.76,52.21 197.14,52.83 196.91,53.07 196.91,53.07 196.43,53.54 193,53.54 191.66,54.88 188.16,54.88 187.46,54.18 187.1,54.18 187.02,54.09 187.02,53.84 187.11,53.75 187.36,53.75 187.46,53.65 187.46,53.49 187.36,53.39 179.79,53.39 178.99,54.19
  L6 w0.127: v1(246.2,31.26) 246.62,31.68 246.62,32.7 247,33.08 247,36.08 247.13,36.22 247.13,38.31 245.4,40.04 245.4,44.24 246.05,44.89 246.05,45.25 245.72,45.58 245.72,46.95 245.12,47.55 245.12,48.01 244.46,48.67 v1(243.94,48.67)
  BOTTOM w0.076: U4555.CA27 v1(173.18,60.49)
  BOTTOM w0.13: v1(246.2,31.26) 246.2,31.21 247.63,29.77 v3(248.21,29.77) 248.95,29.77 250.38,28.35 250.93,28.35 251.56,28.35 252.09,28.88 253.43,28.88 254.12,29.57 254.12,29.57 254.54,29.98 254.64,29.98 256.06,31.4 256.06,31.51 256.06,34.73 255.8,34.99 CN375.12
M_A_A_0: length 57.6
  L6 w0.117: v2(130.88,14.22) 130.98,14.22 131.19,14.42 131.19,14.63 130.99,14.82 130.78,14.82 130.18,14.21 129.41,14.21 129.25,14.38 128.21,14.38 128.09,14.5 128.09,14.8 128.21,14.93 129.16,14.93 129.28,15.04 129.28,15.28 129.16,15.39 128.3,15.39 128.19,15.51 128.19,21.65 128.41,21.87 128.41,22.45 133.68,27.72 134.27,27.72 146.44,39.89 146.44,43.67 146.85,44.08 146.85,46.53 146.97,46.65 147.19,46.65 v1(147.25,46.59)
  BOTTOM w0.076: v1(147.25,46.59) 146.81,47.03 146.81,48.62 148,49.8 148,51.77 148.14,51.92 148.14,52.25 148.75,52.85 148.75,53.5 148.61,53.63 148.61,54.24 148.72,54.35 U4555.AC37
  BOTTOM w0.16: CN4100.144 v2(130.88,14.22)
M_A_A_1: length 58.9
  L6 w0.117: v2(127.46,17.85) 127.46,17.67 127.33,17.54 127.16,17.54 127.04,17.66 127.04,23.09 127.71,23.75 128.63,23.75 143.53,38.65 143.69,38.65 143.81,38.53 143.98,38.53 144.14,38.69 144.14,38.86 144.02,38.98 144.02,39.14 144.19,39.31 144.35,39.31 144.47,39.19 144.64,39.19 144.8,39.36 144.8,39.52 144.68,39.64 144.68,39.81 144.85,39.97 145.01,39.97 145.13,39.85 145.3,39.85 145.46,40.02 145.46,40.18 145.34,40.3 145.34,40.47 145.67,40.79 145.67,40.99 145.55,41.11 145.49,41.11 145.37,41.22 145.37,41.46 145.49,41.57 145.55,41.57 145.67,41.69 145.67,41.92 145.55,42.04 145.49,42.04 145.37,42.16 145.37,42.39 145.49,42.51 145.55,42.51 145.67,42.63 145.67,42.86 145.55,42.98 145.49,42.98 145.37,43.09 145.37,43.33 145.49,43.44 145.55,43.44 145.67,43.56 145.67,43.78 146.35,44.45 146.35,45.24 146.23,45.36 146.17,45.36 146.05,45.48 146.05,45.71 146.17,45.83 146.23,45.83 146.35,45.94 146.35,46.18 146.23,46.3 146.17,46.3 146.05,46.41 146.05,46.65 146.17,46.76 146.23,46.76 146.35,46.88 146.35,48.18 146.46,48.29 146.7,48.29 146.82,48.41 146.82,48.63 146.69,48.76 146.12,48.76 146.01,48.88 146.01,49.76 146.19,49.94 146.42,49.94 146.56,49.8 146.56,49.42 146.71,49.27 146.98,49.27 147.27,48.99 v1(147.27,48.48)
  BOTTOM w0.076: v1(147.27,48.48) 148.16,49.37 148.16,51.7 148.31,51.85 148.31,52.18 148.91,52.78 148.91,53.57 148.78,53.7 148.78,54.17 148.98,54.38 148.98,54.65 148.88,54.83 148.88,55.02 U4555.AC36
  BOTTOM w0.16: CN4100.133 128.13,18.52 v2(127.46,17.85)
M_A_A_2: length 57.6
  L6 w0.117: v1(147.26,45.34) 147.31,45.3 147.31,44.07 146.82,43.58 146.82,39.65 134.35,27.19 134.19,27.19 134.08,27.3 133.91,27.3 133.75,27.13 133.75,26.97 133.86,26.86 133.86,26.69 133.69,26.53 133.53,26.53 133.36,26.69 133.2,26.69 133.03,26.52 133.03,26.36 133.2,26.2 133.2,26.03 133.03,25.86 132.87,25.86 132.7,26.03 132.54,26.03 132.37,25.86 132.37,25.7 132.53,25.53 132.53,25.37 132.37,25.2 132.2,25.2 132.04,25.37 131.88,25.37 131.71,25.2 131.71,25.03 131.87,24.87 131.87,24.71 131.71,24.54 131.54,24.54 131.38,24.7 131.22,24.7 131.05,24.54 131.05,24.37 131.21,24.21 131.21,24.05 131.05,23.88 130.88,23.88 130.72,24.04 130.55,24.04 130.39,23.88 130.39,23.71 130.55,23.55 130.55,23.38 130.43,23.27 129.77,23.27 128.9,22.4 128.9,21.81 128.57,21.48 128.57,17.09 v2(128.6,17.06)
  BOTTOM w0.076: 146.76,45.85 146.54,46.07 146.54,48.58 147.83,49.87 147.83,51.85 147.98,52 147.98,52.32 148.58,52.92 148.58,53.43 148.54,53.47 148.54,53.47 148.45,53.57 148.45,54.59 148.5,54.74 148.5,54.98 148.46,55.09 148.46,56.22 U4555.AC34
  BOTTOM w0.16: v2(128.6,17.06) 128.24,16.7 128.23,16.66 128.17,16.32 127.92,14.31 127.88,13.96 CN4100.132 ; 146.76,45.85 v1(147.26,45.34)
M_A_A_3: length 57.5
  L6 w0.117: v1(147.25,47.29) 147,47.55 146.73,47.55 146.61,47.43 146.61,44.33 146.05,43.77 146.05,40.05 143.98,37.97 143.81,37.97 143.69,38.09 143.52,38.09 143.36,37.93 143.36,37.76 143.48,37.64 143.48,37.47 143.31,37.31 143.15,37.31 143.03,37.43 142.86,37.43 142.7,37.26 142.7,37.1 142.82,36.98 142.82,36.81 142.65,36.65 142.49,36.65 142.37,36.77 142.2,36.77 142.04,36.6 142.04,36.44 142.16,36.32 142.16,36.15 141.99,35.99 141.83,35.99 141.71,36.11 141.54,36.11 141.38,35.94 141.38,35.78 141.5,35.66 141.5,35.49 141.33,35.32 141.17,35.32 141.04,35.45 140.88,35.45 140.71,35.28 140.71,35.11 140.83,34.99 140.83,34.83 140.67,34.66 140.5,34.66 140.38,34.78 140.22,34.78 140.05,34.62 140.05,34.45 140.17,34.33 140.17,34.17 140.01,34 139.84,34 139.72,34.12 139.56,34.12 139.39,33.96 139.39,33.79 139.51,33.67 139.51,33.51 139.35,33.34 139.18,33.34 139.06,33.46 138.9,33.46 138.73,33.3 138.73,33.13 138.85,33.01 138.85,32.84 138.68,32.68 138.52,32.68 138.4,32.8 138.23,32.8 138.07,32.63 138.07,32.47 138.19,32.35 138.19,32.18 138.02,32.02 137.86,32.02 137.74,32.14 137.57,32.14 137.41,31.97 137.41,31.81 137.53,31.69 137.53,31.52 137.36,31.36 137.2,31.36 137.08,31.48 136.91,31.48 136.75,31.31 136.75,31.15 136.87,31.03 136.87,30.86 136.7,30.69 136.54,30.69 136.41,30.82 136.25,30.82 136.08,30.65 136.08,30.48 136.2,30.36 136.2,30.2 136.04,30.03 135.87,30.03 135.75,30.15 135.59,30.15 135.42,29.99 135.42,29.82 135.54,29.7 135.54,29.54 135.38,29.37 135.21,29.37 135.09,29.49 134.93,29.49 134.76,29.33 134.76,29.16 134.88,29.04 134.88,28.88 134.72,28.71 134.55,28.71 134.43,28.83 134.27,28.83 134.1,28.67 134.1,28.5 134.22,28.38 134.22,28.21 134.11,28.1 133.52,28.1 128.76,23.35 127.84,23.35 127.46,22.96 127.46,21.67 127.58,21.55 127.64,21.55 127.75,21.44 127.75,21.2 127.64,21.09 127.58,21.09 127.46,20.97 127.46,20.74 127.58,20.62 127.64,20.62 127.75,20.5 127.75,20.27 127.64,20.15 127.58,20.15 127.46,20.03 127.46,19.33 v2(127.46,19.32)
  BOTTOM w0.076: v1(147.25,47.29) 148.33,48.36 148.33,51.59 148.47,51.74 148.47,52.11 149.08,52.71 149.08,53.64 148.94,53.77 148.94,54.1 149.15,54.31 149.15,54.69 149.05,54.87 149.05,55.5 U4555.AC35
  BOTTOM w0.16: CN4100.131 127.63,19.49 v2(127.46,19.32)
M_A_A_4: length 57
  L6 w0.089: v2(145.61,47.29) 145.61,45.17 144.32,43.88
  L6 w0.117: v1(127.11,15.18) 127.11,14.85 127.23,14.73 127.54,14.73 127.66,14.61 127.66,14.38 127.54,14.26 127.23,14.26 127.11,14.14 127.11,14.11 126.99,13.99 126.46,13.99 126.28,14.17 126.28,16.36 126.28,16.37 126.28,23.09 126.28,23.41 127.39,24.52 128.29,24.52 144.07,40.3 144.07,43.64 144.32,43.88
  BOTTOM w0.076: v2(145.61,47.29) 146.04,47.69 146.04,48.79 147.33,50.08 147.33,52.06 147.48,52.22 147.48,53.37 147.72,53.6 147.72,54.52 147.64,54.74 147.64,54.98 147.68,55.09 147.68,55.27 147.64,55.39 147.64,55.61 U4555.AA35
  BOTTOM w0.16: v1(127.11,15.18) 127.11,14.08 126.88,13.85 CN4100.128
M_A_A_5: length 58.5
  L6 w0.117: v1(143.97,45.88) 143.76,45.88 141.62,43.74 141.62,41.1 137.05,36.53 136.15,36.53 123.26,23.65 123.26,17.74 123.48,17.53 123.48,16.98 123.65,16.8 123.65,14.46 123.97,14.13 125.59,14.13 125.87,14.41 v1(125.87,14.68)
  BOTTOM w0.076: U4555.AB35 148.17,55.41 148.33,54.95 148.33,54.77 148.28,54.61 148.28,53.5 148.41,53.37 148.41,52.98 147.81,52.39 147.81,52.07 147.66,51.92 147.66,49.94 146.37,48.65 146.37,46.92 146.15,46.69
  BOTTOM w0.16: v1(125.87,14.68) 126.38,14.17 CN4100.126 ; v1(143.97,45.88) 145.33,45.88 146.15,46.69
M_A_A_6: length 58
  L6 w0.089: v1(145.61,48.55) 145.77,48.55 146.07,48.24 146.07,47.13 145.84,46.9 145.84,44.92
  L6 w0.117: v2(127.46,16.43) 127.36,16.43 127.15,16.22 127.15,15.72 127.04,15.6 126.78,15.6 126.67,15.72 126.67,16.56 126.78,16.68 126.91,16.68 127.03,16.79 127.03,17.03 126.91,17.14 126.78,17.14 126.66,17.26 126.66,23.25 127.55,24.14 128.45,24.14 144.99,40.67 144.99,40.8 144.87,40.92 144.61,40.92 144.49,41.03 144.49,41.27 144.61,41.38 144.87,41.38 144.99,41.5 144.99,41.73 144.87,41.85 144.61,41.85 144.49,41.97 144.49,42.2 144.61,42.32 144.87,42.32 144.99,42.44 144.99,42.67 144.87,42.79 144.61,42.79 144.49,42.9 144.49,43.14 144.61,43.25 144.87,43.25 144.99,43.37 144.99,44.2 145.23,44.45 145.4,44.45 145.54,44.3 145.71,44.3 145.87,44.46 145.87,44.63 145.77,44.74 145.77,44.85 145.84,44.92
  BOTTOM w0.076: v1(145.61,48.55) 145.61,48.64 146.02,49.05 146.02,49.17 147.15,50.31 147.15,52.12 147.32,52.29 147.32,53.44 147.52,53.64 147.52,54.43 U4555.AA37
  BOTTOM w0.16: v2(127.46,16.43) 126.51,17.38 126.51,20.71 CN4100.127
M_A_A_7: length 58.3
  L6 w0.089: v1(145.61,49.18) 145.22,48.79 145.22,45.16 144.18,44.12
  L6 w0.117: 144.18,44.12 143.68,43.62 143.68,40.45 131.46,28.23 131.29,28.23 131.01,28.51 130.85,28.51 130.68,28.34 130.68,28.18 130.96,27.9 130.96,27.73 130.8,27.57 130.63,27.57 130.35,27.85 130.19,27.85 130.02,27.68 130.02,27.52 130.3,27.24 130.3,27.07 130.14,26.9 129.97,26.9 129.69,27.19 129.52,27.19 129.36,27.02 129.36,26.86 129.64,26.57 129.64,26.41 129.47,26.24 129.31,26.24 129.03,26.52 128.86,26.52 128.7,26.36 128.7,26.19 128.98,25.91 128.98,25.75 128.81,25.58 128.65,25.58 128.37,25.86 128.2,25.86 128.04,25.7 128.04,25.53 128.32,25.25 128.32,25.09 128.13,24.9 127.23,24.9 125.86,23.53 125.86,18.94 125.66,18.74 125.66,18.53 125.86,18.33 125.86,18.15 125.74,18.03 125.7,18.03 125.58,17.91 125.58,17.68 125.7,17.56 125.74,17.56 125.86,17.45 125.86,17.21 125.74,17.1 125.7,17.1 125.58,16.98 125.58,16.75 125.7,16.63 125.74,16.63 125.87,16.5 v1(125.87,16.17)
  BOTTOM w0.076: U4555.AA36 147.42,55.13 147.16,54.65 147.16,54.38 147.36,54.17 147.36,53.72 147.15,53.52 147.15,52.37 146.99,52.2 146.99,50.81 v3(146.33,50.15) 146.33,49.9 v1(145.61,49.18)
  BOTTOM w0.16: CN4100.122 125.38,15.68 v1(125.87,16.17)
M_A_A_8: length 57.3
  L6 w0.089: 143.74,45.1 144.38,45.74 144.38,46.73 v1(143.97,47.13)
  L6 w0.117: 143.74,45.1 143.43,45.1 142,43.67 142,40.94 137.21,36.15 136.31,36.15 123.65,23.49 123.65,17.9 123.86,17.68 123.86,17.14 124.13,16.86 124.62,16.86 v1(124.73,16.97)
  BOTTOM w0.076: U4555.AB34 147.8,55.89 147.8,55.42 147.85,55.3 147.85,55.07 147.8,54.95 147.8,54.77 147.89,54.55 147.89,53.54 147.65,53.3 147.65,52.14 147.5,51.99 147.5,50.01 146.21,48.72 146.21,47.25 145.8,46.83 144.27,46.83 v1(143.97,47.13)
  BOTTOM w0.16: CN4100.125 126.13,20 126.1,19.97 126.1,18.34 v1(124.73,16.97)
M_A_A_9: length 57.6
  L6 w0.089: 143.75,44.86 143.88,44.86 144.58,45.56 144.58,47.53 144.33,47.78 v1(143.97,47.78)
  L6 w0.117: 143.75,44.86 142.39,43.5 142.39,40.78 137.08,35.48 136.92,35.48 136.64,35.76 136.47,35.76 136.31,35.6 136.31,35.43 136.59,35.15 136.59,34.99 136.42,34.82 136.26,34.82 135.98,35.1 135.81,35.1 135.65,34.94 135.65,34.77 135.93,34.49 135.93,34.33 135.83,34.23 134.93,34.23 131.11,30.41 131.11,30.25 131.21,30.14 131.21,29.98 131.05,29.81 130.88,29.81 130.78,29.91 130.62,29.91 124.03,23.33 124.03,21.75 124.15,21.63 124.49,21.63 124.62,21.5 124.62,21.28 124.5,21.16 124.15,21.16 124.03,21.05 124.03,20.81 124.15,20.69 124.49,20.69 124.62,20.56 124.62,20.34 124.5,20.23 124.15,20.23 124.03,20.11 124.03,19.88 124.15,19.76 124.27,19.76 124.39,19.64 124.39,19.41 124.27,19.29 124.15,19.29 124.03,19.18 124.03,18.94 124.15,18.83 124.17,18.83 124.29,18.71 124.29,18.47 124.17,18.36 124.15,18.36 124.03,18.24 124.03,18.06 124.24,17.84 124.24,17.51 124.4,17.36 124.56,17.36 124.73,17.52 v1(124.73,17.78)
  BOTTOM w0.076: v1(143.97,47.78) 145.06,48.87 145.06,51.51 146.26,52.72 146.26,54.17 146.47,54.38 146.47,54.65 146.37,54.83 146.37,55.02 U4555.W36
  BOTTOM w0.16: CN4100.121 125.13,19.6 125.25,19.47 125.25,18.31 v1(124.73,17.78)
M_A_A_10: length 56.9
  L6 w0.076: v1(146.74,57.95) 146.38,57.58 146.38,57.06 146.42,57.01 146.42,56.72
  L6 w0.089: 146.42,56.72 146.42,56.02 148.63,53.81 150.16,50.13 150.16,45.11
  L6 w0.117: 150.16,45.11 150.08,44.89 149.94,44.6 149.89,44.47 149.89,37.45 135.68,23.24 135.68,22.58 132.69,19.58 132.69,15.57 132.5,15.38 131.73,15.38 131.57,15.23 131.57,14.2 131.77,14 132.07,14 v2(132.26,14.19)
  BOTTOM w0.076: U4555.Y31 v1(146.74,57.95)
  BOTTOM w0.16: CN4100.146 133.38,13.08 v2(132.26,14.19)
M_A_A_11: length 55.5
  L6 w0.089: v1(145.61,50.37) 144.96,49.72 144.96,45.27 143.4,43.71
  L6 w0.117: 143.4,43.71 143.29,43.6 143.29,40.6 131.73,29.04 130.83,29.04 125.47,23.69 125.47,19.09 125.19,18.81 125.19,15.25 125.05,15.1 124.72,15.1 124.6,15.22 124.6,15.44 v1(124.73,15.57)
  BOTTOM w0.076: v1(145.61,50.37) 145.25,50.73 145.25,51.46 146.43,52.64 146.43,54.1 146.63,54.31 146.63,54.69 146.53,54.87 146.53,55.47 146.47,55.54 146.47,56.01 146.2,56.28 U4555.W34
  BOTTOM w0.16: CN4100.120 124.88,15.44 v1(124.73,15.57)
M_A_A_12: length 57.4
  L6 w0.089: 143.27,43.95 144.78,45.45 144.78,50.69 145.05,50.96 v1(145.63,50.96)
  L6 w0.117: 143.27,43.95 142.84,43.52 142.84,40.7 135.71,33.56 135.54,33.56 135.26,33.85 135.09,33.85 134.93,33.68 134.93,33.52 135.21,33.23 135.21,33.07 135.04,32.9 134.88,32.9 134.59,33.19 134.43,33.19 134.26,33.02 134.26,32.85 134.55,32.57 134.55,32.4 134.38,32.24 134.22,32.24 133.93,32.52 133.77,32.52 133.6,32.36 133.6,32.19 133.89,31.91 133.89,31.74 133.72,31.58 133.56,31.58 133.27,31.86 133.11,31.86 132.94,31.7 132.94,31.53 133.23,31.25 133.23,31.08 133.06,30.92 132.9,30.92 132.61,31.2 132.45,31.2 132.28,31.04 132.28,30.87 132.56,30.59 132.56,30.42 132.4,30.25 132.23,30.25 131.95,30.54 131.78,30.54 131.62,30.37 131.62,30.21 131.9,29.92 131.9,29.76 131.57,29.43 130.67,29.43 124.41,23.17 124.41,22.3 125.09,21.62 125.09,20.23 124.97,20.11 124.95,20.11 124.83,19.99 124.83,19.76 124.95,19.64 125.01,19.64 125.09,19.56 125.09,19.25 124.97,19.14 v2(124.73,19.14)
  BOTTOM w0.076: U4555.AA34 147.25,56.32 147.25,56.09 147.16,55.99 147.16,54.99 146.99,54.69 146.99,54.31 147.19,54.1 147.19,53.79 146.99,53.58 146.99,52.44 146.79,52.24 146.79,50.88 146.65,50.75 145.85,50.75 v1(145.63,50.96)
  BOTTOM w0.16: v2(124.73,19.14) 124.63,19.24 CN4100.119
M_A_A_13: length 58.9
  L6 w0.089: v1(148.57,57.31) 148.57,56.32 151.94,52.96 151.94,47.05
  L6 w0.117: 151.94,47.05 151.94,45.4 151.67,45.13 151.67,43.74 151.66,43.74 151.66,35.36 147.91,31.6 147.75,31.6 147.51,31.84 147.34,31.84 147.18,31.68 147.18,31.51 147.42,31.27 147.42,31.11 147.25,30.94 147.09,30.94 146.82,31.2 146.66,31.2 146.49,31.04 146.49,30.87 146.75,30.61 146.75,30.45 146.59,30.28 146.42,30.28 146.09,30.61 145.93,30.61 145.76,30.45 145.76,30.28 146.09,29.95 146.09,29.79 145.96,29.65 144.27,29.65 137.84,23.23 137.84,22.54 137.66,22.36 137.22,21.92 134.42,19.12 134.42,16.37 v2(134.87,15.89)
  BOTTOM w0.076: U4555.AC32 v1(148.57,57.31)
  BOTTOM w0.16: CN4100.158 136.44,12.44 136.44,14.32 v2(134.87,15.89)
M_A_A_14: length 58.8
  L6 w0.089: v1(148.57,57.95) 149,57.51 149,57.15 150.9,55.25 150.9,54.26 152.16,53 152.16,45.34
  L6 w0.117: v2(134.86,18.87) 134.95,18.95 134.95,19.1 138.38,22.54 138.38,22.7 138.23,22.86 138.23,23.02 138.39,23.19 138.56,23.19 138.71,23.03 138.88,23.03 139.04,23.2 139.04,23.36 138.86,23.54 138.86,23.71 139.03,23.87 139.2,23.87 139.37,23.69 139.54,23.69 139.7,23.86 139.7,24.02 139.53,24.2 139.53,24.37 139.69,24.53 139.86,24.53 140.03,24.36 140.2,24.36 140.36,24.52 140.36,24.69 140.19,24.86 140.19,25.03 140.35,25.19 140.52,25.19 140.69,25.02 140.86,25.02 141.03,25.18 141.03,25.35 140.85,25.52 140.85,25.69 141.01,25.85 141.18,25.85 141.36,25.68 141.52,25.68 141.69,25.84 141.69,26.01 141.51,26.19 141.51,26.35 141.68,26.52 141.84,26.52 142.1,26.25 142.27,26.25 142.43,26.42 142.43,26.58 142.17,26.85 142.17,27.01 142.34,27.18 142.5,27.18 142.77,26.91 142.93,26.91 143.1,27.08 143.1,27.25 142.83,27.51 142.83,27.67 143,27.84 143.16,27.84 143.45,27.56 143.61,27.56 143.78,27.72 143.78,27.89 143.49,28.17 143.49,28.33 143.66,28.5 143.82,28.5 144.1,28.22 144.27,28.22 144.43,28.39 144.43,28.55 144.16,28.83 144.16,29 144.32,29.16 144.49,29.16 144.66,28.99 144.83,28.99 145.11,29.27 146.12,29.27 152.05,35.2 152.05,43.74 152.16,43.86 152.16,45.34
  BOTTOM w0.076: U4555.AC31 v1(148.57,57.95)
  BOTTOM w0.16: CN4100.151 134.63,19.11 v2(134.86,18.87)
M_A_A_15: length 57.9
  L6 w0.089: 151.28,45.2 151.71,45.63 151.71,52.63 147.66,56.68 v1(147.66,57.31)
  L6 w0.117: 151.28,45.2 151.28,35.51 148.75,32.99 148.59,32.99 148.18,33.39 148.01,33.39 147.85,33.23 147.85,33.06 148.26,32.66 148.26,32.49 148.12,32.35 146.43,32.35 136.84,22.76 136.84,22.08 134.04,19.28 134.04,16.92 v2(133.59,16.48)
  BOTTOM w0.076: U4555.AB32 v1(147.66,57.31)
  BOTTOM w0.16: CN4100.156 135.91,12.41 135.91,14.05 133.59,16.36 v2(133.59,16.48)
M_A_A_16: length 55.3
  L6 w0.089: v1(146.75,57.31) 146.75,56.86 147.22,56.39 147.22,55.49 150.42,52.29 150.42,45.39
  L6 w0.117: v2(133.59,15.03) 133.07,15.55 133.07,19.42 136.07,22.42 136.07,23.08 149.17,36.18 149.84,36.18 150.5,36.85 150.5,45.31 150.42,45.39
  BOTTOM w0.076: U4555.Y32 v1(146.75,57.31)
  BOTTOM w0.16: CN4100.152 134.88,13.68 133.59,14.97 v2(133.59,15.03)
M_A_ACT#: length 58
  L6 w0.117: v1(144.01,51.04) 143.71,51.34 143.09,51.34 142.68,50.92 142.68,46.33 140.34,43.99 140.34,42.35 121.1,23.11 121.1,19.52 121.85,18.77 121.85,18.01 122.71,17.15 122.71,15.86 122.59,15.74 121.74,15.74 121.62,15.62 121.62,15.39 121.74,15.27 122.06,15.27 122.18,15.15 122.18,14.89 122.3,14.77 122.53,14.77 122.65,14.89 122.65,15.15 122.77,15.27 122.99,15.27 123.1,15.15 v1(123.1,15.03)
  BOTTOM w0.076: v1(144.01,51.04) 143.99,51.06 143.99,51.36 144.66,52.02 144.66,53.04 145.33,53.72 145.33,54.65 145.29,54.77 145.29,54.95 145.46,55.41 U4555.V35
  BOTTOM w0.16: CN4100.114 123.38,14.76 v1(123.1,15.03)
M_A_ALERT#: length 52.7
  L6 w0.117: v1(143.97,49.09) 143.43,48.55 143.43,46.03 141.23,43.84 141.23,41.31 136.86,36.93 136,36.93 122.88,23.81 122.88,17.58 123.09,17.37 123.09,16.58 v1(123.14,16.53)
  BOTTOM w0.076: 144.76,49.88 144.76,51.45 146.1,52.79 146.1,54.26 146.2,54.36 U4555.W37
  BOTTOM w0.16: CN4100.116 123.88,15.79 v1(123.14,16.53) ; 144.76,49.88 v1(143.97,49.09)
M_A_BG0: length 57.8
  L6 w0.117: v1(122.26,17.01) 122.26,16.84 122,16.58 121.66,16.58 121.47,16.77 121.47,17.67 121.34,17.81 120.91,17.81 120.79,17.92 120.79,18.16 120.91,18.27 121.34,18.27 121.45,18.39 121.45,18.62 121.34,18.74 120.83,18.74 120.71,18.86 120.71,23.27 139.96,42.51 139.96,44.15 142.33,46.52 142.33,50.88 144.01,52.56 v2(145.07,52.56)
  BOTTOM w0.076: v2(145.07,52.56) 145.28,52.56 145.77,53.06 145.77,54.63 145.81,54.77 145.81,54.95 145.77,55.06 145.77,55.31 145.82,55.43 145.82,55.89 U4555.V34
  BOTTOM w0.16: CN4100.115 123.63,18.37 v1(122.26,17.01)
M_A_BG1: length 57.5
  L6 w0.117: v1(122.26,18.98) 121.48,19.77 121.48,20.08 121.6,20.19 122.38,20.19 122.5,20.31 122.5,20.55 122.38,20.66 121.6,20.66 121.48,20.78 121.48,21.01 121.6,21.13 122.38,21.13 122.5,21.25 122.5,21.48 122.38,21.6 121.6,21.6 121.48,21.71 121.48,22.95 135.85,37.31 136.7,37.31 136.82,37.43 136.82,37.59 136.57,37.84 136.57,38.01 136.73,38.17 136.9,38.17 137.15,37.93 137.31,37.93 137.48,38.09 137.48,38.26 137.23,38.5 137.23,38.67 137.4,38.83 137.56,38.83 137.81,38.59 137.97,38.59 138.14,38.75 138.14,38.92 137.89,39.16 137.89,39.33 138.06,39.49 138.22,39.49 138.47,39.25 138.63,39.25 140.85,41.46 140.85,43.96 143.17,46.28 143.17,48.81 143.35,48.99 143.35,49.12 143.07,49.4 143.07,49.94 143.27,50.14 143.59,50.14 v2(143.97,49.77)
  BOTTOM w0.076: 144.45,51.4 145.93,52.89 145.93,54.6 145.98,54.74 145.98,54.98 145.94,55.09 145.94,55.28 145.98,55.4 145.98,55.61 U4555.W35
  BOTTOM w0.16: v1(122.26,18.98) 123.13,19.83 123.13,20.82 CN4100.113 ; 144.45,51.4 144.45,50.24 v2(143.97,49.77)
M_A_BS0: length 54.5
  L6 w0.076: v1(145.84,57.31) 145.89,56.72
  L6 w0.089: 145.89,56.72 145.96,55.94 148.37,53.39 149.7,50.16 149.7,46.15
  L6 w0.117: v2(132.26,15.88) 131.8,17.19 131.8,19.68 132.91,22.21 133.39,23.03 149.09,38.73 149.09,44.03 149.25,44.64 149.35,44.89 149.7,46.15
  BOTTOM w0.076: U4555.W32 v1(145.84,57.31)
  BOTTOM w0.16: v2(132.26,15.88) 132.74,15.05 134.38,13.42 CN4100.150
M_A_BS1: length 58.4
  L6 w0.089: 150.88,45.27 150.67,45.49 150.67,52.41 150.09,52.99 150.09,53.97 147.27,56.79 147.27,57.56 v1(147.66,57.95)
  L6 w0.117: v2(133.59,18.18) 133.65,18.24 133.65,19.44 136.45,22.24 136.45,22.92 147.53,33.99 148.36,33.99 148.71,33.65 148.87,33.65 149.05,33.82 149.05,33.97 148.36,34.66 148.36,34.83 148.52,34.99 148.69,34.99 149.4,34.28 149.51,34.28 149.73,34.5 149.73,34.61 149.02,35.32 149.02,35.49 149.18,35.65 149.35,35.65 150.02,34.99 150.2,34.99 150.35,35.14 150.35,35.31 150.01,35.65 150.01,35.81 150.18,35.98 150.35,35.98 150.49,35.83 150.66,35.83 150.82,36 150.82,36.16 150.68,36.31 150.68,36.47 150.88,36.68 150.88,45.27
  BOTTOM w0.076: U4555.AB31 v1(147.66,57.95)
  BOTTOM w0.16: v2(133.59,18.18) 133.13,18.64 CN4100.145
M_A_DQ<0>: length 71
  L6 w0.097: v1(96.26,16.16) 95.72,17.39 95.72,19.28 96.23,23.38 98.46,25.61 99.1,25.61 119.26,45.76 120.41,47.33 120.43,47.34 120.59,47.58 120.6,47.6 120.76,47.81 121.05,48.1 121.05,48.13 124.4,51.47 125.06,52.92 125.06,58.33 128.77,62.04 v1(130.13,62.04)
  BOTTOM w0.076: 131.11,61.62 131.28,61.44 133.6,61.44 133.71,61.55 134.72,61.55 134.93,61.34 135.5,61.34 U4555.A26
  BOTTOM w0.13: CN4100.8 96.88,15.28 v1(96.26,16.16) ; 131.11,61.62 130.54,61.62 v1(130.13,62.04)
M_A_DQ<1>: length 71.6
  L6 w0.097: v1(99.53,16.03) 99.94,15.62 99.94,15.07 100.11,14.9 100.4,14.9 100.54,15.03 100.54,22.75 123.83,46.04 123.83,46.29 128.19,50.65 128.19,56.61 129.97,58.39 129.97,58.98 130.21,59.23 132.44,59.23 v2(133.79,60.58)
  BOTTOM w0.076: v2(133.79,60.58) 134.02,60.35 134.54,60.35 134.78,60.59 135.88,60.59 136.06,60.53 136.24,60.53 136.35,60.57 136.59,60.57 136.72,60.53 137.22,60.53 137.28,60.48 137.54,60.48 137.77,60.71 U4555.D26
  BOTTOM w0.13: CN4100.16 98.88,13.33 98.69,13.51 98.69,15.19 v1(99.53,16.03)
M_A_DQ<2>: length 72.2
  L6 w0.097: v1(96.33,14.61) 97.27,14.61 97.37,14.71 97.37,15.42 97.46,15.52 97.59,15.52 97.68,15.61 97.68,15.8 97.59,15.9 97.46,15.9 97.37,16 97.37,23.25 98.84,24.71 99.47,24.71 121.72,46.96 121.72,47.51 121.94,47.73 121.94,47.76 125.96,51.77 125.96,52.26 125.96,57.96 127.61,59.61 v1(128.02,59.61)
  BOTTOM w0.076: 130.98,59.65 134.78,59.65 135.04,59.91 135.41,59.91 135.6,59.72 135.97,59.72 136.23,59.86 136.72,59.86 136.74,59.88 137.31,59.88 137.58,60.15 U4555.D28
  BOTTOM w0.13: CN4100.4 95.88,12.46 95.88,14.15 v1(96.33,14.61) ; v1(128.02,59.61) 128.06,59.65 130.98,59.65
M_A_DQ<3>: length 71.4
  L6 w0.097: v1(133.11,60.58) 133.11,60.45 132.1,59.45 130.02,59.45 129.68,59.1 129.68,58.52 127.89,56.74 127.89,50.78 123.53,46.42 123.53,46.16 100.24,22.87 100.24,18.49 100.12,18.38 100.06,18.38 99.95,18.26 99.95,18.1 100.06,17.99 100.12,17.99 100.24,17.88 100.24,17.72 100.12,17.6 100.06,17.6 99.95,17.49 99.95,17.33 100.06,17.22 100.12,17.22 100.24,17.1 100.24,16.41 100.13,16.29 99.91,16.29 99.82,16.39 99.82,16.7 99.7,16.81 99.54,16.81 99.43,16.7 99.43,16.58 99.06,16.21 98.92,16.21 98.76,16.36 98.76,16.63 99.42,17.29 v1(99.53,17.29)
  BOTTOM w0.076: v1(133.11,60.58) 133.5,60.19 134.61,60.19 134.85,60.43 135.85,60.43 136.03,60.37 136.27,60.37 136.38,60.41 136.56,60.41 136.69,60.37 136.9,60.37 U4555.C28
  BOTTOM w0.13: CN4100.21 100.13,17.88 v1(99.53,17.29)
M_A_DQ<4>: length 69.5
  L6 w0.097: v1(96.18,18.56) 96.36,18.38 96.64,18.38 96.77,18.51 96.77,19.39 96.68,19.49 96.61,19.49 96.51,19.59 96.51,19.78 96.61,19.88 96.68,19.88 96.77,19.97 96.77,20.17 96.68,20.26 96.61,20.26 96.51,20.36 96.51,20.55 96.61,20.65 96.68,20.65 96.77,20.74 96.77,20.94 96.68,21.03 96.61,21.03 96.51,21.13 96.51,21.32 96.61,21.42 96.68,21.42 96.77,21.52 96.77,21.71 96.68,21.81 96.61,21.81 96.51,21.9 96.51,22.1 96.61,22.19 96.68,22.19 96.77,22.29 96.77,23.5 98.58,25.31 99.23,25.31 121.12,47.21 121.12,47.75 121.35,47.98 121.35,48 125.36,52.02 125.36,58.2 128.7,61.54 131.01,61.54 v1(131.5,62.04)
  BOTTOM w0.076: v1(131.5,62.04) 131.92,61.62 133.5,61.62 133.6,61.72 134.79,61.72 135,61.51 135.46,61.51 135.67,61.71 135.94,61.71 136.42,61.45 U4555.B26
  BOTTOM w0.13: v1(96.18,18.56) 95.63,19.12 CN4100.3
M_A_DQ<5>: length 70.8
  L6 w0.097: v1(96.24,17.27) 96.55,17.27 97.07,17.8 97.07,23.37 98.71,25.01 99.35,25.01 121.42,47.08 121.42,47.63 121.65,47.86 121.65,47.88 125.66,51.89 125.66,52.14 125.66,58.08 128.55,60.97 131.81,60.97 v2(132.87,62.04)
  BOTTOM w0.076: U4555.C26 136.83,61.74 136.23,61.74 135.98,61.88 135.6,61.88 135.39,61.67 135.07,61.67 134.78,61.96 132.94,61.96 v2(132.87,62.04)
  BOTTOM w0.13: CN4100.7 96.61,20.81 96.61,17.65 v1(96.24,17.27)
M_A_DQ<6>: length 70.7
  L6 w0.097: v1(131.05,60.58) 130.66,60.19 130.2,60.19 128.4,58.39 128.11,58.39 127.17,57.45 127.17,52.77 127.17,51.26 123.16,47.25 123.16,47.23 122.94,47 122.94,46.45 99.9,23.42 99.43,23.42 99.12,23.1 99.12,17.41 98.45,16.74 98.45,15.65 98.55,15.55 98.79,15.55 98.89,15.46 98.89,15.17 98.79,15.07 98.55,15.07 98.45,14.97 98.45,14.32 98.78,13.98 99.07,13.98 v1(99.53,14.45)
  BOTTOM w0.076: U4555.B28 136.42,60.15 135.93,59.88 135.67,59.88 135.47,60.08 134.98,60.08 134.76,59.86 131.77,59.86 v1(131.05,60.58)
  BOTTOM w0.13: CN4100.20 99.88,14.12 99.56,14.44 v1(99.53,14.45)
M_A_DQ<7>: length 70.1
  L6 w0.097: v1(99.53,18.71) 99.84,18.71 99.94,18.81 99.94,19.74 99.84,19.83 99.52,19.83 99.43,19.93 99.43,20.12 99.52,20.22 99.84,20.22 99.94,20.32 99.94,20.51 99.84,20.61 99.52,20.61 99.43,20.7 99.43,20.9 99.52,20.99 99.84,20.99 99.94,21.09 99.94,21.28 99.84,21.38 99.52,21.38 99.43,21.47 99.43,21.67 99.52,21.76 99.84,21.76 99.94,21.86 99.94,22.99 123.23,46.28 123.23,46.88 123.37,47.01 123.7,47.01 123.84,47.15 123.84,47.29 123.8,47.33 123.8,47.47 123.93,47.6 124.07,47.6 124.11,47.56 124.25,47.56 124.38,47.7 124.38,47.83 124.34,47.88 124.34,48.01 124.48,48.15 124.62,48.15 124.66,48.11 124.79,48.11 124.93,48.24 124.93,48.38 124.89,48.42 124.89,48.56 125.02,48.69 125.16,48.69 125.2,48.65 125.34,48.65 125.48,48.79 125.48,48.93 125.43,48.97 125.43,49.1 125.57,49.24 125.71,49.24 125.75,49.2 125.89,49.2 126.02,49.34 126.02,49.47 125.98,49.51 125.98,49.65 126.12,49.79 126.25,49.79 126.3,49.74 126.43,49.74 126.57,49.88 126.57,50.02 126.53,50.06 126.53,50.2 126.66,50.33 126.8,50.33 126.84,50.29 126.98,50.29 127.11,50.43 127.11,50.78 127.47,51.14 127.47,52.89 127.47,52.89 127.47,57.29 127.53,57.34 127.79,57.34 127.81,57.33 127.98,57.33 128.08,57.42 128.08,57.6 128.07,57.61 128.07,57.75 128.2,57.89 128.34,57.89 128.41,57.82 128.54,57.82 128.68,57.96 128.68,58.09 128.61,58.16 128.61,58.3 128.75,58.43 128.88,58.43 128.95,58.37 129.09,58.37 129.22,58.5 129.22,58.64 129.16,58.71 129.16,58.84 129.95,59.63 130.11,59.63 130.21,59.73 130.21,59.9 130.31,60 130.5,60 130.6,59.9 130.6,59.73 130.69,59.63 130.89,59.63 130.98,59.73 130.98,60.1 131.08,60.19 131.27,60.19 131.37,60.1 131.37,59.81 131.47,59.71 131.97,59.71 132.06,59.81 132.06,60.26 v1(131.74,60.58)
  BOTTOM w0.076: U4555.A28 135.68,60.15 135.58,60.24 134.96,60.24 134.96,60.24 134.91,60.24 134.69,60.02 132.3,60.02 v1(131.74,60.58)
  BOTTOM w0.13: v1(99.53,18.71) 99.13,19.07 CN4100.17
M_A_DQ<8>: length 65.8
  L6 w0.097: v1(101.07,17.72) 101.04,17.7 101.04,16.53 101.14,16.44 101.37,16.44 101.48,16.55 101.48,19.64 101.35,19.77 101.35,20.03 101.48,20.16 101.48,20.41 101.35,20.54 101.35,20.8 101.48,20.93 101.48,22.14 124.62,45.28 124.62,45.96 128.99,50.33 128.99,56.73 130.52,58.26 130.85,58.26 131.04,58.44 131.46,58.44 v2(131.85,58.84)
  BOTTOM w0.076: v2(131.85,58.84) 132.24,59.22 134.74,59.22 134.98,58.98 135.45,58.98 135.67,59.19 135.94,59.19 136.42,58.93 U4555.B30
  BOTTOM w0.13: CN4100.29 102.13,18.78 v1(101.07,17.72)
M_A_DQ<9>: length 66.6
  L6 w0.097: v1(101.07,14.59) 101.74,14.59 102.09,14.94 102.09,21.91 125.22,45.04 125.22,45.72 129.58,50.08 129.58,56.37 v1(130.87,57.66)
  BOTTOM w0.076: v1(130.87,57.66) 130.87,57.52 131.31,57.07 133.54,57.07 134.55,58.08 135.91,58.08 136.05,58.02 136.24,58.02 136.35,58.06 136.59,58.06 136.72,58.01 137.22,58.01 137.28,57.96 137.54,57.96 137.77,58.2 U4555.D30
  BOTTOM w0.13: v1(101.07,14.59) 100.88,14.4 CN4100.24
M_A_DQ<10>: length 66.2
  L6 w0.097: v2(131.12,56.33) 131.28,56.17 131.28,50.06 126.44,45.21 126.44,44.53 103.85,21.95 103.85,21.78 103.76,21.68 103.62,21.68 103.52,21.58 103.52,21.39 103.62,21.29 103.76,21.29 103.85,21.2 103.85,21 103.76,20.91 103.43,20.91 103.33,20.81 103.33,20.62 103.43,20.52 103.76,20.52 103.85,20.43 103.85,20.23 103.76,20.14 103.43,20.14 103.33,20.04 103.33,19.85 103.43,19.75 103.76,19.75 103.85,19.65 103.85,15.17 103.95,15.08 104.27,15.08 104.37,14.98 104.37,14.79 104.27,14.69 103.95,14.69 103.85,14.59 103.85,14.4 104.12,14.13 104.69,14.13 104.87,14.31 v1(104.87,14.69)
  BOTTOM w0.076: 134.95,56.65 135.83,56.65 U4555.B33
  BOTTOM w0.13: CN4100.38 104.38,13.96 104.87,14.45 v1(104.87,14.69) ; v2(131.12,56.33) 131.88,55.57 133.87,55.57 134.95,56.65
M_A_DQ<11>: length 65.1
  L6 w0.097: v1(132.49,56.33) 131.67,55.5 131.67,50.02 126.73,45.09 126.73,44.41 104.15,21.83 104.15,17.1 104.27,16.98 104.99,16.98 105.09,16.89 105.09,16.69 104.99,16.6 104.27,16.6 104.15,16.49 104.15,15.77 104.25,15.67 104.58,15.67 104.87,15.96 v1(104.87,16.12)
  BOTTOM w0.076: U4555.D32 137.58,57.63 137.31,57.36 136.34,57.36 135.34,56.9 134.84,56.9 133.82,55.88
  BOTTOM w0.13: v1(132.49,56.33) 132.94,55.88 133.82,55.88 ; CN4100.42 105.38,14.1 105.5,14.23 105.5,15.49 v1(104.87,16.12)
M_A_DQ<12>: length 65.2
  L6 w0.097: v1(101.07,16.02) 101.07,15.78 101.38,15.47 101.68,15.47 101.78,15.56 101.78,22.02 124.92,45.16 124.92,45.84 129.28,50.2 129.28,56.63 130.73,58.08 132.46,58.08 v1(133.23,58.84)
  BOTTOM w0.076: v1(133.23,58.84) 133.42,59.03 134.69,59.03 134.91,58.81 135.71,58.81 U4555.A30
  BOTTOM w0.13: v1(101.07,16.02) 101.88,15.21 CN4100.28
M_A_DQ<13>: length 65.6
  L6 w0.097: v1(101.07,19.2) 101.04,19.23 101.04,22.4 101.28,22.65 101.57,22.65 101.71,22.79 101.71,22.93 101.63,23 101.63,23.14 101.77,23.28 101.91,23.28 101.98,23.2 102.12,23.2 102.26,23.34 102.26,23.47 102.18,23.55 102.18,23.69 102.32,23.82 102.45,23.82 102.53,23.75 102.67,23.75 102.8,23.88 102.8,24.02 102.73,24.1 102.73,24.23 102.86,24.37 103,24.37 103.08,24.29 103.21,24.29 103.35,24.43 103.35,24.57 103.27,24.64 103.27,24.78 103.41,24.92 103.55,24.92 103.62,24.84 103.76,24.84 103.9,24.98 103.9,25.11 103.82,25.19 103.82,25.32 103.96,25.46 104.09,25.46 104.17,25.38 104.3,25.38 104.44,25.52 104.44,25.66 104.37,25.73 104.37,25.87 104.5,26.01 104.64,26.01 104.71,25.93 104.85,25.93 104.99,26.07 104.99,26.2 104.91,26.28 104.91,26.42 105.05,26.55 105.18,26.55 105.26,26.48 105.4,26.48 105.53,26.61 105.53,26.75 105.46,26.83 105.46,26.96 105.59,27.1 105.73,27.1 105.81,27.02 105.94,27.02 106.08,27.16 106.08,27.3 106,27.37 106,27.51 106.14,27.65 106.28,27.65 106.35,27.57 106.49,27.57 106.63,27.71 106.63,27.84 106.55,27.92 106.55,28.06 106.69,28.19 106.82,28.19 106.9,28.12 107.04,28.12 107.17,28.25 107.17,28.39 107.1,28.46 107.1,28.6 107.23,28.74 107.37,28.74 107.45,28.66 107.58,28.66 107.72,28.8 107.72,28.93 107.64,29.01 107.64,29.15 107.78,29.28 107.91,29.28 107.99,29.21 108.13,29.21 108.26,29.34 108.26,29.48 108.19,29.56 108.19,29.69 108.32,29.83 108.46,29.83 108.54,29.75 108.67,29.75 124.33,45.41 124.33,46.09 128.69,50.45 128.69,56.72 130.42,58.45 130.78,58.45 v1(131.17,58.84)
  BOTTOM w0.076: v1(131.17,58.84) 131.77,59.44 134.77,59.44 135.07,59.15 135.38,59.15 135.6,59.36 135.98,59.36 136.23,59.22 136.83,59.22 U4555.C30
  BOTTOM w0.13: v1(101.07,19.2) 101.13,19.25 CN4100.25
M_A_DQ<14>: length 64.4
  L6 w0.097: v2(134.33,57.02) 134.33,55.32 132.26,53.25 132.26,49.78 127.33,44.84 127.33,43.48 118.77,34.92 118.48,34.92 118.38,35.02 118.25,35.02 118.11,34.88 118.11,34.74 118.27,34.58 118.27,34.44 118.14,34.31 118,34.31 117.84,34.47 117.7,34.47 117.56,34.33 117.56,34.2 117.73,34.03 117.73,33.9 117.59,33.76 117.45,33.76 117.29,33.93 117.15,33.93 117.02,33.79 117.02,33.65 117.18,33.49 117.18,33.35 117.04,33.21 116.91,33.21 116.74,33.38 116.61,33.38 116.47,33.24 116.47,33.11 116.63,32.94 116.63,32.81 116.5,32.67 116.36,32.67 116.2,32.83 116.06,32.83 115.92,32.7 115.92,32.56 116.09,32.4 116.09,32.26 115.95,32.12 115.82,32.12 115.65,32.29 115.52,32.29 115.38,32.15 115.38,32.01 115.54,31.85 115.54,31.71 115.41,31.58 115.27,31.58 115.11,31.74 114.97,31.74 114.83,31.6 114.83,31.47 115,31.3 115,31.17 114.86,31.03 114.72,31.03 114.56,31.19 114.42,31.19 114.29,31.06 114.29,30.92 114.45,30.76 114.45,30.62 114.31,30.48 114.18,30.48 114.01,30.65 113.88,30.65 113.74,30.51 113.74,30.38 113.9,30.21 113.9,30.08 113.77,29.94 113.63,29.94 113.47,30.1 113.33,30.1 113.19,29.97 113.19,29.83 113.36,29.67 113.36,29.53 113.22,29.39 113.08,29.39 112.92,29.56 112.78,29.56 112.65,29.42 112.65,29.28 112.81,29.12 112.81,28.98 112.67,28.85 112.54,28.85 112.37,29.01 112.24,29.01 112.1,28.87 112.1,28.74 112.27,28.57 112.27,28.44 112.13,28.3 111.99,28.3 111.83,28.46 111.69,28.46 111.56,28.33 111.56,28.19 111.72,28.03 111.72,27.89 111.58,27.75 111.45,27.75 111.28,27.92 111.15,27.92 111.01,27.78 111.01,27.64 111.17,27.48 111.17,27.34 111.04,27.21 110.9,27.21 110.74,27.37 110.6,27.37 110.46,27.23 110.46,27.1 110.63,26.93 110.63,26.8 110.49,26.66 110.35,26.66 110.19,26.83 110.05,26.83 105.59,22.36 105.59,20.02 105.22,19.65 105.22,19.3 v1(104.87,18.94)
  BOTTOM w0.076: U4555.B32 136.43,57.58 136.43,57.58 135.44,57.12 134.43,57.12
  BOTTOM w0.13: v1(104.87,18.94) 104.88,18.94 105.13,19.19 CN4100.41 ; 134.43,57.12 v2(134.33,57.02)
M_A_DQ<15>: length 64.5
  L6 w0.097: v1(104.87,17.45) 104.55,17.45 104.45,17.55 104.45,19.36 104.55,19.46 104.82,19.46 104.92,19.55 104.92,19.75 104.82,19.84 104.55,19.84 104.45,19.94 104.45,20.19 104.55,20.29 105.19,20.29 105.29,20.39 105.29,20.58 105.19,20.68 104.55,20.68 104.45,20.77 104.45,20.97 104.55,21.06 105.19,21.06 105.29,21.16 105.29,21.35 105.19,21.45 104.55,21.45 104.45,21.54 104.45,21.71 118.33,35.58 118.46,35.58 118.64,35.4 118.78,35.4 118.91,35.54 118.91,35.68 118.74,35.85 118.74,35.99 118.87,36.13 119.01,36.13 119.19,35.95 119.32,35.95 119.46,36.09 119.46,36.22 119.28,36.4 119.28,36.54 127.03,44.28 127.03,44.96 131.97,49.9 131.97,54.02 133.84,55.9 v1(133.84,56.53)
  BOTTOM w0.076: v1(133.84,56.53) 133.87,57.12 134.67,57.91 135.88,57.91 136.01,57.85 136.27,57.85 136.38,57.89 136.56,57.89 136.69,57.85 136.9,57.85 U4555.C32
  BOTTOM w0.13: CN4100.37 104.13,18.19 v1(104.87,17.45)
M_A_DQ<16>: length 67.3
  L3 w0.089: 138.35,64.17 138.94,64.17
  L3 w0.097: v1(144.24,17.43) 143.79,17.88 143.52,19.05 142.18,20.39 140.92,20.87 139.23,22.56 137.66,24.26 137.65,24.26 137.34,24.57 137.34,24.6 129.61,32.96 128.08,34.49 128.08,57.41 130.15,59.48 131.67,59.48 134.44,60.23 134.84,60.63 134.84,62.22 135.43,62.8 137.71,64.17 138.35,64.17 ; 138.94,64.17 139.23,63.88 139.66,63.88 140.38,63.56 v1(140.64,63.3)
  BOTTOM w0.076: U4555.J22 140.62,63.31 v1(140.64,63.3)
  BOTTOM w0.13: v1(144.24,17.43) 144.87,18.06 145.63,19.76 CN4100.195
M_A_DQ<17>: length 69.8
  L3 w0.097: v2(148.36,14.54) 148.28,14.63 148.06,14.63 147.96,14.53 147.96,13.24 147.79,13.08 147.51,13.08 147.4,13.19 147.4,13.31 147.3,13.4 146.92,13.4 146.82,13.31 146.82,13.19 146.73,13.1 146.54,13.1 146.44,13.19 146.44,13.31 146.34,13.4 146.22,13.4 146.12,13.5 146.12,13.69 146.22,13.79 147.3,13.79 147.4,13.89 147.4,14.2 147.3,14.3 146.92,14.3 146.83,14.39 146.83,14.59 146.92,14.68 147.45,14.68 147.55,14.78 147.55,15.43 147.55,15.44 147.55,17.01 147.03,17.52 147.03,19.17 146.82,19.38 146.82,19.38 146.79,19.41 146.41,19.41 146.41,19.42 143.69,22.14 143.69,22.4 131.23,34.87 131.23,53.34 135.21,57.32 135.21,58.03 136.44,59.25 136.44,60.31 137.98,61.85 139.14,61.85 139.21,61.78 139.49,61.78 v1(139.97,61.3)
  BOTTOM w0.076: v1(139.97,61.3) U4555.H25
  BOTTOM w0.13: v2(148.36,14.54) 147.88,14.05 CN4100.204
M_A_DQ<18>: length 66.5
  L3 w0.089: 138.8,63.72 137.86,63.72
  L3 w0.097: v1(139.31,63.28) 139.24,63.28 138.8,63.72 ; v1(144.9,15.57) 144.9,17.5 144.58,19 142.76,20.82 142.6,20.82 141.95,21.46 141.41,21.46 141.17,21.46 140.4,22.23 140.4,23.01 128.67,34.74 128.67,56.78 130.16,58.27 133.26,58.27 134.28,59.3 134.28,59.49 135.42,60.62 135.42,61.28 137.86,63.72
  BOTTOM w0.076: U4555.G22 v1(139.31,63.28)
  BOTTOM w0.13: CN4100.194 145.38,13.33 144.98,13.72 144.98,15.49 v1(144.9,15.57)
M_A_DQ<19>: length 66.1
  L3 w0.089: 138.88,63.92 137.71,63.92
  L3 w0.097: v1(139.99,63.31) 139.63,63.67 139.13,63.67 138.88,63.92 ; 137.71,63.92 135.19,61.39 135.19,60.67 133.74,59.23 130.32,59.23 128.37,57.28 128.37,34.62 137.83,25.16 137.83,25.02 137.64,24.83 137.64,24.69 137.78,24.56 137.91,24.56 138.11,24.75 138.24,24.75 138.38,24.61 138.38,24.48 138.19,24.28 138.19,24.15 138.32,24.01 138.46,24.01 138.65,24.2 138.79,24.2 138.92,24.07 138.92,23.93 138.73,23.74 138.73,23.6 138.87,23.47 139,23.47 139.2,23.66 139.33,23.66 139.47,23.52 139.47,23.38 139.28,23.19 139.28,23.06 139.41,22.92 139.55,22.92 139.74,23.11 139.88,23.11 140.09,22.9 140.09,22.12 141.05,21.17 141.54,21.17 141.54,21.17 141.83,21.17 v1(144.19,18.8)
  BOTTOM w0.076: U4555.H22 v1(139.99,63.31)
  BOTTOM w0.13: CN4100.191 144.63,19.68 144.19,19.24 v1(144.19,18.8)
M_A_DQ<20>: length 70.1
  L3 w0.097: v2(138.68,61.27) 138.02,61.27 136.85,60.1 136.85,58.11 135.02,56.28 134.86,56.28 132.17,53.59 132.17,53.24 132.07,53.14 131.93,53.14 131.83,53.04 131.83,52.85 131.93,52.75 132.07,52.75 132.17,52.66 132.17,52.46 132.07,52.37 131.93,52.37 131.83,52.27 131.83,52.08 131.93,51.98 132.07,51.98 132.17,51.89 132.17,51.69 132.07,51.6 131.93,51.6 131.83,51.5 131.83,51.31 131.93,51.21 132.07,51.21 132.17,51.11 132.17,50.92 132.07,50.82 131.93,50.82 131.83,50.73 131.83,50.53 131.93,50.44 132.07,50.44 132.17,50.34 132.17,50.15 132.07,50.05 131.93,50.05 131.83,49.95 131.83,49.76 131.93,49.67 132.07,49.67 132.17,49.57 132.17,49.38 132.07,49.28 131.93,49.28 131.83,49.18 131.83,48.99 131.93,48.89 132.07,48.89 132.17,48.8 132.17,48.6 132.07,48.51 131.93,48.51 131.83,48.41 131.83,48.22 131.93,48.12 132.07,48.12 132.17,48.02 132.17,47.83 132.07,47.73 131.93,47.73 131.83,47.64 131.83,47.45 131.93,47.35 132.07,47.35 132.17,47.25 132.17,47.06 132.07,46.96 131.93,46.96 131.83,46.87 131.83,46.67 131.93,46.58 132.07,46.58 132.17,46.48 132.17,46.29 132.07,46.19 131.93,46.19 131.83,46.09 131.83,45.9 131.93,45.8 132.07,45.8 132.17,45.71 132.17,45.51 132.07,45.42 131.93,45.42 131.83,45.32 131.83,45.13 131.93,45.03 132.07,45.03 132.17,44.94 132.17,44.82 132,44.65 132,44.46 132.17,44.29 132.17,44.1 132.07,44 131.93,44 131.83,43.91 131.83,43.71 131.93,43.62 132.07,43.62 132.17,43.52 132.17,43.33 132.07,43.23 131.93,43.23 131.83,43.14 131.83,42.94 131.93,42.85 132.07,42.85 132.17,42.75 132.17,42.56 132.07,42.46 131.93,42.46 131.83,42.36 131.83,42.17 131.93,42.07 132.07,42.07 132.17,41.98 132.17,41.78 132.07,41.69 131.93,41.69 131.83,41.59 131.83,41.4 131.93,41.3 132.07,41.3 132.17,41.2 132.17,41.01 132.07,40.92 131.93,40.92 131.83,40.82 131.83,40.63 131.93,40.53 132.07,40.53 132.17,40.43 132.17,40.24 132.07,40.14 131.93,40.14 131.83,40.05 131.83,39.85 131.93,39.76 132.07,39.76 132.17,39.66 132.17,39.47 132.07,39.37 131.93,39.37 131.83,39.27 131.83,39.08 131.93,38.98 132.07,38.98 132.17,38.89 132.17,38.7 132.07,38.6 131.93,38.6 131.83,38.5 131.83,38.31 131.93,38.21 132.07,38.21 132.17,38.12 132.17,37.92 132.07,37.83 131.93,37.83 131.83,37.73 131.83,37.54 131.93,37.44 132.07,37.44 132.17,37.34 132.17,37.15 132.07,37.05 131.93,37.05 131.83,36.96 131.83,36.76 131.93,36.67 132.07,36.67 132.17,36.57 132.17,36.38 132.07,36.28 131.93,36.28 131.83,36.19 131.83,35.99 131.93,35.9 132.07,35.9 132.17,35.8 132.17,35.48 134.26,33.38 134.26,33.25 134.18,33.16 134.18,33.02 134.31,32.89 134.45,32.89 134.54,32.97 134.67,32.97 134.81,32.84 134.81,32.7 134.72,32.61 134.72,32.48 134.86,32.34 134.99,32.34 135.08,32.43 135.22,32.43 135.36,32.29 135.36,32.15 135.27,32.07 135.27,31.93 135.4,31.79 135.54,31.79 135.63,31.88 135.76,31.88 135.9,31.74 135.9,31.61 135.81,31.52 135.81,31.39 135.95,31.25 136.09,31.25 136.17,31.34 136.31,31.34 136.45,31.2 136.45,31.06 136.36,30.98 136.36,30.84 136.5,30.7 136.63,30.7 136.72,30.79 136.86,30.79 136.99,30.65 136.99,30.52 136.91,30.43 136.91,30.29 137.04,30.16 137.18,30.16 137.27,30.24 137.4,30.24 137.54,30.11 137.54,29.97 137.45,29.88 137.45,29.75 137.59,29.61 137.73,29.61 137.81,29.7 137.95,29.7 138.09,29.56 138.09,29.42 138,29.34 138,29.2 138.14,29.06 138.27,29.06 138.36,29.15 138.5,29.15 138.69,28.95 138.69,28.38 147.62,19.45 147.62,19.29 147.71,19.21 147.87,19.21 147.99,19.09 147.99,18.95 147.85,18.82 147.85,18.63 147.62,18.41 147.62,18.16 v1(147.8,17.99)
  BOTTOM w0.076: v2(138.68,61.27) 138.71,61.28 U4555.F25
  BOTTOM w0.13: CN4100.203 147.63,19.21 147.76,19.07 147.76,18.02 v1(147.8,17.99)
M_A_DQ<21>: length 68.4
  L3 w0.097: v2(148.36,17.57) 148.36,17.41 148.82,16.95 148.82,13.96 148.98,13.8 149.26,13.8 149.37,13.91 149.37,14.28 149.47,14.37 149.61,14.37 149.7,14.47 149.7,14.66 149.61,14.76 149.47,14.76 149.37,14.86 149.37,15.05 149.47,15.15 149.61,15.15 149.7,15.24 149.7,15.44 149.61,15.53 149.47,15.53 149.37,15.63 149.37,17.01 149.03,17.35 148.66,17.97 148.66,18.82 148.66,18.82 148.66,18.84 138.99,28.51 138.99,29.08 132.47,35.6 132.47,53.54 134.83,55.9 135.05,55.9 137.07,57.93 137.07,60 137.95,60.88 140.18,60.88 v1(140.61,61.3)
  BOTTOM w0.076: v1(140.61,61.3) U4555.J25
  BOTTOM w0.13: v2(148.36,17.57) 148.68,17.92 148.68,20.77 CN4100.207
M_A_DQ<22>: length 67.1
  L3 w0.097: v2(148.36,16.07) 148.36,15.79 148.27,15.69 148,15.69 147.84,15.84 147.84,17.13 147.33,17.65 147.33,19.33 146.82,19.84 146.68,19.84 146.62,19.78 146.49,19.78 146.35,19.91 146.35,20.05 146.41,20.11 146.41,20.25 146.27,20.38 146.14,20.38 146.08,20.32 145.94,20.32 145.8,20.46 145.8,20.6 145.86,20.66 145.86,20.79 145.73,20.93 145.59,20.93 145.53,20.87 145.39,20.87 145.26,21.01 145.26,21.14 145.32,21.2 145.32,21.34 145.18,21.48 145.04,21.48 144.98,21.41 144.85,21.41 144.71,21.55 144.71,21.69 144.77,21.75 144.77,21.89 144.63,22.02 144.5,22.02 144.44,21.96 144.3,21.96 144.16,22.1 144.16,22.23 144.23,22.29 144.23,22.43 133.69,32.97 133.69,33.1 133.83,33.25 133.83,33.38 133.7,33.52 133.56,33.52 133.42,33.38 133.28,33.38 133.14,33.51 133.14,33.65 133.29,33.79 133.29,33.93 133.15,34.06 133.01,34.06 132.87,33.92 132.73,33.92 132.6,34.06 132.6,34.2 132.74,34.34 132.74,34.47 132.6,34.61 132.47,34.61 132.32,34.47 132.19,34.47 132.05,34.6 132.05,34.74 132.19,34.88 132.19,35.02 132.06,35.16 131.92,35.16 131.78,35.01 131.64,35.01 131.53,35.13 131.53,53.28 135.6,57.35 135.6,57.49 135.47,57.63 135.47,57.76 135.6,57.9 135.74,57.9 135.87,57.76 136.01,57.76 136.15,57.9 136.15,58.04 136.01,58.17 136.01,58.31 136.15,58.44 136.28,58.44 136.42,58.31 136.56,58.31 136.64,58.39 136.64,60.22 138.09,61.67 138.97,61.67 v1(139.34,61.3)
  BOTTOM w0.076: v1(139.34,61.3) U4555.G25
  BOTTOM w0.13: CN4100.208 148.88,15.56 v2(148.36,16.07)
M_A_DQ<23>: length 66.4
  L3 w0.097: v1(138.66,63.3) 137.78,63.3 135.68,61.21 135.68,60.54 134.63,59.49 134.63,59.09 133.62,58.07 130.47,58.07 128.97,56.57 128.97,34.86 140.7,23.14 140.7,22.36 141.29,21.76 142.07,21.76 142.72,21.11 142.9,21.11 145.19,18.82 145.19,17.31 145.42,17.08 145.42,14.06 145.18,13.82 144.51,13.82 v1(144.37,13.96)
  BOTTOM w0.076: U4555.F22 v1(138.66,63.3)
  BOTTOM w0.13: v1(144.37,13.96) 144.38,13.95 CN4100.190
M_A_DQ<24>: length 71.5
  L3 w0.097: v1(139.6,14.54) 138.19,15.96 137.5,17.98 136.21,19.27 135.74,19.27 134.47,20.55 133.55,20.55 124.52,29.58 124.52,61.69 128.26,65.43 131.48,65.43 133.14,65.1 v2(133.5,64.75)
  BOTTOM w0.076: U4555.D22 137.17,64.26 136.23,64.26 135.98,64.39 135.6,64.39 135.57,64.36 133.88,64.36 v2(133.5,64.75)
  BOTTOM w0.13: v1(139.6,14.54) 139.38,14.32 CN4100.170
M_A_DQ<25>: length 71.4
  L3 w0.097: v1(139.1,17.42) 139.1,17.42 136.61,19.92 135.94,19.92 134.04,21.82 133.12,21.82 132.39,22.55 132.39,22.69 132.54,22.84 132.54,22.97 132.4,23.11 132.26,23.11 132.11,22.96 131.98,22.96 131.84,23.1 131.84,23.24 131.99,23.38 131.99,23.52 131.85,23.66 131.72,23.66 131.57,23.51 131.43,23.51 131.3,23.65 131.3,23.78 131.44,23.93 131.44,24.07 131.31,24.2 131.17,24.2 131.02,24.06 130.89,24.06 130.75,24.19 130.75,24.33 130.9,24.48 130.9,24.61 130.76,24.75 130.62,24.75 130.48,24.6 130.34,24.6 130.2,24.74 130.2,24.87 130.35,25.02 130.35,25.16 130.21,25.3 130.08,25.3 129.93,25.15 129.79,25.15 125.12,29.82 125.12,61.44 128.42,64.75 v2(130.07,64.75)
  BOTTOM w0.076: 131.32,63.94 133.28,63.94 133.35,63.87 134.74,63.87 134.91,63.7 135.9,63.7 136.04,63.75 136.25,63.75 136.4,63.7 136.55,63.7 136.78,63.78 136.94,63.78 U4555.C22
  BOTTOM w0.13: v2(130.07,64.75) 130.88,63.94 131.32,63.94 ; v1(139.1,17.42) 140.13,18.44 CN4100.173
M_A_DQ<26>: length 70.6
  L3 w0.097: v1(128.66,62.66) 126.65,60.65 126.65,31.35 130.81,27.19 130.95,27.19 131.03,27.27 131.16,27.27 131.3,27.14 131.3,27 131.22,26.92 131.22,26.78 131.36,26.65 131.49,26.65 131.57,26.73 131.71,26.73 131.85,26.59 131.85,26.45 131.76,26.37 131.76,26.24 131.9,26.1 132.04,26.1 132.12,26.18 132.25,26.18 132.39,26.04 132.39,25.91 132.31,25.83 132.31,25.69 132.45,25.55 132.58,25.55 132.66,25.64 132.8,25.64 132.94,25.5 132.94,25.36 132.86,25.28 132.86,25.15 132.99,25.01 133.13,25.01 133.24,25.12 133.51,25.12 133.64,25 133.64,24.79 133.79,24.64 134.03,24.64 135.09,23.57 135.09,22.91 136.57,21.43 137.23,21.43 138.14,20.53 139.3,20.53 140.82,19 141.39,19 141.84,18.56 141.84,15.61 142.95,14.5 v1(142.95,14.47)
  BOTTOM w0.076: 133.09,62.5 133.35,62.23 133.38,62.23 133.52,62.23 134.86,62.23 135.06,62.44 135.39,62.44 135.6,62.23 135.97,62.23 136.16,62.33 136.79,62.33 U4555.C24
  BOTTOM w0.089: 133.09,62.5 132.69,62.5 132.68,62.5 130.95,62.5
  BOTTOM w0.13: 130.95,62.5 130.81,62.5 130.7,62.61 128.71,62.61 v1(128.66,62.66) ; CN4100.186 143.38,14.05 v1(142.95,14.47)
M_A_DQ<27>: length 71.3
  L3 w0.097: v2(142.99,18.87) 141.97,19.89 141.19,19.89 136.33,24.76 136.19,24.76 135.88,24.45 135.75,24.45 135.61,24.58 135.61,24.72 135.92,25.03 135.92,25.17 135.78,25.3 135.65,25.3 135.34,24.99 135.2,24.99 135.06,25.13 135.06,25.27 135.37,25.58 135.37,25.71 135.24,25.85 135.1,25.85 134.79,25.54 134.65,25.54 134.52,25.68 134.52,25.81 134.83,26.12 134.83,26.26 134.69,26.4 134.55,26.4 134.24,26.09 134.11,26.09 133.97,26.22 133.97,26.36 134.28,26.67 134.28,26.81 134.14,26.94 134.01,26.94 133.7,26.63 133.56,26.63 133.42,26.77 133.42,26.9 133.73,27.21 133.73,27.35 133.6,27.49 133.46,27.49 133.15,27.18 133.01,27.18 132.88,27.31 132.88,27.45 133.19,27.76 133.19,27.9 133.05,28.03 132.92,28.03 132.61,27.72 132.47,27.72 132.33,27.86 132.33,28 132.64,28.31 132.64,28.44 132.51,28.58 132.37,28.58 132.06,28.27 131.92,28.27 131.79,28.41 131.79,28.54 132.1,28.85 132.1,28.99 127.58,33.51 127.58,60.09 129.99,62.51 130.85,62.51 v1(131.66,63.31)
  BOTTOM w0.076: v1(131.66,63.31) 132.11,63.77 133.22,63.77 133.28,63.7 134.67,63.7 134.85,63.53 135.92,63.53 136.07,63.58 136.23,63.58 136.37,63.53 136.57,63.53 136.79,63.61 137.58,63.61 137.77,63.42 U4555.D24
  BOTTOM w0.13: v2(142.99,18.87) 143.63,19.51 CN4100.187
