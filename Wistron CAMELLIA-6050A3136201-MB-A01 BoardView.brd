# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SDA_P: length 199.2
  TOP w0.076: U300.L7 238.55,44.31 238.87,44.63 238.87,45.36 238.95,45.44 238.95,46.53 238.78,46.7 238.78,46.98 237.93,47.84 237.93,50.36
  TOP w0.102: 237.93,50.36 237.93,50.91 237.41,51.43 237.41,52.16 236.19,53.38 236.19,54.76 235.21,55.75 233.56,55.75 233.21,56.1 233.21,58.19 232.48,58.92 230.99,58.92 228.66,61.25 228.66,61.47 v1(228.24,61.89)
  L3 w0.102: v1(197.56,98.24) 200.47,95.32 209.05,95.32 210.53,96.8 210.53,98.73 211.73,99.93 213.42,99.93 214.01,99.34 214.01,97.68 217.04,94.65 217.04,93.62 217.79,92.88 217.79,92.14 222.35,87.58 222.35,77.94 v1(221.64,77.23)
  L6 w0.102: v1(101.7,88.66) 102.51,89.47 109.48,89.47 111.26,91.25 121.82,91.25 125.94,95.37 127.83,95.37 128.47,96 156.35,96 161.61,101.26 164.54,101.26 166.41,99.39 166.66,99.39 168.8,99.39 173.11,103.7 181.28,103.7 184.02,100.96 184.03,100.96 185,99.99 195.91,99.99 197.56,98.34 v1(197.56,98.24) ; v1(228.24,61.89) 228.88,62.52 228.88,63.91 224.1,68.69 224.1,72.28 221.4,74.98 221.4,76.99 v1(221.64,77.23)
  BOTTOM w0.102: v1(101.7,88.66) 101.7,89.09 v3(101.2,89.59) 100.83,89.96 R66003.1
SET: length 4
  BOTTOM w0.102: R4415.1 106.75,109.71 U4413.1 105.8,109.73 104.92,110.61 v3(104.92,111.01)
SG_IN: length 9.8
  BOTTOM w0.076: U4555.CN20 179.53,64.91 180.07,64.91 180.29,64.77 180.74,64.77 180.92,64.95 181.23,64.95 181.39,64.79 186.74,64.79 186.93,64.98 188,64.98
  BOTTOM w0.102: TP4522.1 188.16,64.98 188,64.98
SLP_LAN#_PCH: length 19.7
  TOP w0.076: 170.75,53.01 170.75,54.91 v3(170.48,55.18) 170.48,56.19 169.74,56.93 169.37,56.93 169.15,57.15 169.15,57.47 169.51,57.83 v1(169.51,57.91)
  TOP w0.102: R4858.1 171.01,42.36 171.01,43.5 170.86,43.65 170.86,46.36 172.74,48.24 172.74,50.04 170.75,52.03 170.75,53.01
  BOTTOM w0.076: v1(169.51,57.91) 169.24,58.18 U4555.BT31
SLP_S0#: length 95.8
  TOP w0.102: R66105.2 102.03,93.33 v1(102.03,93.41) 102.03,94.47 101.97,94.53 U66000.35
  L3 w0.102: v2(170.32,104.58) 172.27,102.63 175.18,102.63 178.11,99.7 181.11,99.7 181.71,99.09 183.31,99.09 v1(184.1,98.3)
  L5 w0.102: v1(184.1,98.3) 184.1,97.9 184.41,97.58 v1(184.41,95.21)
  L6 w0.102: v2(170.32,104.58) 169.14,103.39 161.02,103.39 155.33,97.7 127.94,97.7 127.18,96.94 125.28,96.94 122.01,93.66 119.01,93.66 118.75,93.41 v1(102.03,93.41)
  BOTTOM w0.102: v1(184.41,95.21) 183.86,95.21 R7156.2
SLP_S3#_3R: length 570.8
  TOP w0.13: v1(249.15,34.23) 249.31,34.07 249.31,33.53 247.97,32.18 247.97,31.55 246.46,30.05 243.47,30.05 242.33,31.19 242.1,31.19 241.75,31.54 R398.1 ; v1(215.16,85.08) 215.32,84.92 215.32,84.31 215.53,84.09 R7016.1 ; v1(199.69,71.3) 199.69,71.95 200.93,73.19 204.21,73.19 204.42,73.4 204.77,73.4 205,73.17 209.62,73.17 211.07,74.62 211.07,75.75 211.32,75.99 211.68,75.99 v1(212.1,75.57) 212.3,75.38 214.36,75.38 216.68,73.05 221.67,73.05 222.59,73.97 234.39,73.97 237.91,77.5 240.62,77.5 241.71,78.58 241.71,79.64 242.92,80.85 243.13,80.85 248.65,80.85 250.45,82.65 v1(253.39,82.65) ; R4864.1 177.52,42.19 178.2,41.52 R4516.2 ; v1(208.25,39.83) 207.69,39.27 190.31,39.27 189.94,39.63 179.71,39.63 178.2,41.14 R4516.2 ; U2501.6 24.21,31.78 24.46,32.04 25.22,32.04 v1(25.27,31.99) ; R4516.2 178.38,41.44 178.88,41.94 178.88,44.39 v1(178.71,44.57) ; v1(104.34,41.7) 103.8,41.15 U4920.1 104.01,40.62 R4921.1 ; R2702.1 v1(253.54,74.49)
  L3 w0.097: v1(212.1,75.57) 215.03,72.65 215.03,69.46 v1(214.63,69.05) ; v1(266.85,41.62) 269.03,41.62 272.92,45.51 272.92,48.08 270.84,50.16 270.84,69.95 270.59,70.21 270.59,71.38 271.17,71.96 271.17,72.64 271.39,72.86 271.39,75.7 271.17,75.92 270.53,76.56 270.53,77.55 271.2,78.22 271.2,78.49 271.2,86.84 272.69,88.33 v1(272.69,89.91) 261.76,89.91 257.13,85.28 256.37,85.28 253.74,82.65 v1(253.39,82.65) 253.39,79.96 252.17,78.74 252.17,75.86 v1(253.54,74.49) ; v1(197.86,61.23) 200.86,58.23 214.03,58.23 v1(215.3,56.96) ; v1(225.32,82.54) 222.99,82.54 222.9,82.64 222.9,92.6 v1(222.91,92.62) 220.79,92.62 216.52,96.88 215.54,96.88 214.24,98.18 214.24,99.43 213.51,100.16 212.28,100.16 212.02,100.42 205.25,100.42 204.44,99.61 200.79,99.61 199.82,98.64 197.39,98.64 197.15,98.4 197.15,98.07 196.75,97.67 v1(196.75,97.63)
  L5 w0.127: v1(214.06,78.75) 214.93,79.62 214.93,81.93 215.76,82.75 215.76,84.48 v1(215.16,85.08) ; v1(197.86,61.23) 198.71,60.38 205.7,60.38 208.92,57.16 208.92,48.28 208.25,47.6 v1(208.25,39.83)
  L6 w0.127: v1(215.3,56.96) 215.48,56.96 216.21,57.7 216.21,65.65 214.63,67.24 v1(214.63,69.05) ; v1(214.06,78.75) 212.1,76.79 v1(212.1,75.57) ; v1(25.27,31.99) 26.22,31.03 26.22,27.5 35.4,18.33 40.72,18.33 41.67,17.38 44.74,17.38 45.57,16.54 45.92,16.54 46.24,16.86 46.24,18.91 47.23,19.9 47.23,22.17 49.93,24.87 52.15,24.87 52.41,24.61 53.67,23.34 66.21,23.34 66.81,22.75 67.65,21.91 84.99,21.91 94.24,31.17 94.24,32.69 102.06,40.5 103.15,40.5 v1(104.34,41.7) ; v1(215.16,85.08) 216.83,85.08 217.29,84.62 222.19,84.62 224.28,82.54 v1(225.32,82.54)
  BOTTOM w0.13: D7002.3 213.58,75.57 v1(212.1,75.57) ; R7023.1 196.53,96.19 196.53,96.21 196.02,96.72 196.02,97.27 196.13,97.37 196.22,97.41 196.31,97.41 196.53,97.63 v1(196.75,97.63) ; v1(249.15,34.23) 249.15,34.91 248.88,35.18 248.88,39.58 249.94,40.64 251.55,40.64 252.66,41.75 254.75,41.75 255.76,42.76 ; 255.76,42.76 255.77,42.75 256.12,42.75 256.13,42.76 261.68,42.76 261.86,42.58 264.47,42.58 265.44,41.62 v1(266.85,41.62) ; 255.76,42.76 255.37,43.15 255.37,44.27 255.7,44.61 255.79,44.61 255.8,44.62 255.95,44.62 256.37,45.05 256.37,45.44 256.16,45.66 255.55,45.66 254.62,46.59 CN4941.2 ; v1(214.06,78.75) 213.44,78.75 R7028.1 212.49,78.78 210.97,78.78 210.72,79.03 Q7002.2 ; v1(199.69,71.3) 199.48,71.1 199.48,69.84 199.07,69.43 199.07,69.23 198.86,69.03 198.86,68.8 198.79,68.73 D4702.2 ; v1(222.91,92.62) 222.7,92.82 R7124.1 ; v1(104.34,41.7) 104.34,42.31 104.9,42.86 108.79,42.86 112.57,39.09 153.5,39.09 154.75,40.34 174.49,40.34 v1(178.71,44.57) ; v1(214.63,69.05) 214.21,68.63 213.84,68.63 213.7,68.77 R7414.1 ; U3150.4 272.12,90.3 272.51,89.91 v1(272.69,89.91)
SLP_S3#_3R_COMPARE: length 2.4
  BOTTOM w0.13: D7400.1 211.09,68.72 v3(211.86,68.72) 212.83,68.72 R7414.2
SLP_S3#_3R_KBC: length 9
  TOP w0.076: v1(239.53,39.34) U300.D6
  TOP w0.13: R398.2 240,31.54 v2(239.42,32.12)
  L3 w0.076: v1(239.53,39.34) 239.53,39.19 239.04,38.7 239.04,37.48 238.91,37.35 238.91,36.31 239.36,35.85 239.36,35.32
  L3 w0.097: 239.36,35.32 239.36,35.19 239.36,32.17 v2(239.42,32.12)
SLP_S3#_3R_N: length 6.2
  TOP w0.076: 253.79,71.06 254,70.86 254.45,70.86 255.92,69.39 255.92,69.07 U2700.U1
  TOP w0.13: 253.79,71.06 253.31,71.55 R2710.2 253.38,71.72 253.84,72.18 253.84,73.15 R2702.2
SLP_S3#_3R_PCH: length 20.1
  TOP w0.13: R4516.1 177.39,41.44 177.11,41.72 177.11,43.45 177.68,44.02 177.68,45.53 177.48,45.73 177.48,46.81 v2(178.1,47.42)
  BOTTOM w0.076: 178.1,48.51 177.97,48.64 176.4,48.64 175.41,49.62 175.18,49.62 174.3,50.5 173.54,50.5 171.92,52.12 171.2,52.12 170.14,53.18 170.14,53.19 170.07,53.97 170.04,54.14 169.89,54.28 169.81,54.41 169.81,54.64 169.87,54.75 169.91,54.84 U4555.BU36
  BOTTOM w0.13: 178.1,48.51 v2(178.1,47.42)
SLP_S3#_3R_RC: length 4.8
  BOTTOM w0.13: v3(213.71,77.97) 213.54,77.79 R7028.2 212.98,77.69 213.32,77.35 D7002.1 212.83,76.4 C7009.1 212.06,76.11 211.23,76.11 211.05,76.29 Q7306.5
SLP_S3#_XDP_PRSNT: length 134.5
  TOP w0.13: v1(106.07,41.7) 106.07,40.4 105.44,39.77 R4921.2 104.91,39.76 103.75,39.76 102.5,38.5 U4920.4
  L5 w0.127: v1(106.07,41.7) 110.65,46.28 110.65,46.94 112.52,48.81 112.52,61.06 114.74,63.29 116.35,63.29 117.05,63.98 117.05,74.67 116.57,75.15 116.57,77.36 117.02,77.81 117.02,82.03 117.48,82.49 117.48,82.84 116.91,83.42 115.3,83.42 115.17,83.54 115.14,83.54 114.89,83.79 114.89,84.19 117.54,86.83 117.54,91.12 117.79,91.38 120.3,91.38 123.17,88.5 123.17,88.4 125.16,86.41 125.16,82.29 125.4,82.04 125.75,82.04 125.99,82.29 125.99,88.27 125,89.26 125,94.51 126.15,95.66 156.2,95.66 158.36,93.5 160.14,93.5 161.11,92.53 v2(161.11,90.3)
  BOTTOM w0.13: v2(161.11,90.3) 161.11,89.04 160.9,88.84 Q7307.5
SLP_S3_5R: length 63.8
  TOP w0.13: v1(250.29,71.13) 250.29,71.08 249.91,70.7 Q2701.5 ; v1(211.49,75.57) 211.95,75.12 214.25,75.12 216.58,72.79 221.78,72.79 222.41,73.42 223.71,73.42 224.16,72.97 233.76,72.97 238.02,77.24 240.73,77.24 241.97,78.48 241.97,78.69 241.97,79.54 243.02,80.59 248.76,80.59 249.19,81.02 v1(250.39,81.02)
  L3 w0.097: v1(250.29,71.13) 250.29,75.23 249.66,75.87 249.66,80.28 v1(250.39,81.02)
  L6 w0.127: v1(211.49,75.57) 211.49,78.77 v1(212.77,80.04)
  BOTTOM w0.13: v1(211.49,75.57) 210.96,75.57 Q7011.G ; v3(213.26,80.53) v1(212.77,80.04) 212.74,80.02 R7005.2 211.82,80.02 Q7002.6
SLP_S4#_3R: length 479.5
  TOP w0.102: v1(50.01,12.82) 51,13.81 51,14.41 51.18,14.59 51.18,17.35 51.46,17.64 51.46,20.44 52.75,21.73 52.75,22.13 52.47,22.42 51.66,22.42 47.34,26.74 47.34,27.18 47.1,27.42 43.81,27.42 40.99,30.24 33.67,30.24 31.81,32.09 27.53,32.09 26.28,33.34 26.08,33.34 25.2,32.46 24.19,32.46 23.71,31.98 U2501.7 ; v2(172.76,45.47) 172.1,44.81 R4521.2 172.1,43.9 R4863.1 ; U1000.6 138.19,5.93 v1(138.07,5.81) ; v1(81.2,27.24) 81.61,26.84 81.61,26.22 81.84,26 81.84,20.38 82.37,19.85 v1(82.37,19.8) ; v1(222.02,38.29) 220.93,39.38 220.93,41.72 221.74,42.53 221.74,42.53 R301.1
  L3 w0.102: v1(112.98,41.77) 109.65,41.77 109.55,41.67 109.55,38.94 109.34,38.73 109.34,35.53 99.37,25.55 98.73,25.55 89.15,15.98 89.15,15.59 88.74,15.19 v1(88.74,15.15) ; v1(263.6,37.68) 264.39,36.89 267.01,36.89 267.25,36.66 267.25,36.28 264.72,33.75 262.08,33.75 261.42,33.08 261.42,31.94 261.14,31.67 261.14,30.22 260.05,29.14 259.66,29.14 255.39,24.87 v1(255.39,23.66) ; v1(50.01,12.82) 50.8,13.6 59.51,13.6 62.19,10.93 83.92,10.93 85.56,9.29 86.76,9.29 87.25,9.77 87.25,10.01 87.48,10.25 87.93,10.25 v1(88.34,9.84) 89.76,8.42 101.58,8.42 101.92,8.42 104.89,5.45 106.1,5.45 106.15,5.4 110.28,5.4 113.96,9.08 131.34,9.08 v1(132.56,7.86)
  L5 w0.102: v1(255.39,23.66) 255.39,23.61 254.5,22.72 245.74,22.72 v1(243.94,20.92) ; v1(214.5,34.69) 215.29,35.48 215.29,41.01 213.1,43.19 213.1,45.09 213.28,45.27 213.28,46.47 213.1,46.65 213.1,47 213.55,47.44 213.55,49.65 214.17,50.27 214.17,59.91 216.51,62.24 216.51,63.97 215.69,64.79 215.69,69.46 215.21,69.94 215.21,77.03 212.36,79.88 212.36,80.45 v1(212.34,80.48)
  L6 w0.102: v1(262.56,51.78) 262.56,50.67 263.27,49.96 263.27,46.03 263.6,45.7 v1(263.6,37.68) ; v1(214.5,34.69) 214.09,34.28 208.85,34.28 204.94,38.19 178.21,38.19 173.19,43.21 173.19,45.03 v2(172.76,45.47) ; v1(82.37,19.8) 82.6,19.8 87.25,15.15 v1(88.74,15.15) ; v1(222.02,38.29) 222.02,37.72 223.15,36.59 224.36,36.59 226.67,34.28 227.46,34.28 228.17,33.57 229.67,33.57 230.08,33.16 232.06,33.16 232.26,32.96 232.54,32.96 232.54,32.96 233.1,32.96 233.43,32.63 235.54,32.63 236.01,32.15 236.01,31.54 237.64,29.92 237.64,25.75 237.64,25.25 239.76,23.13 240.41,23.13 240.41,23.13 241.73,23.13 v1(243.94,20.92) ; v1(132.56,7.86) 132.97,7.46 133.49,7.46 135.14,5.81 v1(138.07,5.81)
  BOTTOM w0.102: v1(214.5,34.69) 215.96,36.16 218.32,36.16 220.46,38.29 v1(222.02,38.29) ; v1(212.34,80.48) 212.21,80.6 R7020.1 ; v1(262.56,51.78) 261.63,50.84 257.81,50.84 257.53,50.56 257.53,50.23 258.09,49.67 258.09,49.07 257.82,48.81 256.82,48.81 256.64,48.63 256.64,48.21 256.12,47.68 CN4941.5 ; v1(112.98,41.77) 114.94,41.77 115.62,41.09 152.66,41.09 153.92,42.35 168.72,42.35 171.84,45.47 v2(172.76,45.47) ; v1(88.74,15.15) 88.34,14.75 v1(88.34,9.84) ; U2500.4 81.2,28.62 v1(81.2,27.24)
SLP_S4#_3R_KBC: length 14.2
  TOP w0.076: 232.51,41.39 232.71,41.39 232.84,41.26 234.56,41.26 235.17,40.65 235.63,40.65 U300.F11
  TOP w0.102: 232.51,41.39 230.63,41.39 230.59,41.44 229.31,41.44 228.54,42.2 227.48,42.2 227.05,41.77 224,41.77 v3(223.72,42.05) 223.24,42.53 R301.2
SLP_S4#_3R_PCH: length 20.3
  TOP w0.076: v1(170.44,60.49) 170.96,59.97 170.96,57.79 170.97,57.77 170.97,56.44 171.29,56.13 171.29,54.84 171.59,54.53 172,54.53 172.33,54.21 172.33,53.72 173.04,53.01
  TOP w0.102: R4521.1 171.57,44.27 v3(171.57,44.99) 172.28,45.7 172.28,47.17 173.35,48.23 174.08,48.23 174.47,48.63 174.47,51.37 173.04,52.8 173.04,53.01 173.04,53.01
  BOTTOM w0.13: U4555.BU27 v1(170.44,60.49)
SLP_S4#_3R_R: length 2.9
  BOTTOM w0.102: R7018.2 211.36,82.08 R7020.2 211.33,81.62 211.33,81.62 v3(210.56,81.62) 210.72,81.47 Q7002.5
SLP_S4_3R: length 6.9
  TOP w0.076: 209.92,78.06 v1(209.57,78.06)
  TOP w0.102: 209.92,78.06 211.34,78.06 212.03,77.36 212.03,77.36 R7019.2 214.02,76.67 v3(213.99,76.65)
  BOTTOM w0.13: v1(209.57,78.06) 209.57,78.63 Q7002.3
SLP_S5#_3R: length 103.8
  TOP w0.13: v1(169.56,59.23) 169.99,59.66 TP4507.1
  L3 w0.076: 174.79,54.17 173.97,55 173.07,55 172.43,55.64 171.75,55.64 170.84,56.55 169.75,56.55 169.7,56.6 169.11,57.19 169.11,58.78 v1(169.56,59.23)
  L3 w0.097: v1(251.38,44.95) 251.3,44.95 248.95,47.3 248.76,47.3 247.84,48.22 246.88,48.22 246.51,47.85 246.51,47.83 246.5,47.83 246.5,47.75 246.26,47.51 245.8,47.51 245.05,48.26 241.8,48.26 241.39,48.68 240.21,48.68 239.88,48.34 236.12,48.34 236,48.22 231.87,48.22 231.68,48.02 230.58,48.02 230.23,47.68 216.78,47.68 216.71,47.76 216.06,47.76 215.28,46.98 214.57,46.98 213.79,47.76 210.78,47.76 207.21,51.33 203.25,51.33 201.61,49.68 196.98,49.68 195.99,48.69 189.43,48.69 188.93,48.69 185.94,51.67 177.29,51.67 174.79,54.17
  BOTTOM w0.13: U4555.BT29 v1(169.56,59.23) ; v1(251.38,44.95) 251.38,47.25 252.09,47.96 255.42,47.96 255.62,47.76 CN4941.4
SLP_WLAN_PCH#: length 19
  TOP w0.076: v1(169.49,58.54) 169.91,58.13 169.91,57.03 170.96,55.99 170.96,53.01
  TOP w0.102: R4851.1 171.22,43.05 171.22,43.59 171.07,43.74 171.07,45.78 v3(171.57,46.29) 171.57,46.79 172.95,48.16 172.95,50.13 170.96,52.12 170.96,53.01
  BOTTOM w0.076: U4555.BT30 169.21,58.83 v1(169.49,58.54)
SPI_CLK_EC: length 6.1
  TOP w0.076: 232.51,41.61 232.95,41.61 233.14,41.42 234.74,41.42 235.2,40.96 U300.F12
  TOP w0.13: 232.51,41.61 230.72,41.61 230.68,41.65 230.59,41.65 v3(230.32,41.92) 229.76,41.92 R316.2
SPI_CLK_EC_R: length 16.5
  TOP w0.13: v2(216.33,46.84) 216.13,47.05 R312.2 ; v1(224.02,42.76) 224.02,42.67 224.43,42.27 226.84,42.27 227.27,42.7 228.8,42.7 229.22,42.28 R316.1
  L3 w0.097: v1(224.02,42.76) 223.89,42.89 223.83,42.89 222.54,44.18 220.34,44.18 220.16,44.18 218.08,46.26 216.92,46.26 v2(216.33,46.84)
SPI_CLK_FLH: length 15.5
  TOP w0.13: U3500.19 224.49,54.58 v1(224.41,54.49) 224,54.09 223.84,54.09 223.6,54.09 220.12,50.61 v3(219.5,50.61) 218.85,50.61 216.76,48.52 R4794.1 R312.1
  BOTTOM w0.13: v1(224.41,54.49) 224.71,54.8 CN367.6 226.95,54.81 U367.6
SPI_CLK_PCH: length 26
  TOP w0.13: R4567.1 195.3,44 R4842.1 194.28,44.39 193.49,45.18 193.16,45.18 192.85,44.88 192.19,44.88 189.51,47.56 189.23,47.56 188.98,47.31 188.67,47.31 v3(188.44,47.54) 188.41,47.56 v1(187.68,47.56)
  BOTTOM w0.076: U4555.CH37 176.41,54.24 176.89,53.75 180.01,53.75 180.3,53.46
  BOTTOM w0.13: v1(187.68,47.56) 187.68,48.51 184.41,51.77 183.77,51.77 183.07,52.48 182.89,52.48 182.67,52.27 182.67,52.08 182.77,51.98 182.77,51.8 182.6,51.63 182.13,51.63 180.3,53.46
SPI_CLK_PCH_R: length 28
  TOP w0.13: R4794.2 216.76,47.37 216.84,47.29 216.84,46.63 216.75,46.54 216.75,46.01 216.09,45.35 216.09,44.72 216.32,44.49 216.32,44.14 215.84,43.66 212.8,43.66 212.5,43.36 211.5,43.36 211.31,43.55 211.08,43.78 211.08,43.78 211.02,43.84 210.86,44 210.67,44.18 207.25,44.18 207.06,44 205.98,44 205.27,43.29 205.03,43.29 204.66,43.66 204.45,43.66 204.08,43.29 203.84,43.29 203.46,43.66 203.26,43.66 202.88,43.29 202.67,43.29 202.3,43.66 202.09,43.66 201.72,43.29 201.5,43.29 201.13,43.66 200.87,43.66 200.5,43.29 200.27,43.29 199.89,43.66 199.65,43.66 199.28,43.29 199.05,43.29 198.68,43.66 198.46,43.66 198.08,43.29 197.81,43.29 197.43,43.66 197.21,43.66 196.84,43.29 196.61,43.29 196.24,43.66 195.89,43.66 R4567.2
SPI_CS0#_EC: length 13.5
  TOP w0.076: U300.G11 235.63,41.93 233.49,41.93 232.51,42.92
  TOP w0.13: R441.2 223.55,43.79 226.6,43.79 226.84,44.03 v3(227.35,44.03) 227.5,43.89 229,43.89 229.17,43.71 230.52,43.71 230.91,43.31 232.11,43.31 232.51,42.92
SPI_CS0#_EC_R: length 8.5
  TOP w0.13: R441.1 223.98,43.33 v1(224.02,43.37) ; R442.2 v3(218.31,46.95) 218.34,46.87 v1(218.97,46.23)
  L3 w0.097: v1(218.97,46.23) 220.55,44.66 222.74,44.66 v1(224.02,43.37)
SPI_CS0#_FLH: length 24.4
  TOP w0.13: v1(223.77,49.85) 223.77,49.81 222.92,48.96 220.6,48.96 v3(220.54,48.91) 220.21,48.58 219.35,48.58 R331.1 R442.1 R4790.1
  L6 w0.127: v1(234.11,54.17) 233.77,54.51 228.86,54.51 226.26,51.91 225.62,51.91 223.77,50.05 v1(223.77,49.85)
  BOTTOM w0.13: CN367.1 236.52,57.35 U367.1 235.28,57.35 234.71,56.78 234.51,56.78 234.24,56.51 234.24,56.18 234.11,56.05 v1(234.11,54.17)
SPI_CS0#_PCH: length 20.3
  TOP w0.13: v1(186.71,46.69) 188.03,45.36 188.49,45.36 v3(188.85,45) 190.22,43.63 R4570.1
  BOTTOM w0.076: U4555.CG36 175.76,54.19 176.69,53.25 179.52,53.25 181.94,50.83 183.59,50.83
  BOTTOM w0.13: v1(186.71,46.69) 186.26,47.13 186.26,48.16 183.59,50.83
SPI_CS0#_PCH_R: length 32.2
  TOP w0.13: R4790.2 217.74,47.66 217.74,46.25 217.64,46.16 217.64,44.88 217.21,44.44 217.21,43.77 216.21,42.77 213.49,42.77 213.17,42.77 212.87,42.46 212.69,42.46 211.13,42.46 210.56,43.03 210.3,43.29 207.66,43.29 207.47,43.11 206.89,43.11 206.18,42.39 193.65,42.39 192.63,43.42 v3(191.64,43.42) 191.44,43.63 R4570.2
SPI_SI_EC: length 9
  TOP w0.076: 232.51,44.11 234.03,42.58 235.63,42.58 U300.H11
  TOP w0.13: 232.51,44.11 232.46,44.15 229.85,44.15 v3(229.69,44.31) 229.52,44.15 228.88,44.15 228.63,44.39 228.63,44.91 R439.2
SPI_SI_EC_R: length 6.2
  TOP w0.13: R439.1 228.25,44.47 v1(228.09,44.31) ; R313.2 v2(224.63,46.73)
  BOTTOM w0.13: v2(224.63,46.73) 227.05,44.31 v1(228.09,44.31)
SPI_SI_FLH: length 11.5
  TOP w0.13: R418.1 R313.1 R4796.1 226.06,49.01 226.06,49.7 225.62,50.13 v1(225.62,53.38) 225.23,53.77 225.23,54.37 225.49,54.62 U3500.21
  BOTTOM w0.13: U367.5 226.95,53.54 CN367.5 225.77,53.53 v1(225.62,53.38)
SPI_SI_FLH_R: length 6.8
  TOP w0.13: v3(126.11,74.03) 126.58,74.03 127.23,73.39 127.23,73.02 126.56,72.35 R4931.2 125.91,72.1 C4937.1 125.23,72.1 124.82,71.69 124.6,71.69 124.48,71.56 124.48,71.41 124.34,71.28 124.22,71.28 124.08,71.15 CN4920.47
SPI_SI_PCH: length 19.8
  TOP w0.13: v2(184.57,47.45) 185.34,46.68 185.34,46.37 187.5,44.21 187.7,44.21 188.11,43.8 R4568.1
  BOTTOM w0.076: 183.43,48.82 183.24,49.01 182.83,49.01 179.24,52.59 176.41,52.59 175.05,53.96 175.02,54.12 174.84,54.38 174.84,54.38 174.84,54.64 174.9,54.76 U4555.CF36
  BOTTOM w0.13: v2(184.57,47.45) 184.57,47.68 183.43,48.82
SPI_SI_PCH_R: length 42.5
  TOP w0.13: R4568.2 188.79,42.46 v3(188.85,42.41) 190.03,41.23 190.58,41.23 190.96,40.85 206.8,40.85 207.53,41.57 208.11,41.57 208.29,41.75 209.67,41.75 210.49,40.93 213.99,40.93 214.68,41.62 216.69,41.62 218.36,43.29 218.36,43.95 220.61,46.19 225.11,46.19 225.24,46.32 R4796.2
SPI_SO2_FLH: length 18.5
  TOP w0.13: v1(225.07,49.75) v3(224.33,49.01) 223.97,48.66 223.83,48.66 R369.1 R314.1 R370.1 R4793.1
  L6 w0.127: v1(235.33,54.17) 235.18,54.02 235.18,53.12 234,51.94 229.94,51.94 227.85,49.85 225.17,49.85 v1(225.07,49.75)
  BOTTOM w0.13: CN367.3 235.57,54.8 U367.3 235.33,54.58 v1(235.33,54.17)
SPI_SO2_PCH: length 21.9
  TOP w0.13: R4611.1 188.85,43.69 v3(188.85,43.71) 187.96,44.59 187.66,44.59 185.84,46.41 v1(185.84,46.74)
  BOTTOM w0.076: U4555.CF34 175.25,56.18 175.37,55.94 175.37,55.75 175.33,55.62 175.33,55.4 175.37,55.27 175.37,55.1 175.33,54.98 175.33,54.75 175.33,54.73 175.36,54.64 175.4,54.38 175.4,54.07 176.55,52.92 179.38,52.92 182.3,50 183.33,50 183.43,49.9
  BOTTOM w0.13: 183.43,49.9 185.42,47.92 185.42,47.16 v1(185.84,46.74)
SPI_SO2_PCH_R: length 36.3
  TOP w0.13: R4611.2 189.58,42.43 v3(190.24,41.77) 190.74,42.27 R4929.2 192.37,42.27 192.48,42.16 192.8,42.16 193.35,41.61 206.49,41.61 207.21,42.34 207.79,42.34 207.97,42.52 209.99,42.52 210.02,42.49 210.81,41.7 213.01,41.7 213.01,41.7 213.18,41.7 213.49,42 216.53,42 216.53,42 217.98,43.45 217.98,44.1 221.46,47.59 221.46,47.62 R4793.2
SPI_SO3_FLH: length 15.9
  TOP w0.13: v1(224.38,49.85) 223.11,48.58 221.38,48.58 220.99,48.19 R4795.1 R422.1 R368.1
  L6 w0.127: v1(224.38,49.85) 226.06,51.53 226.49,51.53 v1(229.26,54.09)
  BOTTOM w0.13: CN367.7 226.95,56.08 U367.7 228.51,56.08 229.26,55.34 229.26,55.33 v1(229.26,54.09)
SPI_SO3_PCH: length 22.3
  TOP w0.13: R4592.1 190.3,42.99 189.06,44.23 188.87,44.23 188.12,44.98 187.82,44.98 186.26,46.54 186.26,47.13 185.97,47.42 v2(185.84,47.42)
  BOTTOM w0.076: 183.43,50.45 182.09,50.45 179.45,53.09 176.62,53.09 175.59,54.12 175.59,54.48 175.49,54.77 175.49,54.94 175.53,55.07 175.53,55.29 175.49,55.43 175.49,55.59 175.51,55.65 U4555.CG34
  BOTTOM w0.13: 183.43,50.45 185.84,48.03 v2(185.84,47.42)
SPI_SO3_PCH_R: length 33.9
  TOP w0.13: R4795.2 220.85,47.52 217.6,44.26 217.6,43.61 216.37,42.38 213.33,42.38 213.03,42.08 212.85,42.08 212.85,42.08 210.97,42.08 210.4,42.65 210.29,42.76 210.15,42.9 207.81,42.9 207.63,42.72 207.05,42.72 206.33,42 193.51,42 192.84,42.66 v3(192.68,42.66) 192.42,42.93 190.96,42.93 R4592.2
SPI_SO_EC: length 6.5
  TOP w0.076: U300.G12 235.16,41.75 233.38,41.75 232.51,42.63
  TOP w0.13: 232.51,42.63 232.46,42.67 231.32,42.67 231.25,42.74 230.78,42.74 v3(230.32,43.2) 230.02,42.89 R440.2
SPI_SO_EC_R: length 10.2
  TOP w0.13: v2(226.34,46.78) 226.46,46.9 R425.2 ; R440.1 229.03,43.39 228.91,43.52 226.87,43.52 226.72,43.37 v1(224.63,43.37)
  L3 w0.097: v2(226.34,46.78) 226.34,45.07 v1(224.63,43.37)
SPI_SO_FLH: length 20.1
  TOP w0.13: U3500.24 227.94,54.3 v1(227.94,54.18) 227.94,48.91 227.2,48.17 226.48,48.17 R425.1 R367.2
  L6 w0.127: v1(227.94,54.18) 228.43,54.89 233.99,54.89 v1(234.72,54.17)
  BOTTOM w0.13: v1(234.72,54.17) 234.62,54.27 234.62,55.39 235.31,56.08 U367.2 236.52,56.08 CN367.2
SPI_SO_PCH: length 19
  TOP w0.13: v1(184.71,46.65) 184.71,46.46 v3(187.48,43.69) 187.48,42.98 R4569.1
  BOTTOM w0.076: 183.43,49.36 183.12,49.67 182.4,49.67 179.31,52.76 176.48,52.76 175.24,54 175.24,54.09 175.2,54.13 175.12,54.51 U4555.CF37
  BOTTOM w0.13: v1(184.71,46.65) 185.03,46.97 185.03,47.76 183.43,49.36
SPI_SO_PCH_R: length 44
  TOP w0.13: R367.1 225.84,47.68 225.84,46.38 225.27,45.81 220.77,45.81 218.75,43.79 218.75,43.13 216.85,41.23 214.93,41.23 214.24,40.55 210.33,40.55 209.51,41.37 208.45,41.37 208.27,41.19 207.69,41.19 206.96,40.46 190.8,40.46 190.42,40.85 189.12,40.85 v3(188.85,41.11) R4569.2
SPI_TPM_CS#: length 26.5
  TOP w0.13: R4808.1 194.93,42.84 194.03,43.74 193.35,43.74 192.73,44.37 191.97,44.37 189.53,46.8 v3(189.51,46.8) 187.86,46.8 v1(187.73,46.93)
  BOTTOM w0.076: 184.1,51.36 181.88,51.36 179.65,53.58 176.83,53.58 176.14,54.27 176.14,54.62 176.18,54.75 176.18,54.98 176.18,55 176.14,55.1 176.14,55.94 176.26,56.18 U4555.CH34
  BOTTOM w0.13: 184.1,51.36 187.17,48.3 187.17,47.46 187.57,47.05 187.6,47.05 v1(187.73,46.93)
SPI_TPM_CS#_R: length 38.3
  TOP w0.13: R4808.2 195.66,42.78 206.02,42.78 206.73,43.49 207.31,43.49 207.5,43.67 210.46,43.67 210.69,43.45 210.77,43.36 211.06,43.07 211.29,42.85 212.53,42.85 212.53,42.85 212.71,42.85 213.01,43.15 213.65,43.15 216.05,43.15 216.83,43.93 216.83,44.6 217.26,45.03 217.26,46.33 217.35,46.42 217.35,47.5 217.32,47.54 217.32,48.35 218.33,49.37 v3(218.69,49.37) 219.6,49.37 223.81,53.58 R3516.2 224.53,53.58 224.99,54.04 U3500.20
SPI_TPM_VCC: length 183.2
  TOP w0.254: C3503.1 226.99,61.02 U3500.1 ; C3503.1 226.99,61.39 226.62,61.76 R3503.1 224.71,61.76 224.45,62.01 224.45,62.61 224.11,62.96 222.63,62.96 221.66,61.99 221.66,61.3 221.96,61 C3506.1 222.72,61.03 R3501.1 223.37,60.16 U3500.8 ; C3503.1 227.59,61.03 228.53,60.09 v1(228.53,58.43) ; U3500.22 225.99,54.53 v1(225.65,54.19) ; R4931.1 v1(126.78,73.2) ; C3504.1 v1(228.53,58.43) ; v1(228.53,58.43) 229.08,58.43 C366.1 ; v1(218.97,46.84) R331.2 R368.2 ; R3504.2 221.06,55.62 v1(220.52,55.62) ; v1(220.29,53.79) 219.61,54.47 R3541.1 ; v1(220.29,53.79) 219.83,53.33 219.83,52.56 217.78,50.51 216.41,50.51 214.83,52.08 205.8,52.08 205.32,51.6 202.99,51.6 202.39,52.2 v1(202.39,54.13) ; v1(220.29,53.79) 220.41,53.66 R3517.1 ; v1(224.04,52.27) 224.13,52.36 R3516.1 ; v1(170.85,62.99) 170.3,62.41 C4524.2 C4549.2 170.72,61.27 v1(170.85,61.27) ; R369.2 R418.2 224.02,46.83 v1(223.97,46.78)
  L3 w0.254: v1(218.97,46.84) 221.34,46.84 221.89,46.29 223.49,46.29 v1(223.97,46.78) ; v1(225.65,54.19) 224.79,54.19 224.61,54.01 223.18,54.01 222.78,53.61 221.59,53.61 221.41,53.79 v1(220.29,53.79)
  L5 w0.254: v1(224.04,52.27) 224.04,51.61 225.6,50.05 225.6,49.42 224.02,47.83 v1(223.97,46.78) ; v1(170.85,62.99) 170.85,62.99 170.38,62.51 168.83,62.51 165.66,65.68 163.82,65.68 163.49,66.01 154.27,66.01 154.21,65.95 146.31,65.95 146,66.26 140.46,66.26 140.25,66.47 132.45,66.47 126.78,72.14 v1(126.78,73.2)
  L6 w0.127: 173.28,60.96 173.6,60.64 173.6,57.23 173.99,56.83 174.54,56.83 174.56,56.8 174.56,60.59 174.19,60.96 173.28,60.96 ; 173.28,60.96 173.25,60.96
  L6 w0.254: 173.25,60.96 172.58,60.96 172.27,61.27 v1(170.85,61.27) ; v1(220.52,55.62) 220.02,55.12 220.02,54.05 v1(220.29,53.79) ; v1(202.39,54.13) 202.27,54.01 202.27,53.93 201.22,52.89 195.89,52.89 192.86,55.92 188.57,55.92 187.61,54.96 176.41,54.96 174.56,56.8
  BOTTOM w0.254: 225.32,57.34 225.33,57.34 CN367.8 226.95,57.35 U367.8 228.27,57.35 228.53,57.6 v1(228.53,58.43) ; 225.32,57.34 225.07,57.09 225.07,55.82 224.63,55.39 C321.1 223.67,54.42 224.17,53.92 224.17,53.92 224.65,53.92 224.92,54.19 v1(225.65,54.19) 225.65,54.09 225.14,53.58 225.14,53.34 224.08,52.27 v1(224.04,52.27) ; 225.32,57.34 225.32,57.96 R373.2 ; v1(170.85,62.99) 170.85,63.05 U4555.BV23
SPK_OUT_L_DN: length 13.9
  TOP w0.254: 16.23,38.93 16.27,38.93 17.58,40.25 U500.43
  TOP w1.016: R567.1 7.06,38.99 7.91,39.84 11.78,39.84 12.69,38.93 16.23,38.93
SPK_OUT_L_DP: length 13.5
  TOP w0.254: 16.28,40.2 16.76,40.2 17.21,40.65 U500.42
  TOP w1.016: 16.28,40.2 13.22,40.2 12.3,41.11 7.38,41.11 R550.1
SPK_OUT_L_R_DN: length 5.9
  TOP w0.254: 4.41,38.95 C642.1
  TOP w0.635: v3(2.71,39.18) 3.12,38.77 3.25,38.77 3.32,38.7 3.49,38.7 v5(3.52,38.67) 5.01,38.67
  BOTTOM w0.635: v5(3.52,38.67) 3.4,38.79 CN550.3
SPK_OUT_L_R_DP: length 5.1
  TOP w0.254: C643.1 4.41,40.54 v3(4.34,40.6)
  TOP w0.635: R550.2 4.99,40.6 v3(4.34,40.6) 2.54,40.6 v5(2.4,40.46)
  BOTTOM w0.635: v5(2.4,40.46) CN550.4
SPK_OUT_R_DN: length 11.9
  TOP w0.254: U500.44 17.83,39.85 v1(17.73,39.74) v1(17.29,39.31)
  L6 w1.016: 15.96,40.01 7.92,40.01 7.74,39.83 v5(7.74,38.29)
SPK_OUT_R_DP: length 8.5
  TOP w0.254: v1(17.75,38.85) v1(18.18,39.28) 18.35,39.45 U500.45
  L6 w1.016: 9.01,38.27 9.48,38.74 15.67,38.74
  vias: v1(6.56,36.3) v1(7.3,36.3) v3(7.92,36.64)
SPK_OUT_R_R_DN: length 7.7
  TOP w0.254: C640.1 4.41,37.51
  TOP w0.635: v3(2.71,37.89) 2.73,37.87 2.76,37.87 2.8,37.85 2.97,37.85 3.04,37.78 3.52,37.78 v5(3.53,37.77) 3.55,37.78 4.99,37.78 R566.2
  BOTTOM w0.635: v5(3.53,37.77) 3.77,37.77 3.78,37.78 3.89,37.78 4.41,38.3 4.41,39.04 4.4,39.05 4.4,39.3 CN550.2
SPK_OUT_R_R_DP: length 9.9
  TOP w0.254: 4.41,36.26 C641.1
  TOP w0.635: R551.2 5,35.96 3.39,35.96 v5(3.32,36.03) v3(2.54,36.03)
  BOTTOM w0.635: v5(3.32,36.03) 3.4,36.03 5.4,38.04 CN550.1
SPKR_EN_AB: length 16.8
  TOP w0.076: R515.1 19.08,36.57
  TOP w0.102: 19.08,36.57 19.08,35.3 21.29,33.09 v1(21.29,32.75) ; v1(28.47,35.47) 28.05,35.9 R502.2 R500.2 27.95,37.12 R505.2
  L5 w0.102: v1(28.47,35.47) 28.47,34.96 27.94,34.43 25.22,34.43 24.4,35.24 23.54,35.24 21.29,32.99 v1(21.29,32.75)
SPKR_EN_AB_AUDIO: length 4.4
  TOP w0.102: U500.13 25.14,38.05 25.14,37.13 25.32,36.95 26.27,36.95 26.44,37.12 R505.1 C511.1 26.72,36.15 R516.2
SR1#: length 135.8
  TOP w0.102: v1(241.39,24.96) 240.98,25.37 240.98,26.11 240.91,26.18 239.98,26.18 R1010.1 ; U1000.2 136.98,9.18 136.1,10.06 134.03,10.06 133.22,9.24 v1(133.22,7.86)
  L3 w0.102: v1(241.39,24.96) 241.86,24.5 241.86,24.06 242.38,23.54 242.38,21.48 242.15,21.26 242.15,15.58 236.49,9.92 232.52,9.92 227.55,4.95 227.39,4.95 227.1,4.66 222.56,4.66 221.65,5.58 220.41,5.58 219.3,6.69 215.85,6.69 215.62,6.69 213.84,8.47 192.41,8.47 191.8,9.08 191.21,9.08 177.42,9.08 177.17,8.83 169.33,8.83 169.16,8.66 164.68,8.66 164.46,8.43 163.49,8.43 162.82,8.43 162.74,8.51 162.74,8.51 162.58,8.67 162.22,9.02 162.21,9.04 159.84,9.04 159.84,9.04 159.36,9.04 158.94,9.46 158.09,9.46 157.73,9.1 151.96,9.1 151.02,8.16 150.99,8.16 150.98,8.14 142.43,8.14 141.47,9.1 134.46,9.1 v1(133.22,7.86)
SRTCRST#: length 65.2
  TOP w0.102: v1(177.06,47.42) 178.72,49.08 190.14,49.08 192.43,46.79 194.07,46.79 194.84,46.01 195.74,46.01 196.42,45.34 203.55,45.34 205.01,46.8 209.17,46.8 209.83,46.14 211.5,46.14 211.83,45.81 212.85,45.81 213.51,46.47 v1(213.51,46.83) 213.57,46.89 Q1001.6
  L5 w0.102: v1(213.51,46.83) 214.78,48.1 216.28,48.1 218.21,50.03 218.21,50.87 220.16,52.82 v2(220.39,52.82)
  BOTTOM w0.076: v1(177.06,47.42) 176.91,47.42 176.86,47.47 175.21,49.13 174.97,49.13 174.1,50 173.33,50 171.71,51.62 171,51.62 169.4,53.23 169.39,53.23 169.22,53.35 169.21,53.37 169.04,53.52 168.98,53.65 168.96,53.67 168.94,53.81 168.94,54.45 U4555.BR37
  BOTTOM w0.102: R4834.2 C4764.1 221.91,52.8 221.78,52.67 220.54,52.67 v2(220.39,52.82)
SSD_SUSCLK: length 8.9
  TOP w0.13: v1(264.36,19.27) 264.36,14.37 TP1951.1
  BOTTOM w0.13: v1(264.36,19.27) 264.67,19.58 CN1951.68
SUSCLK32_KBC: length 4.7
  TOP w0.076: U300.L5 239.85,44.24 240.13,44.52 240.13,44.69 240.18,44.75 240.18,45.21 240.51,45.53 240.51,47.39 v3(240.28,47.61) 239.9,48 239.9,48.28 R332.2
SUSCLK32_PCH: length 221.9
  TOP w0.076: v1(239.75,49.38) 239.82,49.31 R332.1
  L3 w0.076: v1(169.53,57.31) 170.12,56.71 170.91,56.71 171.82,55.81 172.5,55.81 173.14,55.16 174.48,55.16 175.74,53.9
  L3 w0.097: 175.74,53.9 177.49,52.15 186.14,52.15 189.12,49.17 195.79,49.17 196.79,50.16 201.41,50.16 203.05,51.8 207.01,51.8 207.41,51.8 210.98,48.23 213.98,48.23 214.58,47.64 215.26,47.64 215.86,48.23 216.9,48.23 216.98,48.16 230.04,48.16 230.38,48.5 231.48,48.5 231.67,48.69 235.8,48.69 235.93,48.82 238.44,48.82 238.45,48.83 239.2,48.83 v1(239.75,49.38)
  L6 w0.127: v1(169.53,57.31) 169.05,57.79 169.05,60.55 167.89,61.72 167.49,61.72 167.49,61.72 136.57,61.72 134.8,63.48 134.57,63.72 128.74,63.72 127.25,62.23 127.25,61.57 123.1,57.42 123.02,57.42 119.6,53.99 119.6,47.49 118.69,46.25 114.64,42.2 104.98,42.2 104.98,42.2 103.04,42.2 93.74,32.9 93.74,31.38 84.77,22.42 67.86,22.42 67.32,22.96 64.87,25.4 58.33,25.4 v1(57.65,26.07)
  BOTTOM w0.13: R1310.1 59.97,26.91 59.55,26.91 59.55,26.91 58.81,26.91 57.98,26.07 v1(57.65,26.07) ; U4555.BT32 v1(169.53,57.31)
SUSCLK32_PCH_WLAN: length 2.9
  BOTTOM w0.13: CN1300.50 62.59,29 v3(61.87,28.28) 61.19,27.6 R1310.2
TACH_FAN1_IN: length 171.3
  TOP w0.076: U300.E10 236.61,40.31 236.93,40.63 v1(236.93,40.64)
  L3 w0.102: v1(97.63,32.87) 97.22,33.28 96.48,33.28 93.58,30.37 86.26,30.37 v1(85.75,30.88)
  BOTTOM w0.076: 232.51,41.14 233.88,41.14 234.02,40.99 236.42,40.99 236.78,40.64 v1(236.93,40.64)
  BOTTOM w0.102: 232.51,41.14 232.36,41.14 232.24,41.26 231.95,41.26 231.39,41.82 230.99,41.82 230.99,41.82 230.32,41.82 229.76,41.26 229.58,41.26 229.49,41.17 228.54,41.17 228.54,41.16 227.73,41.16 226.94,40.38 223.8,40.38 223.73,40.3 219.54,40.3 219.37,40.3 218.45,41.21 214.37,41.21 214.12,40.96 212.8,40.96 210.19,38.35 209.96,38.35 209.37,37.76 206.95,37.76 206.54,37.35 190.05,37.35 185.65,32.96 157.81,32.96 156.27,31.42 105.58,31.42 103.47,33.52 98.28,33.52 v1(97.63,32.87) ; R4301.1 84.69,31.94 v1(85.75,30.88) 84.41,30.88 D4300.1 ; D4300.1 83.08,30.53 83.08,32.02 83.2,32.13 83.34,32.13 83.62,32.42 CN4300.3 ; D4300.1 83.58,29.26 TP4302.1
TBT_CIO_PLUG_EVENT: length 4.2
  TOP w0.076: 250.92,69.33 251.53,69.33 251.7,69.5 253.83,69.5 254.12,69.2 U2700.AA1
  TOP w0.102: 250.92,69.33 250.8,69.33 250.64,69.48 R2722.2
TBT_EE_CLK: length 21.5
  TOP w0.13: v1(250.95,60.92) 250.44,60.92 v3(248.98,59.46) 248.65,59.13 248.65,54.83 247.41,53.59 244.68,53.59 243.19,55.08 243.19,55.09 CN2700.6 U2703.6 ; U2700.Y16 254.36,62.02 v1(254.68,62.34)
  L3 w0.097: v1(254.68,62.34) 252.83,62.34 252.64,62.54 252.23,62.54 251.46,61.76 251.46,61.43 v1(250.95,60.92)
TBT_EE_CS_N: length 23.2
  TOP w0.13: U2703.1 CN2700.1 244.98,65.24 v3(244.98,65.24) 244.83,65.39 R2752.1 244.83,66.67 243.63,67.87 v1(243.43,68.09) ; U2700.W18 255.01,61.37 v1(255.33,61.69)
  L3 w0.097: v1(243.43,68.09) 244.56,68.09 245.01,67.64 248.32,67.64 248.5,67.64 248.86,67.28 249.47,67.28 249.8,66.95 249.8,66.76 249.8,66.76 249.8,66.37 251.78,64.39 252.64,64.39 253.35,63.68 254.89,63.68 255.55,63.02 255.55,62.68 255.73,62.5 255.73,62.09 v1(255.33,61.69)
TBT_EE_DI: length 22.3
  TOP w0.13: v1(254.68,61.69) 254.36,61.37 U2700.Y18 ; U2703.5 CN2700.5 241.17,55.84 242.38,54.63 242.39,54.63 242.67,54.35 242.67,54.35 243.26,53.76 243.37,53.76 244.04,53.08 247.62,53.08 249.16,54.62 249.16,55.05 249.16,58.52 v3(250.34,59.7) v1(250.97,60.34)
  L3 w0.097: v1(250.97,60.34) 251.08,60.45 251.15,60.45 251.93,61.23 251.93,61.3 252.33,61.69 v1(254.68,61.69)
TBT_EE_DO: length 22.1
  TOP w0.13: v1(255.33,62.34) 255.01,62.02 U2700.W16 ; v1(242.82,67.88) 242.82,67.65 243.01,67.46 243.01,66.28 R2753.1 243.18,65.74 v3(243.68,65.24) 243.71,65.22 CN2700.2 U2703.2
  L3 w0.097: v1(242.82,67.88) 243.03,67.68 244.65,67.68 244.92,67.41 248.41,67.41 248.77,67.06 249.37,67.06 249.57,66.86 249.57,66.28 252.4,63.46 254.8,63.46 255.33,62.93 v1(255.33,62.34)
TBT_EE_WP_N: length 20.8
  TOP w0.13: v1(255.34,67.55) U2700.W4 ; U2703.3 CN2700.3 242.44,65.19 v3(242.39,65.24) 242.38,65.25 242.38,66.11 242.75,66.47 242.75,67.36 242.4,67.71 242.4,68.06 242.6,68.26 242.6,68.28 v1(242.82,68.49)
  L3 w0.097: v1(255.34,67.55) 254.93,67.95 253.29,67.95 252.59,67.25 249.82,67.25 249.56,67.5 248.95,67.5 248.6,67.86 248.23,67.86 248.23,67.86 245.1,67.86 244.47,68.49 243.03,68.49 v1(242.82,68.49)
TBT_FORCE_PWR: length 89.3
  TOP w0.076: U2700.V4 v1(255.99,67.55)
  TOP w0.102: v1(247.45,68.87) 247.78,69.2 248.18,69.2 248.45,68.93 R2739.2 v1(249.12,69.18) R2711.2 ; v1(232.53,65.5) 231.89,66.14 219.78,66.14 219.78,66.14 216.73,66.14 216.1,65.5 216.1,65.5 216.01,65.42 212.08,65.42 211.95,65.29 209.06,65.29 v1(208.51,64.73)
  L3 w0.076: 180.51,64.16 178.19,64.16 178.15,64.12 176.15,64.12 v1(175.5,63.47)
  L3 w0.102: v1(208.51,64.73) 207.64,64.73 205.86,62.96 204.91,62.96 204.3,62.35 203.36,62.35 202.49,63.21 198.5,63.21 198.49,63.22 198.46,63.22 198.42,63.26 197.9,63.26 197.61,63.55 195.54,63.55 195.16,63.17 194.51,63.17 194.13,63.55 194.06,63.55 193.97,63.64 185.85,63.64 185.35,63.14 181.79,63.14 180.77,64.16 180.51,64.16
  L5 w0.102: v1(232.53,65.5) 233.11,65.5 234.25,64.35 242.38,64.35 246.7,68.67 247.25,68.67 v1(247.45,68.87)
  BOTTOM w0.076: v1(255.99,67.55) 255.99,67.57 255.17,68.39 251.96,68.39
  BOTTOM w0.089: v1(175.5,63.47) 175.45,63.5 U4555.CF22
  BOTTOM w0.102: v1(249.12,69.18) 249.91,68.39 251.96,68.39
TBT_HOLD_N: length 6.1
  TOP w0.102: R2751.1 247.13,54.09 v3(246.22,54.09) 245.5,54.09 CN2700.7 U2703.7
TBT_I2C_SCL: length 77.4
  TOP w0.076: R2725.2 252.04,71.7 v1(252.04,71.13) 252.82,70.35 254.19,70.35 255.28,69.27 255.28,68.8 U2700.V2 ; v1(265.1,25.73) 264.47,25.73 264.12,26.08 263.32,26.08 U2403.E2
  L6 w0.127: v1(252.04,71.13) 252.04,71.28 252.5,71.74 262.27,71.74 265.12,68.88 265.12,68.19 265.12,68.19 265.12,58.75 261.81,55.44 261.81,54.88 263.24,53.45 263.24,52.46 263.24,52.46 263.24,51.94 263.77,51.41 263.77,46.23 264.39,45.61 264.39,45.4 264.39,42.57 265.72,41.24 265.72,37.78 264.15,36.21 264.15,31.31 264.15,31.1 263.34,30.3 263.34,27.15 264.77,25.73 v1(265.1,25.73)
  BOTTOM w0.13: CN2701.10 252.04,77.15 252.17,77.02 252.17,73.28 252.49,72.96 252.49,72.23 v3(252.46,72.2) 252.04,71.78 v1(252.04,71.13)
TBT_I2C_SDA: length 79.8
  TOP w0.076: U2700.V1 255.5,69.3 254.27,70.53 253.26,70.53 v1(252.63,71.16) ; U2403.D2 263.07,25.8 263.29,25.58 263.94,25.58 264.74,24.78 v1(265.15,24.78)
  TOP w0.102: v1(252.63,71.16) 252.52,71.26 252.52,72.02
  TOP w0.13: R2724.2 252.22,73.95 252.52,73.65 252.52,72.02
  L6 w0.127: v1(252.63,71.16) 252.95,71.48 262.16,71.48 264.87,68.78 264.87,58.86 261.55,55.54 261.55,54.78 262.98,53.35 262.98,51.83 263.51,51.31 263.51,46.13 264.13,45.51 264.13,42.47 265.46,41.13 265.46,37.89 263.89,36.32 263.89,31.21 263.09,30.4 263.09,26.66 264.97,24.78 v1(265.15,24.78)
  BOTTOM w0.13: CN2701.9 252.25,77.65 252.66,77.23 252.66,74.11 v3(252.69,74.08) 252.99,73.78 252.99,71.53 v1(252.63,71.16)
TBT_MRESET: length 130.1
  TOP w0.076: U300.F5 240.18,40.64 v1(240.18,39.99)
  TOP w0.102: v1(270.98,77.38) 270.8,77.2 R2742.2 ; R352.1 240.48,34.33 241.27,35.12 v1(241.53,35.12)
  L3 w0.076: 241.32,35.32 240.65,35.99 240.65,37.55 241.35,38.25 241.35,39.35 240.71,39.99 v1(240.18,39.99)
  L3 w0.102: v2(240.93,22.71) 240.93,23.54 239.28,25.18 239.28,28.06 239.5,28.27 239.5,29.05 240.13,29.68 241.78,29.68 242.13,30.04 242.13,34.51 v1(241.53,35.12) 241.32,35.32 ; v1(246.24,20.79) 246.11,20.66 246.11,15.16 248.6,12.66 262.2,12.66 263.27,13.74 263.27,17.59 263.5,17.82 263.5,20.76 262.86,21.4 261.96,21.4 261.41,21.95 260.14,23.22 260.14,24.58 260.75,25.18 260.75,25.52 260.72,25.54 260.72,28.81 261.85,29.93 261.85,31.37 262.08,31.61 262.42,31.61 262.59,31.79 263.98,31.79 273.44,41.25 273.44,42.27 273.15,42.56 273.15,48.18 271.07,50.26 271.07,70.15 271.07,70.72 271.4,71.04 271.4,71.75 271.4,72.55 271.62,72.77 271.62,76.7 v1(270.98,77.38)
  L5 w0.102: v2(240.93,22.71) 241.56,22.71 243.33,20.94 243.33,20.67 243.84,20.16 245.6,20.16 v1(246.24,20.79)
TBT_PCIE_WAKE_N: length 10.3
  TOP w0.076: 250.99,69.88 251.2,69.67 253.9,69.67 254.35,69.21 254.35,68.8 U2700.Y2
  TOP w0.102: 249.42,69.88 249.41,69.9 Q2701.4 ; 249.42,69.88 250.39,69.88 ; 249.42,69.88 249.33,69.79 R2760.2 248.45,70.4 R2759.1 R2705.1 247.57,70.4 v3(247.14,70.83) ; 250.39,69.88 250.41,69.9 Q2701.6 ; 250.39,69.88 250.99,69.88
TBT_SVR_IND:
  vias: v3(258.44,73.34)
TBT_TCK: length 5.9
  TOP w0.13: v1(255.33,61.04) U2700.W19
  BOTTOM w0.13: R2745.2 252.88,58.61 TP2703.1 253.53,59.26 254.87,59.26 255.77,60.16 255.77,60.6 v1(255.33,61.04)
TBT_TDI: length 4.3
  TOP w0.13: v1(255.33,60.39) U2700.W20
  BOTTOM w0.13: R2743.2 252.42,59.68 252.73,59.68 252.8,59.76 TP2700.1 254.7,59.76 v1(255.33,60.39)
TBT_TDO: length 3.7
  TOP w0.13: v1(254.69,61.05) 254.36,60.72 U2700.Y19
  BOTTOM w0.13: R2746.2 252.03,60.82 252.98,60.82 253.05,60.89 253.38,60.89 TP2704.1 254.2,61.53 v1(254.69,61.05)
TBT_TMS: length 3.4
  TOP w0.13: U2700.Y20 254.36,60.07 v1(254.68,60.39)
  BOTTOM w0.13: v1(254.68,60.39) TP2701.1 253.13,60.39 252.64,59.9 252,59.9 R2744.2
TBT_TMU_CLK_OUT: length 8.9
  TOP w0.076: U2700.Y1 254.58,69.23 253.98,69.83 251.72,69.83 250.92,70.63
  TOP w0.13: 250.92,70.63 250.87,70.68 250.87,72.55 R2740.2 250.59,72.84 R2775.2 250.59,74.16 R2703.2 250.64,74.21 v3(250.64,74.92)
TBT_USB_FORCE_PWR: length 5.2
  TOP w0.076: v1(255.98,66.91) U2700.V5
  BOTTOM w0.076: v1(255.98,66.91) 255.5,66.43 255.5,66.15 254.51,65.15 254.1,65.15 253.91,65.34 R2731.2 R2727.2 253.59,64.08 v3(253.64,64.02)
TBT_WAKE#_PCH: length 84.4
  TOP w0.102: R2705.2 247.85,71.34 v1(248.13,71.62) 248.64,72.13 248.95,72.13 249.16,72.33 250.16,72.33 250.16,72.33 250.24,72.33 250.41,72.16 Q2701.1
  L3 w0.102: v1(217.73,80.48) 218.13,80.08 218.13,79.3 221.69,75.74 229.94,75.74 231.6,74.08 233.82,74.08 236.33,71.57 244.99,71.57 245.5,71.06 247.73,71.06 248.13,71.46 v1(248.13,71.62)
  L6 w0.102: v1(191.34,71.13) 192.52,72.32 196.92,72.32 197.27,71.96 199.14,71.96 202,74.82 207.03,74.82 207.08,74.76 212.44,74.76 212.92,75.24 212.92,75.52 217.32,79.93 217.32,80.04 217.73,80.45 v1(217.73,80.48)
  BOTTOM w0.076: U4555.CM12 178.69,70.33 178.96,70.6 179.54,70.6 179.63,70.51 179.89,70.51 179.89,70.5 180.03,70.46 180.23,70.46 180.36,70.5 181.61,70.5 181.95,70.16 182.37,70.16 182.95,69.58 184.24,69.58 184.68,70.02 184.68,70.29 v3(185.28,70.89) 185.59,71.2 188,71.2
  BOTTOM w0.102: 188,71.2 188.26,71.2 R4535.2 188.39,71.38 188.66,71.65 190.82,71.65 v1(191.34,71.13)
TBT_XTAL_25_IN: length 5.4
  TOP w0.076: v1(261.97,57.16) 262,57.19 262,58.46 261.72,58.74 261.72,59.14 U2700.D22
  BOTTOM w0.13: v1(261.97,57.16) 261.97,55.67 v3(262.26,55.37) 262.54,55.1 L2700.1
TBT_XTAL_25_OUT: length 3.8
  TOP w0.076: U2700.D23 262.2,58.65 262.2,57.85 v1(262.63,57.42)
  BOTTOM w0.13: v1(262.63,57.42) 262.63,56.23 R2748.1
TBT_XTAL_25_R_IN: length 2.5
  BOTTOM w0.13: X2700.3 265.15,54.8 264.74,54.8 264.57,54.97 C2744.1 264.41,55.1 L2700.2
TBT_XTAL_25_R_OUT: length 4.3
  BOTTOM w0.13: R2748.2 263.78,55.75 C2745.1 264.76,55.75 265.06,55.45 266.59,55.45 X2700.1
TBTA_AUX_DN: length 80.9
  TOP w0.076: v1(259.89,67.55) U2700.J4 ; U2403.C11 258.4,25.16 257.65,25.16 257.43,25.39 256.77,25.39 256.75,25.41 256.73,25.41
  TOP w0.104: 256.73,25.41 253.05,25.41 252.85,25.21 251.95,25.21 v1(251.69,25.47) 251.45,25.24 250.34,25.24 R2428.1 ; R2656.2 253.51,19.9 253.51,19.76 253.41,19.65 v6(249.12,19.65) 247.26,19.65 246.93,19.33 246.93,19.14 246.71,18.91 v1(246.57,18.91)
  L3 w0.097: v1(259.89,67.55) 260.12,67.78 260.12,68.03 260.34,68.24 261.99,68.24 263.3,66.94 263.3,50.54 262.96,50.2 262.96,39.71 256.06,32.81 256.06,31.98 254.47,30.39 253.94,30.39 252.79,29.24 252.02,29.24 250.79,28.01 250.48,28.01 250.13,27.66 250.13,26.26 250.91,25.47 v1(251.69,25.47)
  BOTTOM w0.104: v1(246.57,18.91) 246.57,20.55 246.64,20.62 246.64,22.44 249.25,25.05 251.26,25.05 v1(251.69,25.47)
TBTA_AUX_DP: length 80.9
  TOP w0.076: 256.73,25.2 256.75,25.2 256.77,25.22 257.36,25.22 257.58,25 258.4,25 U2403.B11 ; v1(260.54,67.55) U2700.H4
  TOP w0.104: v1(247.45,18.91) 247.32,18.91 247.14,19.1 247.14,19.24 247.34,19.45 v6(251.02,19.45) 253.5,19.45 253.72,19.67 253.72,19.9 R2655.2 ; 256.73,25.2 253.14,25.2 252.94,25.01 251.95,25.01 v1(251.69,24.74) 251.4,25.03 250.35,25.03 R2425.1
  L3 w0.097: v1(251.69,24.74) 251.69,24.9 251.31,25.28 250.83,25.28 249.93,26.17 249.93,27.74 250.4,28.21 250.71,28.21 251.94,29.44 252.71,29.44 253.85,30.59 254.39,30.59 255.86,32.06 255.86,32.89 262.76,39.79 262.76,50.28 263.1,50.62 263.1,66.86 261.91,68.05 260.42,68.05 260.32,67.95 260.32,67.71 260.49,67.55 v1(260.54,67.55)
  BOTTOM w0.104: v1(247.45,18.91) 247.15,18.91 246.78,19.28 246.78,20.46 246.85,20.54 246.85,22.35 249.34,24.84 251.59,24.84 v1(251.69,24.74)
TBTA_AUX_R_DN: length 7.5
  TOP w0.076: 256.73,23.2 256.75,23.2 256.77,23.18 257.91,23.18 258.75,24.02 258.75,24.15 U2403.A11
  TOP w0.104: R2656.1 253.47,21.4 253.47,21.92 253.77,22.22 254.75,23.2 v6(255.57,23.2) 256.73,23.2
TBTA_AUX_R_DP: length 7.5
  TOP w0.076: U2403.A10 258.91,24.17 258.91,23.95 257.97,23.02 256.77,23.02 256.75,23 256.73,23
  TOP w0.104: 256.73,23 254.84,23 v6(253.97,22.13) 253.97,22.13 253.67,21.83 253.67,21.51 R2655.1
TBTA_CA2HD_0_C_DN: length 10.6
  TOP w0.104: R2715.1 267.1,59 arc(267.14,58.89) 267.25,58.84 267.75,58.84 267.75,58.84 267.96,58.84 arc(268.14,58.92) v1(268.22,59.1)
  BOTTOM w0.104: C2737.2 275.13,63.24 275.11,63.21 D2905.1 arc(274.64,63.04) 274.34,62.98 274.02,62.98 arc(273.98,62.97) 273.95,62.95 273.92,62.92 arc(273.84,62.87) 273.75,62.85 273.5,62.85 arc(273.36,62.82) 273.24,62.74 269.73,59.24 arc(269.33,58.96) 268.85,58.84 arc(268.82,58.84) 268.78,58.84 268.48,58.84 arc(268.3,58.92) v1(268.22,59.1)
TBTA_CA2HD_0_C_DP: length 10.6
  TOP w0.104: v1(268.22,58.37) arc(268.14,58.56) 267.96,58.64 267.66,58.64 267.3,58.64 arc(267.16,58.58) R2713.1
  BOTTOM w0.104: C2736.2 275.18,62.63 275.11,62.55 D2904.1 arc(274.64,62.72) 274.34,62.78 274.06,62.78 arc(273.92,62.68) 273.75,62.65 273.5,62.65 arc(273.44,62.63) 273.39,62.6 269.88,59.09 arc(269.41,58.77) 268.87,58.64 268.48,58.64 arc(268.3,58.56) v1(268.22,58.37)
TBTA_CA2HD_0_DN: length 12.6
  TOP w0.104: CN2900.B10 282.64,61.73 284.33,61.73 arc(284.39,61.72) 284.45,61.68 284.47,61.66 arc(284.48,61.65) 284.49,61.64 arc(284.52,61.62) 284.54,61.59 284.81,61.33 arc(284.85,61.3) v1(284.9,61.29)
  BOTTOM w0.104: v1(284.9,61.29) 284.78,61.29 284.53,61.53 arc(284.44,61.6) 284.34,61.66 arc(284.34,61.66) 284.34,61.66 arc(284.3,61.68) 284.25,61.69 284.12,61.71 arc(284.11,61.71) 284.1,61.71 283.29,61.71 arc(283.07,61.67) 282.89,61.55 282.74,61.4 arc(282.43,61.19) 282.06,61.11 279.43,61.11 arc(279.32,61.14) 279.22,61.2 277.56,62.86 arc(277.39,62.97) 277.19,63.01 276.87,63.01 arc(276.71,63.08) R2640.1 276.64,63.24 C2737.1
TBTA_CA2HD_0_DP: length 12.6
  TOP w0.104: CN2900.B11 283.08,61.31 arc(283.14,61.33) 283.18,61.36 283.33,61.5 arc(283.36,61.52) 283.4,61.53 284.24,61.53 arc(284.37,61.48) 284.42,61.35 v1(284.42,60.8)
  BOTTOM w0.104: C2736.1 276.64,62.63 R2641.1 arc(276.7,62.75) 276.83,62.81 277.19,62.81 arc(277.31,62.78) 277.42,62.71 279.07,61.05 arc(279.24,60.95) 279.43,60.91 282.06,60.91 arc(282.51,61) 282.89,61.25 283.04,61.4 arc(283.15,61.48) 283.29,61.51 284.1,61.51 284.21,61.49 arc(284.23,61.48) 284.26,61.47 arc(284.33,61.43) 284.38,61.39 284.48,61.29 284.48,60.94 arc(284.46,60.87) v1(284.42,60.8)
TBTA_CA2HD_0_R_DN: length 4.4
  TOP w0.076: 265.54,59.03 265.53,59.05 265.5,59.05 264.91,59.64 arc(264.82,59.7) 264.72,59.72 263.9,59.72 263.81,59.74 arc(263.75,59.8) 263.71,59.87 263.55,60.03 arc(263.51,60.05) 263.47,60.06 263.26,60.06 arc(263.15,59.99) 263.17,59.87 263.21,59.83 U2700.A21
  TOP w0.104: 265.54,59.03 265.71,58.87 266.42,58.87 arc(266.55,58.92) R2715.2
TBTA_CA2HD_0_R_DP: length 4.3
  TOP w0.076: 265.4,58.89 265.38,58.9 265.38,58.93 264.79,59.52 arc(264.76,59.55) 264.72,59.55 263.88,59.55 263.67,59.6 arc(263.62,59.61) 263.57,59.6 263.56,59.6 263.22,59.6 arc(263.1,59.63) 263,59.69 U2700.B21
  TOP w0.104: 265.4,58.89 265.62,58.66 266.37,58.66 arc(266.53,58.59) R2713.2
TBTA_CA2HD_1_C_DN: length 10.6
  TOP w0.104: C2743.2 274.91,67.65 D2903.1 274.17,67.77 arc(274.04,67.85) 273.89,67.88 273.48,67.88 arc(273.34,67.85) 273.22,67.77 271.69,66.24 arc(271.59,66.1) 271.56,65.93 271.56,65.93 arc(271.47,65.5) 271.23,65.14 268.52,62.43 arc(268.34,62.31) 268.13,62.27 267.27,62.27 arc(267.15,62.22) R2719.1
TBTA_CA2HD_1_C_DP: length 10.7
  TOP w0.104: R2718.1 267.1,62.7 arc(267.16,62.54) 267.32,62.47 268.13,62.47 arc(268.26,62.5) 268.37,62.57 271.08,65.29 arc(271.28,65.58) 271.35,65.93 271.35,65.93 arc(271.4,66.18) 271.54,66.39 273.07,67.92 arc(273.26,68.04) 273.48,68.09 273.91,68.09 arc(274.04,68.11) 274.16,68.19 D2902.1 274.31,68.29 C2742.2
TBTA_CA2HD_1_DN: length 6.7
  TOP w0.104: C2743.1 275.43,67.67 R2642.2 arc(276.1,67.82) 276.25,67.88 277.04,67.88 arc(277.09,67.87) 277.14,67.84 279.14,65.85 arc(279.28,65.75) 279.46,65.71 280.13,65.71 arc(280.28,65.68) 280.41,65.6 280.41,65.6 arc(280.44,65.57) 280.48,65.57 CN2900.A10
TBTA_CA2HD_1_DP: length 6.7
  TOP w0.104: C2742.1 275.43,68.29 R2643.2 arc(276.1,68.15) 276.24,68.09 277.04,68.09 arc(277.17,68.06) 277.29,67.98 279.28,65.99 arc(279.36,65.94) 279.46,65.92 280.15,65.92 arc(280.28,65.94) 280.4,66.02 arc(280.45,66.05) 280.51,66.07 CN2900.A11
TBTA_CA2HD_1_R_DN: length 4.1
  TOP w0.076: 265.55,62.29 265.53,62.29 265.51,62.31 265.06,62.31 arc(264.93,62.34) 264.83,62.41 arc(264.7,62.49) 264.54,62.53 263.71,62.53 263.71,62.53 arc(263.68,62.52) 263.66,62.5 263.58,62.42 arc(263.51,62.38) 263.44,62.36 263.22,62.36 arc(263.1,62.39) 263,62.45 U2700.B15
  TOP w0.104: 265.55,62.29 266.4,62.29 arc(266.54,62.23) R2719.2
TBTA_CA2HD_1_R_DP: length 4
  TOP w0.076: 265.55,62.5 265.53,62.5 265.51,62.48 265.06,62.48 arc(264.99,62.49) 264.94,62.52 arc(264.76,62.65) 264.54,62.69 263.69,62.69 263.56,62.82 263.25,62.82 arc(263.15,62.75) 263.17,62.62 263.2,62.59 U2700.A15
  TOP w0.104: 265.55,62.5 266.4,62.5 arc(266.54,62.56) R2718.2
TBTA_CAP: length 2.8
  TOP w0.102: U2602.D4 265.03,39.63 C2613.1 265.1,39.61 265.37,39.33 265.37,39.13 265.58,38.92 v3(265.58,37.89)
TBTA_FO: length 31
  TOP w0.102: v1(256.56,34.2) 256.69,34.08 R2633.1 256.85,33.75 R2401.1 ; U2602.C4 v1(264.81,40.13)
  L3 w0.102: v1(264.81,40.13) 264.91,40.22 271.15,40.22 v1(273.03,42.1)
  L5 w0.102: v1(256.56,34.2) 264.23,34.2 266.03,36.01 266.87,36.01 270.08,39.21 270.14,39.21 v1(273.03,42.1)
TBTA_FO_R: length 5.1
  TOP w0.076: 260.57,30.15 U2403.L7
  TOP w0.102: R2401.2 257.83,32.9 257.93,32.8 257.93,32.8 258.52,32.21 v3(258.52,32.17) 258.74,32.17 260.57,30.34 260.57,30.15
TBTA_HD2CA_0_C_DN: length 10.7
  TOP w0.104: C2739.2 276.14,63.08 arc(276.06,63.03) 275.97,63.01 275.53,63.01 arc(275.39,63.07) D2901.1 275.29,63.17 arc(275.07,63.03) 274.82,62.98 274.27,62.98 arc(274.1,62.95) 273.96,62.85 271.13,62.85 arc(271,62.83) 270.89,62.75 268.28,60.15 arc(268.21,60.1) 268.13,60.09 267.28,60.09 arc(267.15,60.14) R2714.1
TBTA_HD2CA_0_C_DP: length 10.8
  TOP w0.104: C2738.2 276.23,62.7 arc(276.11,62.78) 275.97,62.8 275.58,62.8 arc(275.4,62.73) D2900.1 275.29,62.58 arc(275.08,62.73) 274.82,62.78 274.27,62.78 arc(274.18,62.76) 274.11,62.71 274.08,62.68 arc(274.04,62.65) 274,62.65 271.13,62.65 arc(271.08,62.64) 271.03,62.61 268.43,60 arc(268.29,59.91) 268.13,59.88 267.32,59.88 arc(267.16,59.81) R2716.1
TBTA_HD2CA_0_DN: length 4.9
  TOP w0.104: C2739.1 276.8,63.24 R2623.2 arc(277.47,63.09) 277.62,63.03 278.11,63.03 arc(278.27,63) 278.39,62.92 279.4,61.91 arc(279.45,61.88) 279.51,61.87 280.49,61.87 280.51,61.9 280.78,61.9 arc(280.93,61.96) CN2900.A3
TBTA_HD2CA_0_DP: length 4.9
  TOP w0.104: C2738.1 276.8,62.62 R2609.2 arc(277.47,62.77) 277.62,62.83 278.11,62.83 arc(278.19,62.81) 278.25,62.77 279.25,61.77 arc(279.37,61.69) 279.51,61.66 280.82,61.66 arc(280.95,61.64) CN2900.A2
TBTA_HD2CA_0_R_DN: length 4.2
  TOP w0.076: 265.52,60.15 265.5,60.16 265.48,60.16 264.97,60.67 arc(264.87,60.73) 264.75,60.76 264.05,60.76 264.05,60.76 263.86,60.76 arc(263.76,60.78) 263.68,60.83 263.63,60.88 arc(263.52,60.95) 263.39,60.98 263.25,60.98 arc(263.1,60.95) 262.98,60.87 U2700.B19
  TOP w0.104: 265.52,60.15 265.58,60.09 266.42,60.09 arc(266.55,60.14) R2714.2
TBTA_HD2CA_0_R_DP: length 4.3
  TOP w0.076: U2700.A19 263.24,60.75 arc(263.15,60.72) 263.12,60.63 arc(263.15,60.55) 263.22,60.52 263.39,60.52 arc(263.57,60.54) 263.74,60.59 263.86,60.59 263.98,60.59 264.75,60.59 arc(264.81,60.58) 264.85,60.55 265.36,60.04 265.36,60.01 265.37,60
  TOP w0.104: 265.37,60 265.49,59.88 266.37,59.88 arc(266.53,59.81) R2716.2
TBTA_HD2CA_1_C_DN: length 12.3
  TOP w0.104: v1(268.22,60.81) arc(268.14,61) 267.96,61.07 267.66,61.07 267.3,61.07 arc(267.16,61.02) R2720.1
  BOTTOM w0.104: C2740.2 274.9,67.65 D2907.1 arc(274.06,67.8) 273.79,67.86 273.53,67.86 arc(273.31,67.81) 273.12,67.69 272.44,67.01 arc(272.12,66.53) 272.01,65.96 272.01,64.76 arc(271.92,64.3) 271.66,63.92 268.93,61.19 arc(268.8,61.1) 268.65,61.07 268.48,61.07 arc(268.3,61) v1(268.22,60.81)
