# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DEV_MODE_DET_EC: length 4.7
  TOP w0.076: U300.M2 241.8,45.87 241.17,46.5 241.17,48 v3(241.47,48.3) 241.47,48.66 R334.1
DEVSLP1: length 134
  TOP w0.076: v1(186.69,72.57) 186.67,72.55 182.68,72.55 v1(182.29,72.17)
  TOP w0.102: v1(243.94,21.53) 245.76,19.71 245.76,14.98 248.15,12.58 254.9,12.58 255.26,12.94 255.26,16.16 256.72,17.62 257.99,17.62 v2(258.74,16.87)
  L6 w0.102: v1(243.94,21.53) 242.13,23.33 239.84,23.33 237.84,25.33 237.84,25.67 237.84,25.67 237.84,30 236.22,31.63 236.22,32.24 235.62,32.83 233.52,32.83 233.19,33.16 232.62,33.16 232.62,33.16 232.34,33.16 232.14,33.36 230.16,33.36 228.59,34.94 227.7,34.94 227.7,34.94 227.53,34.94 226.39,36.08 226.02,36.08 224.66,37.45 224.66,37.98 224.66,38.1 224.39,38.37 223.08,38.37 221.92,39.53 221.92,39.74 220.7,40.96 220.7,41.25 219.78,42.16 219.78,46.89 215.11,51.57 215.11,54.78 214.49,55.41 214.49,58.66 214.79,58.96 214.79,66.16 211.16,69.79 209.6,69.79 209.01,69.2 207.99,69.2 207.51,69.68 207.51,70.14 205,72.66 205,73.15 204.76,73.38 202.62,73.38 201.77,72.54 201.77,71.9 202.12,71.55 202.12,71.05 201.45,70.37 198.43,70.37 188.89,70.37 v1(186.69,72.57)
  BOTTOM w0.076: U4555.CR8 180.63,72.76 180.73,72.87 181.6,72.87 v1(182.29,72.17)
  BOTTOM w0.102: CN1951.38 257.4,18.21 v2(258.74,16.87)
DG_GPIO_0: length 8.7
  TOP w0.076: U2700.W1 255.04,69.25 254.12,70.17 252.19,70.17 251.74,70.63
  TOP w0.102: 251.74,70.63 251.63,70.73 251.63,73.57 251.28,73.92 R2738.2 251.23,74 v3(251.91,74.69)
DG_GPIO_1: length 6
  TOP w0.076: R2741.2 251.23,70.73 251.95,70.01 254.06,70.01 254.82,69.25 254.82,68.8 U2700.W2
DG_TMU_CLKIN: length 8.2
  TOP w0.076: U2700.W6 v1(254.69,66.9)
  TOP w0.102: R2730.2 v1(249.12,68.57) R2737.2
  BOTTOM w0.076: 251.96,68.06 253.56,68.06 v3(254,67.63) 254.69,66.94 v1(254.69,66.9)
  BOTTOM w0.102: v1(249.12,68.57) 249.63,68.06 251.96,68.06
DGPU_HOLD_RST#: length 11.4
  TOP w0.076: v1(178.07,74.22) 178.39,74.54 183.6,74.54 183.79,74.35 187.17,74.35 187.77,73.75 188.08,73.75
  TOP w0.102: 188.08,73.75 TP4521.1
  BOTTOM w0.076: U4555.CK6 177.67,73.82 v1(178.07,74.22)
DGPU_PRSNT#: length 12.2
  TOP w0.076: v1(178.08,74.88) 178.26,74.7 183.67,74.7 183.86,74.51 187.24,74.51 187.31,74.45 187.38,74.45
  TOP w0.102: 187.38,74.45 189.21,74.45 TP4520.1
  BOTTOM w0.076: v1(178.08,74.88) 177.68,74.47 U4555.CK5
DGPU_PWR_EN#: length 6.9
  TOP w0.076: TP4519.1 183.68,73.04 178.5,73.04 178.12,72.66 v1(178.02,72.66)
  BOTTOM w0.076: U4555.CK8 177.92,72.52 v1(178.02,72.66)
DGPU_PWRGD: length 8.5
  TOP w0.076: v1(178,72.07) 178.83,72.88 184.8,72.88 TP4518.1
  BOTTOM w0.076: U4555.CK9 177.83,71.87 178,72.03 v1(178,72.07)
DIS_DPWROK: length 3.8
  BOTTOM w0.102: v3(213.13,99.63) 213.73,99.63 Q1002.3 213.87,98.93 R1017.1 214.65,98.89 Q1002.2
DIS_DPWROK#: length 3.4
  BOTTOM w0.102: v3(214.22,103.75) 214.44,103.52 R1015.1 214.44,101.92 R1016.2 214.65,101.71 Q1002.5
DIS_P1V8S: length 1.8
  BOTTOM w0.254: Q7011.D 209.58,74.95 R7038.1 v3(208.02,74.95)
DIS_P3V3A_PRIME: length 3.1
  TOP w0.102: v3(218.41,90.57) R7001.1 217.15,91 Q7006.D
DIS_P3V3S_LCDVDD: length 6.3
  TOP w0.254: R3029.1 53.3,7.44 52.19,7.44 51.29,8.34 51.29,9.77 v2(51.78,10.25)
  BOTTOM w0.254: U3000.4 v2(51.78,10.25)
DIS_P3V3S_TOUCH_VCC: length 2.1
  TOP w0.102: R3031.1 20.9,16.32 21.33,16.76 21.33,17.52 21.7,17.88 Q3001.6
DIS_P5V0S: length 2.8
  BOTTOM w0.254: Q7005.6 195.94,92.69 196.19,92.94 196.68,92.94 v3(197.18,93.44) 196.7,93.91 R7014.1
DIS_PVCCSTG: length 1.1
  BOTTOM w0.102: R7013.1 159.44,95.79 v3(159.18,96.05)
DIS_PVCCSTG_EN: length 3.9
  BOTTOM w0.102: v3(159.43,99.63) 159.28,99.48 R7010.2 160.68,98.92 ; 160.68,98.92 Q7000.2 ; 160.68,98.92 161.08,98.92 161.18,98.82 Q7000.3
DISP_RCOMP: length 3.3
  TOP w0.254: v1(154.93,74.05) 154.91,74.03 154.69,74.03 154.52,73.86 154.52,73.82 154.45,73.76 154.45,73.2 154.43,73.18 154.43,72.98 154.42,72.96 154.42,72.56 154.07,72.22 R4544.2
  BOTTOM w0.254: v1(154.93,74.05) 154.92,74.04 U4555.AM6
DMIC_CLK0: length 70.6
  TOP w0.13: v1(218.72,68.62) 218.45,68.35 216.15,68.35 216.04,68.24 215.28,67.48 213.37,67.48 212.8,68.04 209.96,68.04 209.52,67.6 208.43,67.6 207.88,67.05 192.02,67.05 R4551.2
  BOTTOM w0.13: CN3001.10 223.89,102.25 223.88,102.26 221.32,102.26 221.27,102.31 220.3,102.31 R3012.1 220.11,102.04 217.33,99.26 217.33,88.68 218.44,87.57 218.74,87.27 218.74,83.29 216.43,80.98 216.43,80.34 217.75,79.02 217.75,77.68 218.5,76.93 219.42,76.01 219.42,71.36 218.72,70.65 v1(218.72,68.62)
DMIC_CLK0_DB: length 94.3
  TOP w0.13: v2(60.22,56.25) 60.22,54.73 61,53.95 61,53.17 59.87,52.05 CN9354.5 ; MIC9352.2 60.22,45.55 v1(59.71,46.05) ; MIC9350.2 61.22,115.35 61.22,114.97 61.48,114.71 61.48,114.41 v1(61.9,113.99)
  L3 w0.097: v1(61.9,113.99) 61.52,113.61 61.52,100.71 60.49,99.69 60.49,68.54 60.08,68.13 60.08,65.84 60.83,65.08 60.83,63.65 60.93,63.55 61.32,63.16 61.32,59.41 61.52,59.22 61.52,57.44 60.32,56.25 v2(60.22,56.25) 60.22,53.98 61.72,52.48 61.72,51.95 61.31,51.55 61.03,51.55 60.91,51.43 60.91,50.63 61.01,50.54 61.43,50.54 61.52,50.44 61.52,47.54 61.07,47.08 61.07,45.41 60.91,45.25 60.91,43.57 60.81,43.47 60.52,43.47 60.43,43.57 60.43,45.81 60.59,45.98 60.59,47.66 60.43,47.82 60.43,49.63 60.33,49.72 60.03,49.72 59.73,49.43 59.73,47.69 60.11,47.31 60.11,46.46 v1(59.71,46.05)
DMIC_CLK1: length 66.6
  TOP w0.13: R4513.1 194.23,62.04 194.23,62.04 195.76,63.57 195.76,64.01 197.51,65.76 v3(199.74,65.76) 203.62,65.76 206.06,65.76 206.07,65.77 208.41,65.77 208.96,66.32 210.05,66.32 210.49,66.76 212.27,66.76 212.84,66.2 215.81,66.2 216.6,66.99 216.68,67.07 219.82,67.07 220.53,67.79 220.53,68.39 220.29,68.63 v1(220.29,68.85)
  BOTTOM w0.13: v1(220.29,68.85) 220.4,68.96 220.4,69.45 220.7,69.75 R3023.1 220.7,76.54 219.03,78.21 219.03,79.41 219.03,81.77 220.01,82.76 220.01,83.66 220.01,87.8 218.97,88.85 218.61,89.2 218.61,93.68 220.05,95.12 221.6,95.12 224.22,97.75 CN3001.1
DMIC_DATA0: length 7.9
  BOTTOM w0.13: U3002.4 219.38,100.08 R3016.2 219.66,100.85 v3(219.76,100.85) 219.76,100.96 220.59,101.8 221.06,101.8 221.11,101.75 CN3001.9
DMIC_DATA0_DB: length 88.8
  TOP w0.13: v2(60.22,57.55) 59.61,56.94 59.61,54.61 60.49,53.73 60.49,53.39 59.65,52.55 CN9354.4 ; v1(59.61,43.12) 60.22,43.72 MIC9352.1 ; MIC9350.1 61.07,117.12 v1(61.62,117.67)
  L3 w0.097: v1(61.62,117.67) 61.04,117.09 61.04,100.91 60.02,99.88 60.02,68.74 59.6,68.32 59.6,65.64 59.88,65.36 60.35,64.89 60.35,63.45 60.45,63.35 60.84,62.97 60.84,59.22 61.04,59.02 61.04,57.64 60.94,57.55 v2(60.22,57.55) 59.76,57.55 59.66,57.64 59.66,58.64 59.56,58.74 59.35,58.74 59.25,58.64 59.25,43.47 v1(59.61,43.12)
DMIC_DATA0_PCH: length 62.6
  TOP w0.13: v1(219.25,69.28) 219.25,68.43 218.66,67.84 216.36,67.84 216.25,67.73 215.49,66.97 213.15,66.97 212.59,67.53 210.18,67.53 209.73,67.09 208.64,67.09 208.09,66.54 195.47,66.54 195.37,66.44 v3(194.03,66.44) R4546.2
  BOTTOM w0.13: R3016.1 219.49,99.23 U3002.3 ; R3016.1 R4510.2 ; R3016.1 218.02,99.23 217.84,99.05 217.84,88.89 218.65,88.08 219.25,87.48 219.25,83.34 219.25,83.07 218.26,82.09 218.26,79.1 218.26,79.1 218.26,77.89 218.71,77.44 219.94,76.22 219.94,71.15 219.23,70.44 219.23,69.3 v1(219.25,69.28)
DMIC_DATA0_PP: length 1.3
  BOTTOM w0.13: R3035.2 220.91,99.02 U3002.1
DMIC_DATA1: length 7.5
  BOTTOM w0.13: R3014.2 218.64,96.83 U3003.4 219.49,97.6 219.54,97.65 219.54,97.67 219.79,97.92 v3(222.27,97.92) 223.69,97.92 223.95,98.19 224.98,98.19 CN3001.2
DMIC_DATA1_PCH: length 60.5
  TOP w0.13: R4532.1 193.03,62.77 v3(193.52,63.26) 194.73,63.26 195.25,63.79 195.25,64.22 197.31,66.28 208.19,66.28 208.75,66.83 209.84,66.83 210.28,67.27 212.49,67.27 213.05,66.71 215.6,66.71 216.35,67.47 216.46,67.58 218.76,67.58 219.65,68.47 v1(219.81,68.47)
  BOTTOM w0.13: v1(219.81,68.47) 219.81,70.66 220.19,71.04 220.19,76.32 218.82,77.7 218.52,78 218.52,79.2 218.52,81.99 219.5,82.97 219.5,83.44 219.5,87.59 218.76,88.34 218.1,88.99 218.1,94.79 R4559.2 R3014.1 218.64,96.08 U3003.3
DMIC_DATA1_PP: length 1.2
  BOTTOM w0.13: R3036.2 220.86,96.1 U3003.1
DMIC_MUTE_LED: length 8.9
  TOP w0.076: 232.51,47.77 232.97,47.77 v1(234.11,46.62) ; v1(236.28,43.24) U300.J10
  TOP w0.102: TP302.1 230.58,47.77 232.51,47.77
  L3 w0.076: v1(236.28,43.24) 236.28,43.69 234.34,45.63 234.34,46.39 v1(234.11,46.62)
DMIC_R_CLK0: length 13.9
  TOP w0.076: v2(181.37,62.35) 181.85,62.83 182.26,62.83 183.12,63.69 185.63,63.69 187.44,65.5 188,65.5
  TOP w0.13: 188,65.5 188.71,65.5 188.94,65.73 189.56,65.73 190.1,66.27 190.29,66.27 191.07,67.05 R4551.1
  BOTTOM w0.076: U4555.CP24 179.86,62.68 180.34,62.41 180.61,62.41 180.73,62.54 181.19,62.54
  BOTTOM w0.13: v2(181.37,62.35) 181.19,62.54
DMIC_R_CLK1: length 15.3
  TOP w0.076: v1(178.01,61.4) 178.35,61.73 186.11,61.73
  TOP w0.13: 186.11,61.73 189.03,61.73 189.13,61.84 191.54,61.84 v3(191.64,61.94) 192.43,61.94 R4513.2
  BOTTOM w0.13: U4555.CK25 v1(178.01,61.4)
DMIC_R_DATA0: length 15.8
  TOP w0.076: v1(182.03,62.35) 183.2,63.53 185.7,63.53 187.17,64.99 188.03,64.99
  TOP w0.13: R4546.1 192.17,66.44 v3(192.07,66.33) 191.08,66.33 190.51,65.76 190.31,65.76 189.77,65.22 189.15,65.22 188.93,64.99 188.03,64.99
  BOTTOM w0.076: U4555.CN24 179.51,62.41 179.99,62.41 180.3,62.25 180.94,62.25 181.21,61.97 181.65,61.97 v1(182.03,62.35)
DMIC_R_DATA1: length 16.1
  TOP w0.076: 188.1,62.28 187.74,61.92 186.03,61.92 186.01,61.9 178.4,61.9 178.38,61.9 178.35,61.91 178.31,61.91 178.26,61.9 178.25,61.89 178.18,61.86 177.84,61.86 v1(177.42,61.44)
  TOP w0.13: 188.1,62.28 188.29,62.47 v3(190.09,62.47) 192.24,62.47 192.42,62.65 R4532.2
  BOTTOM w0.13: U4555.CJ25 v1(177.42,61.44)
DP_UTIL: length 2.2
  TOP w0.102: TP4500.1 154.92,72.21 155.31,72.6 155.31,73.04 v1(154.94,73.41)
  BOTTOM w0.2: v1(154.94,73.41) 154.93,73.41 154.93,73.41 U4555.AM7
DPB0_TR_C_DN: length 8.7
  TOP w0.076: U2700.B5 262.87,67.19 262.99,67.07 arc(263.11,66.99) 263.24,66.96 264.26,66.96 265.5,68.21 265.54,68.21 265.55,68.22
  TOP w0.119: 265.55,68.22 265.75,68.42 267.33,68.42 v4(268.61,69.7) 269.4,70.49 C2709.1
DPB0_TR_C_DP: length 8.6
  TOP w0.076: 265.4,68.38 265.38,68.36 265.38,68.32 264.19,67.13 263.92,67.13 263.92,67.13 263.89,67.13 arc(263.84,67.14) 263.8,67.17 263.62,67.35 arc(263.54,67.4) 263.44,67.42 263.23,67.42 arc(263.12,67.31) 263.23,67.19 U2700.A5
  TOP w0.119: C2708.1 268.84,71.07 269.18,70.73 269.18,70.58 267.24,68.64 v4(266.11,68.64) 265.66,68.64 265.4,68.38
DPB0_TR_DN: length 41.4
  TOP w0.119: v1(268.09,77.79) 268.09,77.63 268.77,76.95 268.77,76.2 269.48,75.49 269.48,72.19 269.21,71.91 269.21,71.76 C2709.2 ; U3300.39 244.22,92.52 244.31,92.61 244.44,92.61 244.53,92.7 244.78,92.7 244.91,92.57 245.5,92.57 245.94,93 247.44,93 247.75,93.31 248.02,93.31 v1(248.31,93.02)
  BOTTOM w0.119: v1(268.09,77.79) 268.29,77.6 268.46,77.6 268.57,77.71 268.57,77.77 268.58,77.78 268.58,80.52 262.25,86.85 254.66,86.85 250.31,91.2 250.31,91.76 248.79,93.28 248.57,93.28 v1(248.31,93.02)
DPB0_TR_DP: length 41.4
  TOP w0.119: C2708.2 268.99,71.76 268.99,72 269.26,72.28 269.26,75.4 268.55,76.11 268.55,76.86 268.37,77.04 v1(268.09,77.04) ; v2(248.31,93.77) 248.07,93.53 247.66,93.53 247.35,93.22 245.85,93.22 245.41,92.79 245,92.79 244.87,92.92 U3300.40
  BOTTOM w0.119: v1(268.09,77.04) 268.43,77.38 268.55,77.38 268.79,77.62 268.79,77.68 268.8,77.69 268.8,80.61 262.34,87.07 254.75,87.07 250.53,91.29 250.53,91.86 248.88,93.5 248.57,93.5 v2(248.31,93.77)
DPB1_TR_C_DN: length 8.4
  TOP w0.076: U2700.A3 263.23,68.11 arc(263.12,68.23) 263.23,68.34 263.42,68.34 arc(263.51,68.32) 263.6,68.27 263.67,68.19 arc(263.74,68.16) 263.8,68.19 265.34,69.73 265.34,69.77 265.36,69.78
  TOP w0.119: 265.36,69.78 265.36,69.78 265.56,69.98 266.06,69.98 268.61,72.54 268.61,72.64 268.49,72.75 268.49,72.84 268.36,72.98 C2711.1
DPB1_TR_C_DP: length 8.5
  TOP w0.076: U2700.B3 262.99,67.99 arc(263.1,67.91) 263.24,67.88 263.73,67.88 265.46,69.61 265.5,69.61 265.51,69.63
  TOP w0.119: C2710.1 268.83,72.45 v4(266.85,70.47) 266.15,69.76 265.65,69.76 265.51,69.63
DPB1_TR_DN: length 37.1
  TOP w0.119: U3300.36 244.01,91.41 244.73,91.41 244.83,91.52 245.18,91.52 245.69,91 248.12,91 v1(248.38,90.74) ; v1(268.07,75.04) 268.07,75.26 268.19,75.38 268.37,75.38 268.61,75.14 268.61,73.87 C2711.2
  BOTTOM w0.119: v1(268.07,75.04) 267.8,75.3 267.54,75.3 267.3,75.55 267.3,77.14 265.94,78.5 265.94,82.25 261.98,86.2 254.22,86.2 249.42,91 248.65,91 v1(248.38,90.74)
DPB1_TR_DP: length 37.1
  TOP w0.119: v2(248.38,91.44) 248.17,91.23 245.78,91.23 245.27,91.74 244.74,91.74 244.64,91.63 244.01,91.63 U3300.37 ; v1(268.07,75.78) 268.26,75.6 268.47,75.6 268.83,75.23 C2710.2
  BOTTOM w0.119: v1(268.07,75.78) 267.8,75.52 267.64,75.52 267.52,75.64 267.52,77.23 266.16,78.59 266.16,82.34 262.07,86.43 254.31,86.43 249.51,91.23 248.6,91.23 v2(248.38,91.44)
DPB2_TR_C_DN: length 7.9
  TOP w0.076: U2700.C1 262.4,68.99 262.33,68.92 262.23,68.92 262.17,68.98 262.17,69.24 262.32,69.39 262.5,69.39 262.77,69.65 263.98,69.65 264.7,70.37 264.7,70.41 264.71,70.43
  TOP w0.119: 264.71,70.43 267.17,72.89 267.17,73.36 C2713.1
DPB2_TR_C_DP: length 7.8
  TOP w0.076: U2700.C2 262.62,68.86 arc(262.63,68.91) 262.63,68.95 262.63,69.29 262.84,69.49 264.04,69.49 264.81,70.26 264.85,70.26 264.87,70.27
  TOP w0.119: C2712.1 267.39,73.36 267.39,72.8 v4(267.1,72.51) 264.97,70.37 264.97,70.37 264.87,70.27
DPB2_TR_DN: length 34.8
  TOP w0.119: v1(248.67,89.38) 248.66,89.38 248.55,89.5 247.71,89.5 247,90.21 244.63,90.21 244.54,90.12 U3300.33 ; v1(266.85,75.65) 267.11,75.91 267.23,75.91 267.36,75.78 267.36,74.44 C2713.2
  BOTTOM w0.119: v1(266.85,75.65) 266.59,75.91 266.33,75.91 266.08,76.16 266.08,77.14 265.29,77.93 265.29,81.78 261.98,85.09 254.34,85.09 250.43,89 249.84,89 249.05,89.79 248.95,89.79 248.83,89.67 248.78,89.67 248.66,89.55 248.66,89.38 v1(248.67,89.38)
DPB2_TR_DP: length 34.9
  TOP w0.119: v1(248.66,90.08) 248.3,89.72 247.8,89.72 247.09,90.43 244.63,90.43 244.54,90.52 U3300.34 ; C2712.2 267.59,75.87 267.32,76.13 267.11,76.13 v1(266.85,76.39)
  BOTTOM w0.119: v1(248.66,90.08) 248.74,90.01 249.15,90.01 249.93,89.22 250.52,89.22 254.44,85.31 v4(255.6,85.31) 262.07,85.31 265.51,81.87 265.51,78.02 266.3,77.23 266.3,76.25 266.42,76.13 266.59,76.13 v1(266.85,76.39)
DPB3_TR_C_DN: length 7.6
  TOP w0.076: 264.05,71.09 264.04,71.08 264.04,71.03 264.02,71.01 263.62,70.61 262.68,70.61 262.54,70.61 261.25,69.33 261.25,68.88 261.3,68.84 261.4,68.84 261.48,68.92 U2700.E1
  TOP w0.119: 264.05,71.09 265.77,72.81 265.77,73.43 C2715.1
DPB3_TR_C_DP: length 7.6
  TOP w0.076: U2700.E2 261.71,68.8 261.71,69.55 262.61,70.45 263.69,70.45 264.11,70.87 264.14,70.87 264.21,70.93
  TOP w0.119: C2714.1 265.99,73.28 265.99,72.72 v4(265.25,71.97) 264.21,70.93
DPB3_TR_DN: length 33.2
  TOP w0.119: C2715.2 265.75,74.05 266.16,74.46 266.16,75.74 266.04,75.86 265.87,75.86 v1(265.66,75.65) ; v1(248.31,87.76) 248.04,88.02 246.47,88.02 245.76,88.73 245.45,89.04 244.66,89.04 244.54,88.92 U3300.30
  BOTTOM w0.119: v1(248.31,87.76) 248.76,88.21 250.15,88.21 254.74,83.62 262.05,83.62 264.65,81.02 264.65,76.16 264.95,75.86 265.44,75.86 v1(265.66,75.65)
DPB3_TR_DP: length 33.1
  TOP w0.119: v2(265.66,76.32) 265.92,76.08 266.13,76.08 266.38,75.83 266.38,74.36 266.26,74.25 C2714.2 ; U3300.31 244.54,89.32 244.61,89.26 245.55,89.26 245.92,88.89 246.56,88.24 248.04,88.24 v1(248.31,88.51)
  BOTTOM w0.119: v2(265.66,76.32) 265.42,76.08 265.04,76.08 264.87,76.25 264.87,81.12 262.14,83.84 254.84,83.84 250.25,88.43 248.38,88.43 v1(248.31,88.51)
DPB_AUX_C_DN: length 1.7
  TOP w0.119: C3304.2 239.75,95.88 239.75,95.31 239.84,95.22 U3300.51
DPB_AUX_C_DP: length 1.8
  TOP w0.119: C3305.2 239.53,95.8 239.53,95.31 239.44,95.22 U3300.52
DPB_AUX_DN: length 124.6
  TOP w0.119: v1(239.98,97.91) 239.9,97.83 239.9,97.17 C3304.1
  L3 w0.076: v2(149.37,73.37) 149.2,73.54 148.99,73.54 148.82,73.71 148.82,74.9 148.89,74.96 148.89,77 148.82,77.06 148.82,77.11 148.81,77.12 148.81,77.16 148.78,77.19 148.78,77.2
  L3 w0.109: v1(239.98,97.91) 239.98,98.82 239.13,99.67 233.9,99.67 231.23,102.34 222.74,102.34 221.16,103.92 218.65,103.92 217.89,104.68 203.74,104.68 202.75,103.69 184.43,103.69 182.37,105.75 181.34,105.75 173.62,105.75 170.98,108.39 170.46,108.39 164.58,108.39 164.45,108.26 159.65,103.47 159.65,102.95 159.65,102.13 148.76,91.23 148.76,77.32 148.78,77.3 148.78,77.2
  BOTTOM w0.076: U4555.AC7 v2(149.37,73.37)
DPB_AUX_DP: length 124.5
  TOP w0.119: v1(239.32,97.91) 239.68,97.55 239.68,97.42 239.28,97.03 C3305.1
  L3 w0.076: 148.99,77.2 148.99,77.13 149.05,77.07 149.05,74.89 148.98,74.83 148.98,73.78 149.06,73.71 149.17,73.71 149.36,73.9 v1(149.36,74.03)
  L3 w0.109: 148.99,77.2 148.99,77.39 148.97,77.4 148.97,91.15 159.86,102.04 159.86,103.03 159.86,103.03 159.86,103.38 164.66,108.18 170.55,108.18 170.9,108.18 173.53,105.54 181.42,105.54 182.28,105.54 184.34,103.48 202.83,103.48 203.82,104.47 217.8,104.47 218.56,103.71 221.07,103.71 222.65,102.13 231.14,102.13 233.81,99.46 239.04,99.46 239.77,98.73 239.77,98.28 239.4,97.91 v1(239.32,97.91)
  BOTTOM w0.076: U4555.AC6 148.99,73.73 149.19,73.73 149.36,73.9 v1(149.36,74.03)
DPB_DDCCLK: length 98
  TOP w0.076: v1(174.29,72.76) 174.68,72.38 174.68,72.11 175.23,71.57 v3(180.64,71.57) 180.76,71.68 182.25,71.68 183.03,71.68 183.16,71.81 185.25,71.81
  TOP w0.13: v1(240.17,95.57) 240.24,95.5 U3300.50 ; v1(243.74,79.39) 243.42,79.39 240.89,76.86 238.18,76.86 233.92,72.59 224,72.59 223.55,73.04 222.57,73.04 221.94,72.41 216.42,72.41 214.09,74.74 R4786.2 212,74.74 209.76,72.5 206.41,72.5 205.11,71.21 204.86,71.21 203.65,71.2 202.94,70.5 193.73,70.5 190.98,73.25 188.03,73.25 186.6,71.81 185.25,71.81
  L6 w0.127: v1(240.17,95.57) 240.51,95.57 242.86,93.22 242.86,88.58 244.64,86.8 244.64,80.29 v1(243.74,79.39)
  BOTTOM w0.13: U4555.CC8 v1(174.29,72.76)
DPB_DDCDATA: length 98.7
  TOP w0.076: v1(174.29,72.13) 175.23,71.19 179.03,71.19 v3(179.3,70.93) 179.47,71.11 180.83,71.11 181.24,71.52 183.1,71.52 183.17,71.59 184.78,71.59
  TOP w0.13: U3300.49 240.64,96.26 v1(240.69,96.31) ; 184.78,71.59 186.69,71.59 188.09,72.99 190.87,72.99 193.62,70.24 203.05,70.24 203.76,70.95 204.97,70.95 205.22,70.95 206.52,72.24 209.86,72.24 210.72,73.1 R4787.2 215.37,73.1 216.31,72.15 222.05,72.15 222.67,72.78 223.45,72.78 223.89,72.33 234.02,72.33 238.29,76.6 241.05,76.6 243.23,78.78 v1(243.74,78.78)
  L6 w0.127: v1(240.69,96.31) 240.69,95.75 243.11,93.33 243.11,88.68 244.98,86.82 244.98,80.02 v1(243.74,78.78)
  BOTTOM w0.13: U4555.CC9 v1(174.29,72.13)
DPB_DP_CFG0: length 5.7
  TOP w0.102: 243.86,96 243.86,96.67 R3339.1 ; 243.86,96 243.99,95.87 245.31,95.87 245.74,96.31 R3355.1 ; 243.86,96 243.08,96 242.64,95.56 U3300.44
DPB_DP_CFG1: length 11.4
  TOP w0.102: v3(249.78,90.74) 249.44,90.4 249.44,89.37 R3320.1 ; R3320.1 248.71,88.57 248.71,87.59 248.44,87.32 245.41,87.32 244.2,88.52 U3300.29 ; R3320.1 249.93,88.88 251.05,88.88 R3319.1
DPB_HDMI_CLK_DN: length 46.4
  TOP w0.119: U3300.15 237.84,87.01 237.93,86.92 237.93,86.02 v1(237.7,85.78)
  L3 w0.109: v1(237.7,85.78) 237.87,85.61 237.87,85.29 238.78,84.38 244.65,84.38 245.33,85.06 251.19,85.06 253.6,87.48 255.79,87.48 261.99,93.67 269.05,93.67 272.47,97.09 275.71,97.09 CN3150.12
DPB_HDMI_CLK_DP: length 46.4
  TOP w0.119: v2(238.37,85.78) 238.15,85.99 238.15,86.86 238.24,86.95 U3300.16
  L3 w0.109: CN3150.10 275.95,97.7 275.55,97.3 272.38,97.3 268.96,93.88 261.9,93.88 255.71,87.69 253.52,87.69 251.1,85.27 245.24,85.27 244.56,84.59 238.86,84.59 238.08,85.38 238.08,85.62 238.24,85.78 v2(238.37,85.78)
DPB_HDMI_DDC_CLK: length 50.7
  TOP w0.13: U3300.48 241.04,96.07 241.11,96.13 241.11,99 v1(241.06,99.04)
  L3 w0.097: v1(270.93,99.23) 270.52,99.63 270.2,99.63 269.78,99.21 264.86,99.21 263.71,98.05 261.91,98.05 261.8,98.17 241.94,98.17 v1(241.06,99.04)
  BOTTOM w0.13: v1(270.93,99.23) 270.93,98.93 271.48,98.38 271.48,97.21 272.78,95.91 272.78,94.02 272.92,93.89 R3151.1 272.92,92.05 273.14,91.82 275.68,91.82 276.65,92.79 276.65,94.5 CN3150.15
DPB_HDMI_DDC_DATA: length 44.9
  TOP w0.13: v1(241.72,99.04) 241.44,98.76 U3300.47
  L3 w0.097: v1(271.59,99.23) 270.96,99.85 270.11,99.85 269.69,99.44 264.77,99.44 263.61,98.28 262.01,98.28 261.89,98.39 242.37,98.39 v1(241.72,99.04)
  BOTTOM w0.13: CN3150.16 274.91,95.89 274.91,96.32 273.87,97.36 273.44,97.36 273.13,97.06 273.13,96.62 273.2,96.55 R3150.1 273.07,96 271.73,97.34 271.73,99.08 v1(271.59,99.23)
DPB_HDMI_HPD: length 46.8
  TOP w0.102: v2(243.94,82.31) 243.18,83.07 241.61,83.07 241.17,83.51 241.17,83.66 238.37,86.46 238.37,86.77 238.64,87.05 U3300.17
  L3 w0.102: v2(243.94,82.31) 252.12,82.31 260.22,90.41 270.01,90.41 272,92.39 276.54,92.39 CN3150.19
DPB_HDMI_TX0_DN: length 54.6
  TOP w0.119: v1(238.88,86.53) 238.93,86.53 239.18,86.78 239.18,86.95 239.04,87.08 U3300.18
  L3 w0.109: CN3150.9 277.11,98.74 276.88,98.74 276.77,98.63 276.77,93.52 276.29,93.04 272.06,93.04 269.84,90.82 260.02,90.82 256.05,86.85 253.86,86.85 251.45,84.44 245.59,84.44 244.91,83.76 238.52,83.76 237.07,85.2 237.07,86.04 237.44,86.4 238.76,86.4 v1(238.88,86.53)
DPB_HDMI_TX0_DP: length 54.6
  TOP w0.119: v2(239.54,86.45) 239.44,86.55 U3300.19
  L3 w0.109: CN3150.7 277.1,98.95 276.79,98.95 276.56,98.71 276.56,93.61 276.2,93.25 271.97,93.25 269.75,91.03 259.93,91.03 255.96,87.06 253.78,87.06 251.36,84.65 245.5,84.65 244.82,83.97 238.6,83.97 237.28,85.29 237.28,85.95 237.52,86.19 238.64,86.19 238.71,86.12 239.05,86.12 239.39,86.45 v2(239.54,86.45)
DPB_HDMI_TX1_DN: length 44.7
  TOP w0.119: v1(240.12,85.77) 240.12,85.81 240.33,86.02 240.33,86.93 240.24,87.02 U3300.21
  L3 w0.109: CN3150.6 275.76,100.04 274.53,100.04 268.79,94.29 261.73,94.29 255.53,88.1 253.34,88.1 250.93,85.69 245.07,85.69 244.39,85.01 240.51,85.01 240.28,85.24 240.28,85.61 v1(240.12,85.77)
DPB_HDMI_TX1_DP: length 44.7
  TOP w0.119: v2(240.78,85.78) 240.55,86.01 240.55,86.93 240.64,87.02 U3300.22
  L3 w0.109: CN3150.4 275.95,100.7 275.5,100.25 274.45,100.25 268.7,94.5 261.64,94.5 255.45,88.31 253.26,88.31 250.84,85.9 244.98,85.9 244.3,85.22 240.6,85.22 240.49,85.33 240.49,85.55 240.71,85.78 v2(240.78,85.78)
DPB_HDMI_TX2_DN: length 45.3
  TOP w0.119: v1(241.41,86.43) 241.44,86.46 U3300.24
  L3 w0.109: v1(241.41,86.43) 241.56,86.27 241.56,85.86 241.8,85.63 244.13,85.63 244.81,86.31 250.67,86.31 253.09,88.73 255.27,88.73 263.39,96.84 268.61,96.84 269.69,97.92 271.17,97.92 275.7,102.45 276.2,102.45 276.88,101.77 277.08,101.77 CN3150.3
DPB_HDMI_TX2_DP: length 45.3
  TOP w0.119: U3300.25 241.84,87.1 241.67,86.92 241.67,86.75 242,86.43 v2(242.07,86.43)
  L3 w0.109: v2(242.07,86.43) 241.99,86.43 241.77,86.21 241.77,85.95 241.88,85.84 244.04,85.84 244.72,86.52 250.59,86.52 253,88.94 255.19,88.94 263.31,97.05 268.53,97.05 269.61,98.13 271.09,98.13 275.61,102.66 276.29,102.66 276.97,101.98 277.13,101.98 CN3150.1
DPB_HPD: length 97.9
  TOP w0.102: U3300.5 v1(235.9,92.12)
  L3 w0.102: v1(218.74,102.15) 218.77,102.12 222.08,102.12 222.48,101.72 227.96,101.72 235.9,93.78 v1(235.9,92.12) ; v1(183.52,74.08) 183.52,75.08 186.61,78.17 191.82,78.17 193.84,76.15 193.84,74.33 194.08,74.09 195.37,74.09 195.43,74.15 196.65,74.15 197.36,73.43 200.45,73.43 v1(201.11,72.77)
  L5 w0.102: v1(201.32,97.7) 200.91,97.3 200.91,96.87 201.11,96.68 v1(201.11,72.77)
  L6 w0.102: v1(218.74,102.15) 218.5,102.39 204.74,102.39 200.83,98.48 200.83,98.11 201.24,97.7 v1(201.32,97.7)
  BOTTOM w0.076: v1(183.52,74.08) 182.95,74.66 181.37,74.66 181.35,74.63 180.7,74.63 179.78,74.35 179.55,74.28 U4555.CN6
  BOTTOM w0.102: v1(201.11,72.77) 201.11,73.51 R4758.1
DPB_I2C_CTL_EN: length 6.5
  TOP w0.102: v3(249.3,92.95) 249.04,92.7 R3309.1 248.59,92.56 247.23,92.56 R3310.1 246.76,92.12 U3300.38
DPB_IN_CA_DET: length 9.1
  TOP w0.102: TP3303.1 236.45,84.14 R3308.1 236.45,84.64 236.2,84.89 v1(236.2,85.76) ; U3300.11 v1(236.14,89.72)
  L3 w0.102: v1(236.2,85.76) 235.79,85.33 235.79,89.37 v1(236.14,89.72)
DPB_MODE: length 4.2
  TOP w0.102: R3342.1 R3341.1 v3(238.14,96.71) 238.14,96.29 239.04,95.38 U3300.53
DPB_PD#: length 1.4
  TOP w0.102: U3300.46 241.84,95.81 241.84,95.81 TP3301.1
DPB_PEQ: length 11.6
  TOP w0.102: U3300.8 v1(236.07,90.92) ; v1(235.84,82.18) 236.04,82.39 R3340.1 R3356.1
  L3 w0.102: v1(236.07,90.92) 235.59,90.45 235.59,84.96 235.84,84.71 v1(235.84,82.18)
DPB_REXT: length 4.4
  TOP w0.102: R3324.2 244.12,84.64 v3(244.04,84.72) 243.91,84.72 242.64,85.99 U3300.27
DPB_SW: length 6.4
  TOP w0.102: U3300.45 242.24,95.45 242.82,96.03 R3323.1 242.46,96.79 241.78,97.48 241.78,97.81 242.41,98.44 v3(242.9,98.44) 242.94,98.39 R3322.1
DPB_TMDS_DDCBUF: length 6.2
  TOP w0.102: v3(232,96.08) 232.71,95.37 R3301.1
  TOP w0.254: U3300.2 236.35,93.32 236.34,93.33 235.69,93.33 233.78,95.24 R3300.1 R3301.1
DPB_TMDS_PRE: length 18.8
  TOP w0.102: R3311.1 R3312.1 251.61,86.53 250.04,86.53 246.78,83.27 242.09,83.27 v3(241.65,83.71) 241.6,83.71 239.71,85.6 239.71,85.93 240.03,86.25 240.03,86.65 239.84,86.84 U3300.20
DPB_TMDS_RT: length 14.6
  TOP w0.102: U3300.23 241.04,86.63 241,86.59 241,86.26 242.8,84.47 v3(242.8,84.34) 243.66,83.47 246.7,83.47 249.98,86.75 R3305.1 R3303.1
DPB_TR_AUX_C_DN: length 3.9
  TOP w0.076: U2700.P2 257.34,68.63 257.58,68.86 257.58,69.21 257.37,69.41 257.37,69.64 256.13,70.89 256.13,71.52 C2717.1
DPB_TR_AUX_C_DP: length 3.9
  TOP w0.076: U2700.P1 257.34,68.87 257.31,68.84 257.18,68.84 257.11,68.91 257.11,69.3 257.21,69.39 257.21,69.57 255.97,70.82 255.97,71.43 C2716.1
DPB_TR_AUX_CN_DN: length 10.5
  TOP w0.119: v2(252.78,81.28) 253.5,81.28 254.11,80.67 254.11,79.06 254.91,78.27 254.91,76.86 256.44,75.33 256.44,74.53 R2774.1
  BOTTOM w0.119: v2(252.78,81.28) 252.52,81.02 251.5,81.02 CN2701.2
DPB_TR_AUX_CN_DP: length 10.5
  TOP w0.119: v1(252.78,80.59) 253.25,81.06 253.41,81.06 253.89,80.58 253.89,78.97 254.69,78.17 254.69,76.76 256.21,75.24 256.21,74.79 R2773.1
  BOTTOM w0.119: v1(252.78,80.59) 252.57,80.8 251.89,80.8 251.88,80.79 251.51,80.79 CN2701.3
DPB_TR_AUX_DN: length 51.6
  TOP w0.119: v1(235.56,99.04) 235.29,98.78 235.29,98.59 R3302.1 235.56,97.44 R3306.2 235.29,97.17 235.29,96.82 235.76,96.35 237.77,96.35 238.55,95.57 238.55,95.31 238.64,95.22 U3300.54 ; R2774.2 256.64,73.01 v1(256.38,72.76) 256.28,72.66 256.28,72.22 C2717.2
  L3 w0.109: v1(249.7,95.14) 249.47,94.9 249.31,94.9 248.89,95.33 248.89,96.12 248.08,96.93 247.91,96.93 237.6,96.93 236.93,97.6 235.8,97.6 235.29,98.11 235.29,98.78 v1(235.56,99.04)
  L6 w0.127: v1(249.7,95.14) 249.99,94.86 250.46,94.86 251.06,94.25 251.06,85.92 256.31,80.67 256.31,72.84 v1(256.38,72.76)
DPB_TR_AUX_DP: length 51.6
  TOP w0.119: U3300.55 238.24,95.22 238.33,95.31 238.33,95.48 237.68,96.13 235.67,96.13 235.07,96.73 235.07,97.17 R3307.2 234.81,97.44 R3304.1 235.07,98.59 235.07,98.78 v1(234.81,99.04) ; R2773.2 255.93,73.3 255.93,72.91 v1(255.8,72.79) 255.7,72.68 C2716.2
  L3 w0.109: v1(234.81,99.04) 235.08,98.78 235.08,98.02 235.71,97.39 236.84,97.39 237.51,96.72 248,96.72 248.68,96.04 248.68,95.24 249.22,94.69 249.47,94.69 v2(249.7,94.45)
  L6 w0.127: v1(255.8,72.79) 255.82,72.79 256.08,73.05 256.08,80.58 250.83,85.82 250.83,94.16 250.36,94.63 249.88,94.63 v2(249.7,94.45)
DPB_TR_CA_DET: length 3
  TOP w0.102: U3300.42 244.61,93.72 v3(245.56,94.68) 245.56,94.8 R3314.1
DPB_TR_HPD: length 31.6
  TOP w0.076: U2700.Y4 254.37,67.87 254.69,67.55 v1(254.69,67.55)
  TOP w0.102: U3300.32 245.67,89.72 v1(246.43,88.97)
  L5 w0.076: 254.69,68.52 v1(254.69,67.55)
  L5 w0.102: v2(253.87,82.17) 253.62,81.92 253.62,77.39 253.95,77.06 253.95,71.49 254.69,70.74 254.69,68.52
  L6 w0.102: v2(253.87,82.17) 253.79,82.26 253.57,82.26 253.56,82.25 253.22,82.25 252.41,83.06 252.33,83.06 v1(246.43,88.97)
  BOTTOM w0.102: CN2701.1 251.89,81.65 252.61,82.37 253.09,82.37 253.3,82.17 v2(253.87,82.17)
DPB_TX0_C_DN: length 6.5
  TOP w0.119: U3300.4 236.34,92.52 236.25,92.61 235.4,92.61 233.35,94.66 232.48,94.66 232.35,94.79 231.85,94.79 C3307.2
DPB_TX0_C_DP: length 6.5
  TOP w0.119: C3306.2 231.82,95.01 232.44,95.01 232.57,94.88 233.44,94.88 v4(234.5,93.82) 235.49,92.83 236.25,92.83 236.34,92.92 U3300.3
DPB_TX0_DN: length 113.5
  TOP w0.119: C3307.1 230.32,94.77 230.17,94.77 229.64,94.24 v2(229.66,93.87)
  L3 w0.109: v2(229.66,93.87) 229.64,94.18 229.9,94.44 229.9,95.3 227.65,97.56 223.02,97.56 222.61,97.97 221.89,97.97 221.72,98.14 219.39,98.14 215.75,101.78 212.9,101.78 212.68,102.01 204.6,102.01 203.78,101.19 197.3,101.19 196.54,100.44 196.2,100.44 193.63,100.44 192.33,99.14 185.45,99.14 181.33,103.25 172.58,103.25 169.95,105.89 165.61,105.89 162.15,102.43 162.15,101.09 151.34,90.28 151.34,84.58 152.9,83.02 152.9,78.91 152.64,78.66 152.64,77.27 154.18,75.74 154.18,74.95 v1(153.95,74.72)
  BOTTOM w0.076: v1(153.95,74.72) 153.95,74.55 153.86,74.47 U4555.AL5
DPB_TX0_DP: length 113.5
  TOP w0.119: v1(229.18,94.35) 229.41,94.32 230.08,94.99 230.32,94.99 C3306.1
  L3 w0.109: v2(153.96,74.06) 154.1,74.06 154.39,74.34 154.39,75.82 152.86,77.36 152.86,78.57 153.11,78.82 153.11,83.11 151.55,84.67 151.55,90.19 162.36,101 162.36,102.34 165.7,105.68 169.86,105.68 172.5,103.04 181.25,103.04 185.36,98.93 192.42,98.93 193.72,100.23 196.11,100.23 196.63,100.23 197.39,100.98 203.87,100.98 204.68,101.8 212.59,101.8 212.82,101.57 215.66,101.57 219.31,97.92 221.63,97.92 221.8,97.75 222.53,97.75 222.93,97.35 227.56,97.35 229.69,95.22 229.69,94.52 229.49,94.32 v1(229.18,94.35)
  BOTTOM w0.076: U4555.AL6 v2(153.96,74.06)
DPB_TX1_C_DN: length 5
  TOP w0.119: U3300.7 236.34,91.32 236.25,91.41 235.26,91.41 234.41,92.26 234.41,92.69 234.04,93.05 233.4,93.05 233.13,92.79 C3309.2
DPB_TX1_C_DP: length 4.9
  TOP w0.119: C3308.2 233.48,93.28 234.13,93.28 234.63,92.78 234.63,92.36 235.35,91.63 236.25,91.63 236.34,91.72 U3300.6
DPB_TX1_DN: length 116.9
  TOP w0.119: C3309.1 231.94,93.07 231.68,93.07 v1(231.41,92.81)
  L3 w0.109: v1(153.06,74.68) 153.06,74.95 151.78,76.23 151.78,78.46 151.33,78.91 151.33,80.54 150.72,81.15 150.72,90.54 161.53,101.35 161.53,102.69 165.35,106.51 170.21,106.51 172.84,103.88 181.59,103.88 185.71,99.76 192.07,99.76 193.37,101.06 196.29,101.06 197.04,101.82 203.52,101.82 204.34,102.63 212.94,102.63 213.16,102.4 216.01,102.4 219.65,98.76 221.98,98.76 222.15,98.59 222.87,98.59 223.28,98.18 227.9,98.18 228.52,97.57 228.73,97.57 232.39,93.9 232.39,93.33 232.01,92.95 231.56,92.95 v1(231.41,92.81)
  BOTTOM w0.076: U4555.AJ5 v1(153.06,74.68)
DPB_TX1_DP: length 116.9
  TOP w0.119: v2(231.41,93.56) 231.68,93.29 231.94,93.29 C3308.1
  L3 w0.109: v2(231.41,93.56) 231.41,93.44 231.69,93.16 231.93,93.16 232.18,93.41 232.18,93.82 228.64,97.36 228.43,97.36 227.82,97.97 223.19,97.97 222.79,98.38 222.06,98.38 221.89,98.55 219.57,98.55 215.92,102.19 213.08,102.19 212.85,102.42 204.42,102.42 203.61,101.61 197.13,101.61 196.37,100.85 193.46,100.85 192.16,99.55 185.62,99.55 181.51,103.67 172.75,103.67 170.12,106.3 165.44,106.3 161.74,102.6 161.74,101.26 150.93,90.45 150.93,81.24 151.54,80.63 151.54,78.99 151.99,78.54 151.99,76.32 153.27,75.04 153.27,75.03 153.46,74.84 153.46,74.51 153.06,74.11 v1(153.06,74.03)
  BOTTOM w0.076: v1(153.06,74.03) U4555.AJ6
DPB_TX2_C_DN: length 3
  TOP w0.119: C3311.2 234.41,90.51 234.74,90.18 v4(235.56,90.18) 236.28,90.18 236.34,90.12 U3300.10
DPB_TX2_C_DP: length 3.1
  TOP w0.119: U3300.9 236.34,90.52 236.22,90.41 234.83,90.41 234.62,90.62 234.62,91.03 C3310.2
DPB_TX2_DN: length 120.1
  TOP w0.119: C3311.1 233.49,91.29 233.16,91.62 232.79,91.62 v1(232.69,91.51)
  L3 w0.076: 150.22,76.82 150.22,76.81 150.26,76.79 150.26,76.76 150.26,75.3 150.69,74.88 150.69,74.55 v1(151.21,74.03)
  L3 w0.109: 150.22,76.82 150.21,76.88 150.21,77.48 150.19,77.5 150.19,80.8 150.09,80.89 150.09,90.8 160.9,101.61 160.9,102.95 165.09,107.14 170.46,107.14 173.1,104.5 181.85,104.5 185.31,101.05 192.47,101.05 193.11,101.69 196.03,101.69 196.78,102.44 203.27,102.44 204.08,103.26 213.19,103.26 213.42,103.03 216.27,103.03 219.91,99.39 222.24,99.39 222.41,99.21 227.76,99.21 228.78,98.19 228.99,98.19 233.49,93.68 233.49,91.75 233.26,91.51 v1(232.69,91.51)
  BOTTOM w0.076: U4555.AF6 v1(151.21,74.03)
DPB_TX2_DP: length 120
  TOP w0.119: v1(232.69,92.17) 233.02,91.84 233.26,91.84 233.48,91.61 233.99,91.61 C3310.1
  L3 w0.076: 150.43,76.86 150.43,75.37 150.85,74.95 150.85,74.62 151.05,74.42 151.18,74.42 151.26,74.5 v2(151.26,74.77)
  L3 w0.109: 150.43,76.86 150.42,76.9 150.42,77.56 150.4,77.59 150.4,80.89 150.31,80.98 150.31,90.71 161.11,101.52 161.11,102.86 165.18,106.93 170.38,106.93 173.01,104.29 181.77,104.29 185.22,100.83 192.56,100.83 193.2,101.48 196.11,101.48 196.87,102.23 203.35,102.23 204.17,103.05 213.11,103.05 213.34,102.82 216.18,102.82 219.83,99.17 222.15,99.17 222.32,99 227.67,99 228.69,97.98 228.9,97.98 233.28,93.6 233.28,91.83 233.17,91.72 233.06,91.72 232.69,92.1 v1(232.69,92.17)
  BOTTOM w0.076: v2(151.26,74.77) 151.26,74.61 151.12,74.47 U4555.AF5
DPB_TX3_C_DN: length 6
  TOP w0.119: U3300.13 236.34,88.92 236.18,89.09 235.98,89.09 235.78,88.89 235.78,86.63 234.9,85.74 234.9,85.53 235.44,84.99 C3313.2
DPB_TX3_C_DP: length 5.9
  TOP w0.119: C3312.2 234.68,85.84 235.56,86.72 235.56,88.98 235.89,89.31 236.31,89.31 236.33,89.32 U3300.12
DPB_TX3_DN: length 132.9
  TOP w0.119: v1(233.83,85.49) 233.69,85.35 233.32,85.35 233.07,85.1 233.07,83.53 233.4,83.21 v4(233.83,83.21) 234.42,83.21 234.94,83.73 235.03,83.73 235.14,83.84 235.14,83.93 235.35,84.14 C3313.1
  L3 w0.076: v1(150.31,74.72) 150.05,74.46 149.96,74.46 149.92,74.5 149.92,76.07 149.66,76.34 149.66,77.33 149.68,77.36 149.68,77.44
  L3 w0.109: 149.68,77.44 149.68,80.72 149.68,90.97 160.49,101.78 160.49,103.12 164.92,107.55 170.64,107.55 173.27,104.92 181.68,104.92 181.68,104.92 182.02,104.92 185.48,101.46 192.3,101.46 193.7,102.86 203.09,102.86 204.08,103.85 217.06,103.85 217.3,103.61 217.3,102.59 220.08,99.8 222.41,99.8 222.58,99.63 228.88,99.63 234.56,93.95 234.56,85.91 234.14,85.49 v1(233.83,85.49)
  BOTTOM w0.076: U4555.AE5 150.05,74.47 v1(150.31,74.72)
DPB_TX3_DP: length 133
  TOP w0.119: v1(233.83,84.82) 233.83,84.9 233.6,85.13 233.42,85.13 233.3,85.01 233.3,83.62 233.49,83.43 233.74,83.43 234.33,83.43 234.68,83.78 C3312.1
  L3 w0.076: v1(150.31,74.08) 150.1,74.29 150.05,74.29 149.9,74.3 149.76,74.43 149.76,76 149.49,76.27 149.49,77.33 149.47,77.36 149.47,77.42
  L3 w0.109: 149.47,77.42 149.47,80.63 149.47,91.06 160.28,101.87 160.28,103.21 164.83,107.76 170.72,107.76 173.36,105.13 181.59,105.13 181.59,105.13 182.11,105.13 185.57,101.67 192.21,101.67 193.61,103.07 203.01,103.07 204,104.06 217.14,104.06 217.51,103.7 217.51,102.67 220.17,100.01 222.5,100.01 222.67,99.84 228.97,99.84 234.77,94.04 234.77,85.82 233.83,84.88 v1(233.83,84.82)
  BOTTOM w0.076: v1(150.31,74.08) 149.84,73.81 U4555.AE6
DPC0_TR_C_DN: length 3.7
  TOP w0.076: 251.33,66.24 251.35,66.24 251.38,66.21 251.49,66.21 251.69,66.42 252.84,66.42 252.92,66.5 253.38,66.5 253.61,66.27 U2700.AB7
  TOP w0.119: 251.33,66.24 250.5,66.24 C2719.1
DPC0_TR_C_DP: length 3.6
  TOP w0.076: U2700.AC7 253.3,66.27 253.37,66.2 253.37,66.12 253.3,66.04 252.94,66.04 252.73,66.26 251.76,66.26 251.55,66.05 251.38,66.05 251.35,66.02 251.33,66.02
  TOP w0.119: C2718.1 250.5,66.02 251.33,66.02
DPC1_TR_C_DN: length 3.9
  TOP w0.076: 250.97,64.89 250.99,64.89 251.02,64.87 251.56,64.87 252.19,65.5 252.78,65.5 252.86,65.58 253.34,65.58 253.4,65.53 253.4,65.39 253.36,65.35 U2700.AC9
  TOP w0.119: C2721.1 250.31,65.04 250.45,64.89 250.97,64.89
DPC1_TR_C_DP: length 3.9
  TOP w0.076: 250.97,64.67 250.99,64.67 251.02,64.7 251.63,64.7 252.26,65.33 252.74,65.33 252.96,65.12 253.37,65.12 U2700.AB9
  TOP w0.119: 250.97,64.67 250.5,64.67 C2720.1
DPC2_TR_C_DN: length 4
  TOP w0.076: 250.97,63.55 250.99,63.55 251.02,63.52 251.23,63.52 252.29,64.59 252.88,64.59 252.95,64.66 253.44,64.66 253.66,64.44 U2700.AB11
  TOP w0.119: 250.97,63.55 250.45,63.55 250.31,63.69 C2722.1
DPC2_TR_C_DP: length 4.1
  TOP w0.076: U2700.AC11 253.36,64.43 253.38,64.41 253.38,64.25 253.33,64.2 252.96,64.2 252.74,64.42 252.36,64.42 251.3,63.36 251.02,63.36 250.99,63.33 250.97,63.33
  TOP w0.119: 250.97,63.33 250.5,63.33 C2723.1
DPC3_TR_C_DN: length 4.4
  TOP w0.076: 250.97,61.98 250.99,61.98 251.02,62.01 251.2,62.01 251.81,62.62 251.81,62.96 252.29,63.44 252.84,63.44 252.99,63.28 253.32,63.28 253.4,63.36 253.4,63.46 253.34,63.51 U2700.AC13
  TOP w0.119: 250.97,61.98 250.5,61.98 C2724.1
DPC3_TR_C_DP: length 4.4
  TOP w0.076: U2700.AB13 253.44,63.74 253.03,63.74 252.9,63.6 252.23,63.6 251.65,63.02 251.65,62.69 251.13,62.17 251.02,62.17 250.99,62.2 250.97,62.2
  TOP w0.119: C2725.1 250.5,62.2 250.97,62.2
DPC_AUX_DN: length 151.6
  TOP w0.119: C2727.2 257.48,72.25 257.48,75.28 255.59,77.17 255.59,80.27 255.34,80.52 v2(254.61,80.52)
  L6 w0.127: v1(153.31,86.88) 153.31,87.02 155.5,89.21 156.43,89.21 156.73,89.51 157.2,89.51 158.78,91.09 159.35,91.09 159.9,91.63 160.31,92.04 162.61,92.04 165.11,94.54 169.46,94.54 171.88,96.95 185.58,96.95 186.96,98.33 191.83,98.33 195.61,94.54 210.61,94.54 212.7,96.64 225.98,96.64 231.15,91.47 231.15,86.85 232.34,85.65 232.34,83.49 232.74,83.1 232.74,83.1 234.45,81.38 234.45,80.45 237.98,76.93 242.72,76.93 243.89,78.09 245.9,78.09 246.44,78.64 254.2,78.64 254.32,78.51 254.87,78.51 255.42,79.06 255.42,80 255.16,80.26 254.87,80.26 v2(254.61,80.52)
  BOTTOM w0.076: 149.75,81.2 149.75,81.18 149.72,81.16 149.72,76.6 149.86,76.47 149.86,76.03 U4555.AD4
  BOTTOM w0.119: v1(153.31,86.88) 153.31,85.88 149.75,82.32 149.75,81.2 ; CN2701.5 251.51,79.51 251.8,79.51 251.82,79.53 252.58,79.53 252.61,79.51 252.95,79.51 253.69,80.25 254.34,80.25 v2(254.61,80.52)
DPC_AUX_DP: length 151.7
  TOP w0.119: C2726.2 257.26,72.53 257.26,75.19 255.37,77.08 255.37,80.18 255.25,80.3 255.08,80.3 254.61,79.82 v1(254.61,79.77)
  L6 w0.127: v1(254.61,79.77) 254.87,80.03 255.06,80.03 255.19,79.9 255.19,79.15 254.78,78.74 254.42,78.74 254.29,78.87 246.35,78.87 245.8,78.32 243.79,78.32 242.62,77.15 238.07,77.15 234.68,80.55 234.68,81.48 232.97,83.19 232.57,83.59 232.57,85.75 231.38,86.94 231.38,91.56 226.07,96.86 212.61,96.86 210.51,94.77 195.71,94.77 191.92,98.55 186.86,98.55 185.49,97.18 171.78,97.18 169.37,94.77 165.01,94.77 162.52,92.27 160.21,92.27 159.8,91.86 159.8,91.86 159.26,91.31 158.68,91.31 157.11,89.74 156.64,89.74 156.33,89.44 155.41,89.44 153.27,87.3 153.07,87.3 v2(152.65,86.88)
  BOTTOM w0.076: U4555.AD3 149.55,76.15 149.49,76.15 149.3,76.34 149.3,76.44 149.37,76.51 149.38,76.51 149.56,76.68 149.56,78.07 149.35,78.28 149.35,78.4 149.56,78.61 149.56,78.74 149.38,78.92 149.38,79.06 149.56,79.24 149.56,81.16 149.53,81.18 149.53,81.2
  BOTTOM w0.119: 149.53,81.2 149.53,82.42 153.09,85.97 153.09,86.52 152.93,86.68 152.85,86.68 v2(152.65,86.88) ; v1(254.61,79.77) 254.34,80.03 253.79,80.03 253.04,79.29 252.51,79.29 252.49,79.31 251.91,79.31 251.88,79.29 251.51,79.29 CN2701.6
DPC_DDCCLK: length 12
  BOTTOM w0.076: 176.36,77.46 176.36,76.82 176.25,76.72 176.25,76.44 176.16,76.35 176.16,75.99 176.44,75.7 U4555.CH4
  BOTTOM w0.13: R4854.2 v3(177.7,83.68) 177.7,83.47 180.13,81.03 180.13,80.69 178.6,79.16 178.06,79.16 176.36,77.46
DPC_DDCDATA: length 10.9
  BOTTOM w0.076: 176.82,77.54 176.61,77.32 176.61,76.76 176.44,76.59 U4555.CH3
  BOTTOM w0.13: 176.82,77.54 178.22,78.94 178.69,78.94 180.35,80.6 180.35,81.17 178.84,82.69 v3(178.84,83.07) 178.33,83.58 R4870.2
DPC_HPD: length 102.9
  TOP w0.076: v1(252.17,68.9) 252.52,69.26 252.99,69.26 253.06,69.34 253.76,69.34 253.89,69.2 253.89,68.83 254.12,68.6 U2700.AA2
  L3 w0.102: v2(250.39,80.16) 250.47,80.09 250.47,77.63 250.49,77.6 250.49,77.27 250.47,77.24 250.47,76.41 250.49,76.38 250.49,76.05 250.47,76.02 250.47,75.38 251.63,74.21 251.63,70.97 252.17,70.43 v1(252.17,68.9) 251.29,68.9 249.88,70.31 249.88,71.3 249.64,71.54 249.3,71.54 248.61,70.86 245.42,70.86 244.91,71.36 236.25,71.36 233.74,73.88 231.51,73.88 229.86,75.53 221.61,75.53 217.93,79.21 217.93,79.67 v1(217.73,79.87) ; v1(201.11,71.96) 201.06,71.96 199.99,73.03 197.19,73.03 196.48,73.74 195.59,73.74 195.54,73.68 194.23,73.68 193.73,73.18 193.56,73.18 192.96,72.57 190.66,72.57 190.21,73.02 183.58,73.02 183.41,73.2 182.47,73.2 v1(181.59,74.08)
  L6 w0.102: v1(201.11,71.96) 200.7,72.37 200.7,73.23 202.08,74.61 206.94,74.61 207,74.56 212.53,74.56 213.12,75.15 213.12,75.44 217.55,79.87 v1(217.73,79.87)
  BOTTOM w0.076: v1(181.59,74.08) 181.2,73.69 180.62,73.69 180.26,73.84 180.01,73.84 180.01,73.84 179.87,73.79 179.73,73.79 179.59,73.84 179.36,73.84 179.22,73.79 179,73.79 178.81,73.98 U4555.CM6
  BOTTOM w0.102: v1(201.11,71.96) 201.1,71.95 R4759.1 ; CN2701.4 250.4,80.15 v2(250.39,80.16)
DPC_TR_AUX_C_DN: length 3.4
  TOP w0.076: U2700.N2 258.03,68.83 258.03,69.27 257.9,69.41 257.9,70.41 257.53,70.78 C2727.1
DPC_TR_AUX_C_DP: length 3.4
  TOP w0.076: C2726.1 257.17,71.7 257.24,71.63 257.24,71.49 257.36,71.37 257.36,70.71 257.73,70.34 257.73,70.12 257.62,70.01 257.62,69.9 257.73,69.79 257.73,69.64 257.64,69.54 257.64,69.44 257.87,69.21 257.87,69.1 U2700.N1
DPC_TX0_DN: length 139.1
  TOP w0.119: v2(248.52,66.48) 248.8,66.23 249.61,66.23 C2719.2
  L6 w0.127: v1(155.27,88.38) 155.48,88.17 155.99,88.17 156.18,88.36 156.19,88.36 156.91,89.08 157.58,89.08 158.39,89.89 158.77,89.89 160.49,91.61 162.79,91.61 165.29,94.11 169.64,94.11 172.06,96.52 185.76,96.52 186.65,97.41 192.13,97.41 195.43,94.11 210.79,94.11 212.88,96.2 225.8,96.2 230.72,91.29 230.72,86.67 231.91,85.48 231.91,83.31 232.31,82.92 234.02,81.2 234.02,80.27 236.27,78.02 236.27,75.11 238.2,73.18 241.52,73.18 245.28,69.42 245.28,67.96 246.9,66.33 248.38,66.33 v2(248.52,66.48)
  BOTTOM w0.076: U4555.AC4 148.76,75.72 148.76,76.03 148.7,76.16 148.7,76.16 148.7,76.17 148.6,76.38 148.6,76.63 148.64,76.74 148.64,76.94 148.6,77.05 148.6,77.39 148.79,77.58 148.79,77.9 148.26,78.43 148.26,80.7 148.18,80.79 148.18,81.52 148.12,81.58 148.12,81.58
  BOTTOM w0.119: 148.12,81.58 148.12,84.83 151.46,88.16 155.05,88.16 v1(155.27,88.38)
DPC_TX0_DP: length 139.1
  TOP w0.119: C2718.2 249.63,66.01 248.78,66.01 v1(248.52,65.81)
  L6 w0.127: v1(155.27,87.72) 155.48,87.94 156.09,87.94 156.28,88.13 156.28,88.13 157.01,88.85 157.67,88.85 158.49,89.66 158.86,89.66 160.58,91.38 162.89,91.38 165.38,93.88 169.74,93.88 172.15,96.29 185.86,96.29 186.75,97.18 192.04,97.18 195.34,93.88 210.88,93.88 212.98,95.98 225.7,95.98 230.49,91.19 230.49,86.57 231.68,85.38 231.68,83.22 232.08,82.82 233.79,81.11 233.79,80.17 236.04,77.92 236.04,75.02 238.11,72.95 241.43,72.95 245.05,69.33 245.05,67.86 246.81,66.11 248.23,66.11 v1(248.52,65.81)
  BOTTOM w0.076: 148.34,81.63 148.34,80.86 148.43,80.77 148.43,78.5 148.96,77.97 148.96,77.51 148.77,77.32 148.77,77.07 148.81,76.97 148.81,76.71 148.77,76.61 148.77,76.42 148.83,76.26 148.92,76.18 149.14,76.18 149.37,75.95 149.37,75.74 149.21,75.59 149.11,75.59 149.03,75.67 U4555.AC3
  BOTTOM w0.119: v1(155.27,87.72) 155.05,87.94 151.55,87.94 148.34,84.74 148.34,81.63
DPC_TX1_DN: length 137.7
  TOP w0.119: C2721.2 249.62,64.89 248.79,64.89 v2(248.52,65.11)
  L6 w0.127: v2(248.52,65.11) 248.52,65.03 248.16,64.66 247.64,64.66 244.62,67.68 244.62,69.15 241.25,72.52 237.93,72.52 235.49,74.95 235.49,77.83 233.36,79.96 233.36,80.93 231.64,82.64 231.25,83.04 231.25,85.2 230.06,86.4 230.06,91.01 225.53,95.54 213.15,95.54 211.06,93.45 195.16,93.45 192.26,96.34 191.49,96.34 191.08,96.75 186.93,96.75 186.04,95.86 172.33,95.86 169.92,93.45 165.56,93.45 163.06,90.95 160.76,90.95 159.04,89.23 158.66,89.23 157.85,88.42 157.18,88.42 156.17,87.4 156.17,86.73 155.99,86.55 155.62,86.55 v1(155.27,86.91)
  BOTTOM w0.076: 148.77,79.21 148.77,79.2 148.79,79.18 148.79,78.37 149.15,78.01 149.15,77.28 U4555.AC1
  BOTTOM w0.119: v1(155.27,86.91) 155.07,86.7 154.83,86.7 154.56,86.98 154.56,87.15 154.18,87.52 151.73,87.52 148.77,84.56 148.77,79.21
DPC_TX1_DP: length 137.6
  TOP w0.119: C2720.2 249.62,64.67 248.79,64.67 v1(248.52,64.44)
  L6 w0.127: v1(155.27,86.25) 155.34,86.32 156.09,86.32 156.4,86.64 156.4,87.31 157.28,88.19 157.95,88.19 158.76,89 159.14,89 160.86,90.72 163.16,90.72 165.66,93.22 170.01,93.22 172.42,95.63 186.13,95.63 187.02,96.52 190.99,96.52 191.4,96.12 192.17,96.12 195.07,93.22 211.15,93.22 213.25,95.32 225.43,95.32 229.83,90.92 229.83,86.3 231.02,85.11 231.02,82.94 231.42,82.55 233.13,80.83 233.13,79.87 235.26,77.73 235.26,74.86 237.83,72.29 241.15,72.29 244.39,69.05 244.39,67.59 247.54,64.44 v1(248.52,64.44)
  BOTTOM w0.076: 148.99,79.21 148.99,79.2 148.96,79.18 148.96,78.44 149.32,78.08 149.32,77.06 U4555.AC2
  BOTTOM w0.119: 148.99,79.21 148.99,84.47 151.82,87.3 154.09,87.3 154.34,87.05 154.34,86.89 154.74,86.48 155.03,86.48 v1(155.27,86.25)
DPC_TX2_DN: length 130.5
  TOP w0.119: v2(248.52,63.76) 248.55,63.74 C2722.2
  L6 w0.127: v1(157.2,87.09) 157.47,87.09 158.95,88.57 159.89,88.57 160.9,89.58 162.63,89.58 165.84,92.79 199.68,92.79 202.06,90.4 222.73,90.4 226.34,86.79 226.34,85.58 229.12,82.79 230.56,82.79 232.29,81.06 232.29,76.86 235.77,73.38 235.77,72.18 236.43,71.52 236.43,70.87 241.04,66.26 242.79,66.26 242.98,66.26 245.38,63.86 245.85,63.86 245.95,63.76 v2(248.52,63.76)
  BOTTOM w0.076: U4555.AE4 150.43,75.72 150.43,76.03 150.5,76.17 150.59,76.4 150.59,76.63 150.54,76.76 150.54,76.93 150.58,77.04 150.58,77.42 150.43,77.58 150.43,80.68 150.98,81.24 151.02,81.24 151.04,81.25
  BOTTOM w0.119: v1(157.2,87.09) 157.34,86.95 157.79,86.95 158.22,86.52 158.22,83.39 157.65,82.82 152.08,82.82 151.25,81.99 151.25,81.46 151.04,81.25
DPC_TX2_DP: length 130.5
  TOP w0.119: v1(248.52,63.06) 248.98,63.52 249.42,63.52 C2723.2
  L6 w0.127: v1(248.52,63.06) 248.52,63.17 248.16,63.53 245.85,63.53 245.76,63.63 245.29,63.63 242.89,66.03 240.94,66.03 236.2,70.77 236.2,71.42 235.54,72.08 235.54,73.29 232.06,76.77 232.06,80.97 230.47,82.56 229.03,82.56 226.11,85.48 226.11,86.7 222.64,90.17 201.97,90.17 199.58,92.56 165.93,92.56 162.72,89.35 161,89.35 159.99,88.34 159.05,88.34 157.85,87.14 157.2,86.49 v1(157.2,86.4)
  BOTTOM w0.076: U4555.AE3 150.13,75.89 150.13,76.15 150.18,76.21 150.33,76.21 150.43,76.43 150.43,76.6 150.38,76.73 150.38,76.96 150.42,77.07 150.42,77.35 150.26,77.51 150.26,80.75 150.87,81.36 150.87,81.4 150.88,81.41
  BOTTOM w0.119: v1(157.2,86.4) 157.53,86.73 157.7,86.73 158,86.43 158,83.48 157.56,83.04 151.98,83.04 151.03,82.08 151.03,81.55 150.88,81.41
DPC_TX3_DN: length 127.9
  TOP w0.119: C2724.2 249.62,61.98 249.14,61.98 248.96,61.8 248.93,61.8 v1(248.75,61.62)
  L6 w0.127: v1(157.45,84.32) 157.45,84.46 157.87,84.88 157.87,85.15 158.9,86.18 158.9,86.36 160.23,87.68 160.26,87.68 161.27,88.69 163,88.69 166.2,91.9 199.31,91.9 201.7,89.51 222.36,89.51 225.42,86.45 225.42,85.24 228.75,81.9 230.19,81.9 231.4,80.69 231.4,75.69 231.25,75.54 231.25,73.2 232.14,72.32 234.38,72.32 235.54,71.15 235.54,70.5 240.67,65.37 242.61,65.37 245.02,62.97 245.48,62.97 246.54,61.91 248.46,61.91 v1(248.75,61.62)
  BOTTOM w0.076: 150.56,82.09 150.56,82.07 150.53,82.04 150.53,81.42 150.06,80.95 150.06,77.26 U4555.AE1
  BOTTOM w0.119: v1(157.45,84.32) 157.45,84.47 157.09,84.83 153.17,84.83 150.56,82.22 150.56,82.09
DPC_TX3_DP: length 128
  TOP w0.119: v2(248.75,62.29) 248.84,62.2 249.62,62.2 C2725.2
  L6 w0.127: v2(248.75,62.29) 248.61,62.14 246.63,62.14 245.58,63.2 245.11,63.2 242.71,65.6 240.76,65.6 235.77,70.59 235.77,71.24 234.47,72.54 232.23,72.54 231.48,73.3 231.48,75.45 231.63,75.6 231.63,80.79 230.29,82.13 228.85,82.13 225.65,85.33 225.65,86.55 222.46,89.74 201.79,89.74 199.4,92.13 166.11,92.13 162.9,88.92 161.18,88.92 160.16,87.91 160.13,87.91 158.67,86.45 158.67,86.27 v1(157.45,85.05)
  BOTTOM w0.076: U4555.AE2 149.89,77.06 149.89,81.01 150.37,81.49 150.37,82.04 150.34,82.07 150.34,82.09
  BOTTOM w0.119: v1(157.45,85.05) 153.08,85.05 150.34,82.31 150.34,82.09
DPWROK: length 154.8
  TOP w0.076: v1(238.23,39.99) U300.E7
  TOP w0.102: R4936.1 174.73,37.28 210.11,37.28 210.71,36.67 212.31,36.67 v2(212.41,36.77)
  L3 w0.102: v1(213,98.31) 213,96.23 216.78,92.46 216.78,91.72 221.34,87.16 221.34,83.91 220.21,82.78 v1(220.21,80.58)
  L6 w0.102: v1(223.44,39.18) 223.44,39.73 222.53,40.65 222.53,41.38 221.92,41.99 221.92,42.92 220.8,44.04 220.8,47.42 218.56,49.66 218.56,55.06 216.71,56.91 216.71,62.84 218.39,64.51 218.39,64.85 217.6,65.64 217.6,66.34 215.26,68.67 215.26,69.71 215.53,69.97 216.22,70.67 216.22,76.02 216.22,76.43 218.94,79.15 218.94,79.39 220.14,80.58 v1(220.21,80.58)
  BOTTOM w0.076: v1(238.23,39.99) 237.66,39.99 236.91,39.23 235.1,39.23 234.84,39.48 234.61,39.48 233.57,40.53 232.51,40.53
  BOTTOM w0.102: 232.51,40.53 232.11,40.53 231.99,40.65 231.7,40.65 231.14,41.21 230.57,41.21 230.01,40.65 229.83,40.65 229.74,40.56 228.8,40.56 228.79,40.55 227.98,40.55 227.19,39.77 224.06,39.77 223.7,39.41 223.7,39.36 223.52,39.18 v1(223.44,39.18) 222.84,39.18 222.54,39.49 220.21,39.49 217.9,37.17 212.81,37.17 v2(212.41,36.77) ; v1(213,98.31) 213.29,98.02 213.29,97.77 213.87,97.18 U7000.4 213.87,96.42 214.23,96.07 215.43,96.07 215.7,96.34 215.7,97.09 215.94,97.33 215.94,100.46 215.84,100.56 Q1002.6 215.15,101.74 R1014.1
DSW_PWROK: length 19.8
  TOP w0.076: v1(168.59,58.56) 168.96,58.19 168.96,57.75 168.82,57.61 168.82,57.02 169.25,56.59 169.62,56.59 170.02,56.19 170.02,53.01
  TOP w0.102: R4936.2 170.13,42.48 v3(170.13,43.17) 170.13,43.21 169.75,43.59 169.75,44.11 170.02,44.38 R4945.1 170.08,46.38 172.31,48.61 172.31,49.43 170.02,51.73 170.02,53.01
  BOTTOM w0.076: U4555.BP30 168.57,58.58 v1(168.59,58.56)
EC_ADC0: length 7.1
  TOP w0.076: U300.F2 242.12,40.65 244.04,40.65 244.22,40.83 245.44,40.83
  TOP w0.102: 245.44,40.83 246.39,40.83 246.52,40.71 R443.2 246.74,40.76 247.01,41.03 247.5,41.03 247.58,41.11 247.92,41.11 248.29,40.74 C309.1
EC_ADC1: length 10
  TOP w0.076: U300.E3 v1(241.48,39.99) ; v1(243.94,37.1) 244.04,37.1 244.76,36.37 244.76,36.01 245.34,35.44 R444.2
  TOP w0.102: R444.2 246.17,35.44 246.42,35.19 C320.1
  L3 w0.076: v1(243.94,37.1) 244.29,37.45 244.29,38.62 244.46,38.79 244.46,39.22 243.69,39.99 v1(241.48,39.99)
EC_ADC2: length 7.1
  TOP w0.076: v3(245.21,39.94) 245.15,40 242.58,40 242.32,40 242,40.31 U300.E2
  TOP w0.102: v3(245.21,39.94) 246.61,39.94 R300.2 246.74,40.02 247.09,39.66 247.92,39.66 248.29,40.03 C301.1
EC_ADC4: length 7
  TOP w0.076: 245.44,36.2 v3(245.42,36.21) 245.33,36.21 242.86,38.68 242.34,38.68 242,39.01 U300.C2
  TOP w0.102: C304.1 246.89,35.53 246.38,35.53 246.1,35.8 R302.2 245.78,35.85 245.44,36.2
EC_AVCC: length 6.8
  TOP w0.254: U300.D1 244.18,39.66 244.63,39.21 246.43,39.21 R381.2
  TOP w0.381: R381.2 246.67,39.17 247.19,38.65 C318.2 247.88,39.03 C313.2
