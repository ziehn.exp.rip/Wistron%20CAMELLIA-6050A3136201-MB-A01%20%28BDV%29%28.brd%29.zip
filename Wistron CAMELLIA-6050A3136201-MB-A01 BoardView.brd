# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_RX12_DN: length 189.1
  L3 w0.076: 165.87,76.39 165.87,76.38 165.89,76.36 165.89,75.57 165.45,75.13 165.45,74.57 v1(165.99,74.03)
  L3 w0.109: v2(258.72,13.72) 258.72,14.73 257.17,16.29 257.17,16.64 249.32,24.48 249.32,28.28 250.48,29.44 250.48,30.18 251.48,31.18 252.18,31.18 253.81,32.81 253.81,33.13 261.94,41.26 261.94,41.74 262.14,41.94 262.14,55.83 260.09,57.89 253.71,57.89 252.94,58.66 250.01,58.66 247.41,61.26 247.41,64.05 245.38,66.09 239.85,66.09 233.74,72.2 231.51,72.2 229.37,74.35 221.12,74.35 212.48,82.98 212.48,86.53 212.12,86.89 211.56,86.89 210.92,87.53 209.76,87.53 207.8,89.49 202.57,89.49 200.22,91.84 179.19,91.84 178.25,92.79 168.57,92.79 164.33,88.55 164.33,87.05 163.2,85.92 163.2,82.42 165.87,79.76 165.87,76.39
  BOTTOM w0.076: v1(165.99,74.03) 166.21,73.82 U4555.BL6
  BOTTOM w0.119: CN1951.43 258.65,13.64 v2(258.72,13.72)
PCIE_RX12_DP: length 189
  L3 w0.076: v2(165.99,74.7) 165.69,74.7 165.62,74.77 165.62,75.06 166.06,75.5 166.06,76.35 166.08,76.37 166.08,76.39
  L3 w0.109: 166.08,76.39 166.08,79.84 163.42,82.51 163.42,85.83 164.55,86.96 164.55,88.46 168.66,92.58 178.16,92.58 179.11,91.63 200.13,91.63 202.48,89.28 207.72,89.28 209.67,87.32 210.84,87.32 211.48,86.68 212.03,86.68 212.27,86.44 212.27,82.9 221.03,74.13 229.28,74.13 231.43,71.99 233.65,71.99 239.76,65.88 245.29,65.88 247.2,63.96 247.2,61.17 249.92,58.45 252.85,58.45 253.63,57.68 260,57.68 261.93,55.75 261.93,42.02 261.73,41.83 261.73,41.35 253.6,33.22 253.6,32.9 252.09,31.39 251.4,31.39 250.27,30.27 250.27,29.53 249.11,28.37 249.11,24.4 256.96,16.55 256.96,16.2 258.51,14.65 258.51,14.09 258.14,13.72 v1(258.05,13.72)
  BOTTOM w0.076: v2(165.99,74.7) 166.01,74.7 166.32,75.01 166.46,75.01 166.54,74.93 166.54,74.55 U4555.BL5
  BOTTOM w0.119: CN1951.41 258.15,12.99 258.43,13.27 258.43,13.42 258.14,13.72 v1(258.05,13.72)
PCIE_RX14_DN: length 128.5
  L6 w0.076: 161.67,70.01 161.68,70.01 161.71,70.05 162.11,70.05 162.26,70.2 162.53,70.2 162.53,70.2 163.06,70.2 163.57,70.71 163.57,70.97 163.76,71.16 163.76,71.55 164.68,72.47 164.68,73.56 164.85,73.73 164.85,73.82 v1(165.07,74.03)
  L6 w0.127: 161.67,70.01 134.8,70.01 131.52,66.74 127.02,66.74 122.07,61.79 121.43,61.79 120.42,60.77 120.42,60.45 119.45,59.49 118.36,59.49 117.48,58.6 116.78,58.6 115.78,57.59 115.78,47.32 113.1,44.64 102.1,44.64 91.35,33.89 91.35,33.24 86.84,28.73 85.73,28.73 85.32,28.32 81.69,28.32 79.8,26.43 71.11,26.43 70.3,25.62 68.87,25.62 68.61,25.88 68.61,26.24 v2(68.42,26.41)
  BOTTOM w0.076: U4555.BJ6 164.82,74.03 v1(165.07,74.03)
  BOTTOM w0.119: v2(68.42,26.41) 68.61,26.56 68.61,26.85 68.86,27.09 69.85,27.09 70.01,27.25 CN1300.43
PCIE_RX14_DP: length 128.6
  L6 w0.076: 161.67,70.24 161.68,70.24 161.71,70.21 162.04,70.21 162.2,70.37 162.59,70.37 162.6,70.36 162.99,70.36 163.37,70.74 163.37,71 163.6,71.23 163.6,71.62 164.52,72.54 164.52,73.63 164.69,73.79 164.69,74.14 164.63,74.2 164.31,74.2 v2(164.14,74.03)
  L6 w0.127: v1(69.08,26.41) 68.84,26.19 68.84,25.97 68.97,25.85 70.2,25.85 71.02,26.66 79.7,26.66 81.6,28.55 85.23,28.55 85.64,28.96 86.74,28.96 91.12,33.33 91.12,33.98 102.01,44.87 113,44.87 115.55,47.42 115.55,57.69 116.69,58.83 117.38,58.83 118.27,59.72 119.36,59.72 120.19,60.55 120.19,60.87 121.34,62.02 121.97,62.02 126.92,66.97 131.43,66.97 134.71,70.24 161.67,70.24
  BOTTOM w0.076: v2(164.14,74.03) 164.22,74.11 164.6,74.11 164.72,74.22 164.72,74.35 U4555.BJ5
  BOTTOM w0.119: v1(69.08,26.41) 68.83,26.64 68.83,26.75 68.95,26.87 69.89,26.87 70.01,26.75 CN1300.41
PCIE_RX16_DN: length 113.7
  L3 w0.076: v2(162.32,74.71) 161.99,74.71 161.92,74.79 161.92,75.61 160.89,76.64 160.89,76.67 160.87,76.69
  L3 w0.109: 160.87,76.69 160.36,77.2 160.36,77.2 160.12,77.44 160.12,77.77 160.31,77.96 160.31,87.45 160.6,87.74 160.96,87.74 167.82,94.6 169.39,94.6 171.16,96.37 182.38,96.37 185.09,93.66 203.02,93.66 203.65,93.04 203.65,92.67 v1(203.3,92.32)
  BOTTOM w0.076: U4555.BE5 162.81,74.41 163.03,74.41 163.11,74.48 163.11,74.59 162.79,74.92 162.53,74.92 v2(162.32,74.71)
  BOTTOM w0.119: CN1400.41 208.75,52.99 208.89,53.13 208.89,53.22 209.03,53.36 209.03,53.5 208.7,53.83 206.85,53.83 206.01,54.67 203.52,54.67 202.06,56.13 202.06,61.26 202.88,62.08 202.88,65.56 202.19,66.25 202.19,68.38 202.01,68.57 202.01,71.64 201.54,72.1 201.54,74.65 201.11,75.09 201.11,78.14 199.67,79.57 199.67,84.61 203.6,88.54 203.6,92.01 v1(203.3,92.32)
PCIE_RX16_DP: length 113.7
  L3 w0.076: v1(162.31,74.04) 162.31,74.16 161.75,74.72 161.75,75.54 160.77,76.53 160.74,76.53 160.73,76.54
  L3 w0.109: v2(203.96,92.32) 203.86,92.42 203.86,93.12 203.11,93.87 185.18,93.87 182.47,96.58 171.07,96.58 169.3,94.81 167.73,94.81 160.87,87.96 160.52,87.96 160.1,87.54 160.1,78.05 159.91,77.86 159.91,77.35 160.15,77.11 160.73,76.54
  BOTTOM w0.076: U4555.BE6 v1(162.31,74.04)
  BOTTOM w0.119: CN1400.43 209.25,53.59 208.79,54.06 206.94,54.06 206.1,54.89 203.61,54.89 202.28,56.23 202.28,61.17 203.11,61.99 203.11,65.65 202.42,66.34 202.42,68.47 202.23,68.66 202.23,71.73 201.77,72.2 201.77,74.74 201.33,75.18 201.33,78.23 199.9,79.66 199.9,84.52 203.82,88.45 203.82,92.18 v2(203.96,92.32)
PCIE_TX5_C_DN: length 4.7
  TOP w0.076: U2700.Y22 254.38,59.13 254.38,59.1 254.36,59.08 254.36,58.74 254.4,58.69 254.4,58.27 253.96,57.82 253.23,57.82 252.19,56.79 252.19,56.6 C4616.1
PCIE_TX5_C_DP: length 4.6
  TOP w0.076: C4617.1 252.36,56.44 252.36,56.72 253.3,57.66 254.03,57.66 254.57,58.2 254.57,58.43 254.82,58.68 254.82,59.03 254.74,59.1 254.64,59.1 254.58,59.04 U2700.Y23
PCIE_TX5_DN: length 111.3
  TOP w0.119: v1(251.36,53.18) 251.68,53.18 252.08,53.58 252.08,55.6 C4616.2
  L3 w0.109: v1(172.92,85.64) 173.13,85.43 173.31,85.43 175.25,87.38 176.59,87.38 177.33,86.63 181.67,86.63 181.92,86.39 192.05,86.39 194.53,83.91 196.13,83.91 196.98,83.06 198.1,83.06 200.93,80.24 202.4,80.24 204.32,78.32 206.75,78.32 209.4,75.66 209.4,75.4 213.53,71.27 213.53,68.96 214.08,68.41 218.31,68.41 218.53,68.19 219.3,68.19 219.94,67.55 221.24,67.55 221.46,67.77 226.94,67.77 233.84,60.87 233.84,60.55 234.44,59.94 239.75,59.94 240.18,59.51 242.09,59.51 247.93,53.67 250.23,53.67 251.08,52.82 251.23,52.82 251.36,52.94 v1(251.36,53.18)
  BOTTOM w0.076: U4555.BW4 170.73,75.48 170.73,76.04 170.67,76.18 170.65,76.2 170.55,76.43 170.55,76.58 170.61,76.74 170.61,76.94 170.56,77.06 170.56,77.38 170.74,77.56 170.74,77.88 170.14,78.48 170.14,80.94 170.43,81.24 170.43,81.28 170.45,81.29
  BOTTOM w0.119: v1(172.92,85.64) 172.66,85.38 172.27,85.38 172.03,85.14 172.03,83.77 170.96,82.71 170.96,81.81 170.45,81.29
PCIE_TX5_DP: length 111.4
  TOP w0.119: C4617.2 252.3,55.6 252.3,53.49 251.84,53.02 v1(251.84,52.69)
  L3 w0.109: v2(172.92,84.98) 173.17,85.22 173.39,85.22 175.33,87.17 176.5,87.17 177.24,86.42 181.58,86.42 181.83,86.18 191.97,86.18 194.45,83.7 196.04,83.7 196.89,82.85 198.02,82.85 200.84,80.03 202.31,80.03 204.24,78.11 206.66,78.11 209.19,75.58 209.19,75.31 213.32,71.18 213.32,68.87 213.99,68.2 218.22,68.2 218.44,67.98 219.21,67.98 219.86,67.34 221.32,67.34 221.54,67.56 226.85,67.56 233.62,60.79 233.62,60.46 234.35,59.73 239.66,59.73 240.09,59.3 242,59.3 247.85,53.45 250.14,53.45 250.99,52.61 251.32,52.61 251.41,52.69 v1(251.84,52.69)
  BOTTOM w0.076: U4555.BW3 171,75.82 171.08,75.74 171.19,75.74 171.28,75.82 171.28,76.01 171.08,76.2 170.88,76.2 170.79,76.3 170.71,76.46 170.71,76.55 170.77,76.71 170.77,76.97 170.73,77.09 170.73,77.31 170.9,77.49 170.9,77.95 170.3,78.55 170.3,80.87 170.55,81.12 170.59,81.12 170.6,81.13
  BOTTOM w0.119: v2(172.92,84.98) 172.74,85.16 172.37,85.16 172.25,85.04 172.25,83.68 171.19,82.62 171.19,81.71 170.6,81.13
PCIE_TX6_C_DN: length 4.3
  TOP w0.076: C4618.1 254.75,56.49 254.75,56.76 255.24,57.25 255.74,57.25 256.47,57.98 256.47,58.55 256.65,58.73 256.65,59.08 256.42,59.31 U2700.T22
PCIE_TX6_C_DP: length 4.3
  TOP w0.076: C4619.1 254.58,56.55 254.58,56.83 255.17,57.42 255.67,57.42 256.3,58.05 256.3,58.47 256.19,58.58 256.19,59.06 256.25,59.11 256.35,59.11 256.42,59.04 U2700.T23
PCIE_TX6_DN: length 114.5
  TOP w0.119: C4618.2 254.74,55.6 254.74,54.27 255.32,53.69 255.32,52.8 254.98,52.47 254.56,52.47 v1(254.43,52.34)
  L3 w0.109: v2(171.6,85.05) 171.75,85.2 172.08,85.2 172.42,85.54 172.42,86.38 172.75,86.71 174,86.71 175.08,87.79 176.76,87.79 177.5,87.05 181.84,87.05 182.09,86.8 198.2,86.8 199.04,85.96 199.61,85.96 203.28,82.29 206.01,82.29 209.1,79.21 218.54,69.76 221.18,69.76 221.69,69.25 226.04,69.25 234.25,61.05 234.25,60.72 234.61,60.35 239.92,60.35 240.35,59.92 242.26,59.92 248.11,54.08 251.03,54.08 251.81,53.3 252.33,53.3 252.89,53.3 253.64,52.56 254.21,52.56 v1(254.43,52.34)
  BOTTOM w0.076: 170.14,81.67 170.13,81.66 170.09,81.66 169.91,81.48 169.91,77.6 170.12,77.39 170.12,77.06 170.06,76.89 170.06,76.78 170.11,76.64 170.11,76.38 169.96,76.02 169.96,75.72 U4555.BU4
  BOTTOM w0.119: v2(171.6,85.05) 170.99,84.45 170.99,83.34 170.37,82.72 170.37,81.9 170.14,81.67
PCIE_TX6_DP: length 114.5
  TOP w0.119: C4619.2 254.52,55.6 254.52,54.18 255.1,53.6 255.1,52.89 254.89,52.69 254.72,52.69 254.43,52.97 v1(254.43,53.02)
  L3 w0.109: v1(171.6,85.77) 171.6,85.63 171.83,85.41 171.99,85.41 172.21,85.63 172.21,86.47 172.66,86.92 173.91,86.92 174.99,88 176.85,88 177.59,87.26 181.93,87.26 182.18,87.01 198.28,87.01 199.13,86.17 199.7,86.17 203.37,82.5 206.1,82.5 218.63,69.97 221.27,69.97 221.77,69.47 226.13,69.47 234.46,61.13 234.46,60.8 234.7,60.56 240.01,60.56 240.44,60.13 242.35,60.13 248.19,54.29 251.12,54.29 251.9,53.51 252.24,53.51 252.98,53.51 253.72,52.77 254.17,52.77 v1(254.43,53.02)
  BOTTOM w0.076: U4555.BU3 169.79,75.97 169.79,76.06 169.95,76.42 169.95,76.61 169.9,76.75 169.9,76.92 169.96,77.09 169.96,77.32 169.74,77.53 169.74,81.55 169.97,81.77 169.97,81.81 169.99,81.83
  BOTTOM w0.119: 169.99,81.83 170.15,81.99 170.15,82.81 170.77,83.43 170.77,84.54 171.19,84.95 171.19,85.23 171.6,85.64 v1(171.6,85.77)
PCIE_TX7_C_DN: length 3.8
  TOP w0.076: C4632.1 256.99,56.52 256.99,56.99 258.17,58.16 258.17,58.52 258.03,58.66 258.03,59.1 U2700.M22
PCIE_TX7_C_DP: length 3.8
  TOP w0.076: U2700.M23 258.26,59.04 258.32,59.1 258.42,59.1 258.5,59.03 258.5,58.67 258.34,58.51 258.34,58.1 257.16,56.92 257.16,56.51 C4633.1
PCIE_TX7_DN: length 115.2
  TOP w0.119: C4632.2 256.83,55.73 256.83,55.22 256.98,55.07 256.98,53.41 256.89,53.32 256.62,53.32 v1(256.44,53.51)
  L3 w0.109: v1(170.28,84.98) 170.81,85.5 170.81,86.51 171.34,87.05 171.91,87.05 172.4,87.55 173.65,87.55 174.73,88.63 177.11,88.63 177.85,87.88 182.19,87.88 182.43,87.64 198.54,87.64 199.38,86.8 199.96,86.8 203.63,83.13 206.45,83.13 218.98,70.6 221.53,70.6 222.03,70.09 226.39,70.09 234.14,62.34 239.12,62.34 240.7,60.76 242.61,60.76 248.45,54.92 251.38,54.92 252.16,54.14 254.78,54.14 255.41,53.51 v1(256.44,53.51)
  BOTTOM w0.076: U4555.BU2 169.68,76.75 169.35,77.08 169.35,81.7 169.32,81.73 169.32,81.75
  BOTTOM w0.119: v1(170.28,84.98) 170.04,84.74 169.67,84.74 169.37,84.45 169.37,83.35 169.32,83.3 169.32,81.75
PCIE_TX7_DP: length 115.1
  TOP w0.119: v1(256.44,52.9) 256.64,53.1 256.98,53.1 257.2,53.32 257.2,55.16 257.05,55.31 257.05,55.48 C4633.2
  L3 w0.109: v2(170.28,84.32) 170.28,84.4 170.69,84.81 170.69,85.09 171.02,85.42 171.02,86.43 171.43,86.84 171.99,86.84 172.49,87.34 173.74,87.34 174.82,88.42 177.02,88.42 177.76,87.67 182.1,87.67 182.35,87.43 198.46,87.43 199.3,86.59 199.87,86.59 203.54,82.92 206.36,82.92 218.89,70.39 221.44,70.39 221.94,69.88 226.3,69.88 234.05,62.13 239.03,62.13 240.61,60.55 242.52,60.55 248.36,54.7 251.29,54.7 252.07,53.93 254.7,53.93 255.33,53.3 256.07,53.3 256.44,52.93 v1(256.44,52.9)
  BOTTOM w0.076: 169.54,81.75 169.54,81.73 169.52,81.7 169.52,77.33 U4555.BU1
  BOTTOM w0.119: v2(170.28,84.32) 170.27,84.37 170.09,84.52 169.76,84.52 169.6,84.36 169.6,83.26 169.54,83.21 169.54,81.75
PCIE_TX8_C_DN: length 3.5
  TOP w0.076: C4634.1 259.44,56.51 259.44,57.46 260,58.02 260,58.61 259.88,58.74 259.88,58.75 259.87,58.75 259.87,59.08 260.1,59.31 U2700.H22
PCIE_TX8_C_DP: length 3.5
  TOP w0.076: U2700.H23 260.1,59.04 260.16,59.1 260.26,59.1 260.34,59.03 260.34,58.63 260.17,58.47 260.17,57.95 259.61,57.39 259.61,56.52 C4635.1
PCIE_TX8_DN: length 122.1
  TOP w0.119: C4634.2 259.33,55.8 259.62,55.51 259.62,53.73 259.5,53.61 258.59,53.61 258.29,53.91 v1(258.29,54.07)
  L3 w0.109: v1(258.29,54.07) 258.51,53.82 258.7,53.82 258.8,53.93 258.8,54.45 258.71,54.55 252.33,54.55 251.55,55.33 248.62,55.33 241.98,61.97 241.98,62.04 241.27,62.75 234.31,62.75 226.56,70.5 222.2,70.5 221.7,71.01 219.15,71.01 206.62,83.54 203.8,83.54 200.13,87.21 199.56,87.21 198.72,88.05 182.61,88.05 182.36,88.3 178.02,88.3 176.87,89.45 174.77,89.45 173.28,87.96 172.23,87.96 171.74,87.46 171.17,87.46 169.7,86 169.7,85.44 169.37,85.11 169.37,84.82 168.96,84.41 168.96,84.41 v2(168.96,84.32)
  BOTTOM w0.076: U4555.BT4 169.42,76.1 169.42,76.78 169.15,77.05 169.15,78.72 168.4,79.47 168.4,81.8 168.43,81.83 168.43,81.85
  BOTTOM w0.119: v2(168.96,84.32) 168.76,84.46 168.59,84.46 168.43,84.29 168.43,81.85
PCIE_TX8_DP: length 122.1
  TOP w0.119: C4635.2 259.84,53.63 259.59,53.39 v1(258.26,53.39)
  L3 w0.109: v1(258.26,53.39) 258.49,53.61 258.78,53.61 259.02,53.84 259.02,54.54 258.79,54.76 252.42,54.76 251.64,55.54 248.71,55.54 242.19,62.06 242.19,62.13 241.36,62.96 234.4,62.96 226.65,70.72 222.29,70.72 221.79,71.22 219.24,71.22 218.51,71.95 206.71,83.75 203.89,83.75 200.22,87.42 199.64,87.42 198.8,88.26 182.69,88.26 182.45,88.51 178.11,88.51 176.95,89.66 174.68,89.66 173.19,88.17 172.15,88.17 171.65,87.68 171.08,87.68 169.49,86.08 169.49,85.53 v1(168.96,84.99)
  BOTTOM w0.076: U4555.BT3 169.14,76.19 169.26,76.31 169.26,76.71 168.99,76.98 168.99,78.65 168.23,79.4 168.23,81.8 168.2,81.83 168.2,81.85
  BOTTOM w0.119: v1(168.96,84.99) 168.64,84.68 168.5,84.68 168.2,84.38 168.2,81.85
PCIE_TX9_C_DN: length 3
  TOP w0.119: v2(250.55,13.72) 250.82,13.95 250.82,14.5 C4614.1
  BOTTOM w0.119: CN1951.11 250.65,12.99 250.82,13.15 250.82,13.43 v2(250.55,13.72)
PCIE_TX9_C_DP: length 3
  TOP w0.119: v1(251.3,13.69) 251.04,13.95 251.04,14.5 C4615.1
  BOTTOM w0.119: v1(251.3,13.69) 251.04,13.43 251.04,13.1 251.15,12.99 251.15,12.03 CN1951.13
PCIE_TX9_DN: length 166.6
  TOP w0.119: C4614.2 250.81,15.39 250.81,16.22 v1(250.55,16.48)
  L3 w0.109: v2(167.67,84.32) 167.94,84.62 168.18,84.62 168.47,84.91 168.47,85.75 170.81,88.09 171.34,88.09 173.32,90.08 177.12,90.08 178.28,88.92 182.62,88.92 182.87,88.68 196.45,88.68 198.97,88.68 199.82,87.84 200.39,87.84 204.06,84.17 206.88,84.17 217,74.05 217.58,74.05 219.99,71.63 221.96,71.63 222.37,71.22 227.61,71.22 235.46,63.38 241.53,63.38 242.6,62.3 242.6,62.23 248.88,55.95 251.81,55.95 252.59,55.18 258.96,55.18 259.43,54.71 259.43,43.06 259.23,42.86 259.23,42.71 256.26,39.74 256.26,39.74 256.02,39.5 255.28,39.5 249.56,33.78 249.56,33.1 247.77,31.3 247.77,30.56 246.61,29.4 246.61,26.09 246.12,25.6 246.12,22.73 250.82,18.03 250.82,16.75 v1(250.55,16.48)
  BOTTOM w0.076: 167.35,81.04 167.36,81.03 167.36,80.99 167.51,80.84 167.51,79.89 168.82,78.58 168.82,77.01 168.56,76.75 U4555.BR2
  BOTTOM w0.119: v2(167.67,84.32) 167.38,84.57 167.18,84.57 167.06,84.46 167.06,81.33 167.35,81.04
PCIE_TX9_DP: length 166.6
  TOP w0.119: C4615.2 251.03,15.39 251.03,16.22 v1(251.3,16.48)
  L3 w0.109: v1(167.64,85.05) 167.86,84.83 168.09,84.83 168.26,85 168.26,85.84 170.73,88.3 171.25,88.3 173.24,90.29 177.21,90.29 178.37,89.13 182.71,89.13 182.95,88.89 196.37,88.89 199.06,88.89 199.9,88.05 200.48,88.05 204.15,84.38 206.97,84.38 217.08,74.26 217.67,74.26 220.08,71.85 222.04,71.85 222.45,71.44 227.69,71.44 235.54,63.59 241.61,63.59 242.82,62.39 242.82,62.32 248.97,56.16 251.9,56.16 252.68,55.39 259.05,55.39 259.64,54.8 259.64,42.97 259.44,42.78 259.44,42.63 256.47,39.65 256.11,39.29 255.37,39.29 249.78,33.7 249.78,33.01 247.98,31.22 247.98,30.48 246.82,29.32 246.82,26 246.33,25.51 246.33,22.82 251.03,18.12 251.03,16.75 v1(251.3,16.48)
  BOTTOM w0.076: U4555.BR1 168.65,77.26 168.65,78.51 167.34,79.82 167.34,80.77 167.24,80.88 167.2,80.88 167.19,80.89
  BOTTOM w0.119: v1(167.64,85.05) 167.38,84.8 167.09,84.8 166.84,84.55 166.84,81.23 167.19,80.89
PCIE_TX10_C_DN: length 3
  TOP w0.119: v2(253.56,13.72) 253.79,13.93 253.79,14.52 C4612.1
  BOTTOM w0.119: CN1951.23 253.65,12.98 253.82,13.15 253.82,13.43 v2(253.56,13.72)
PCIE_TX10_C_DP: length 3
  TOP w0.119: v1(254.3,13.69) 254.01,13.98 254.01,14.48 C4613.1
  BOTTOM w0.119: v1(254.3,13.69) 254.04,13.43 254.04,13.1 254.15,12.99 254.15,12.03 CN1951.25
PCIE_TX10_DN: length 156.2
  TOP w0.119: C4612.2 253.76,15.34 253.76,16.5 254.06,16.8 254.15,16.8 v1(254.56,17.2)
  L6 w0.127: v1(254.56,17.2) 253.55,18.21 253.55,26.35 253.74,26.54 253.74,41.7 253.44,42.01 253.44,45.69 248.4,50.73 248.4,55.96 241.55,62.81 236.32,62.81 236.32,62.81 234.63,62.81 229.97,67.47 229.97,69.19 223.61,75.56 223.61,80.73 221.47,82.87 216.14,82.87 215.8,82.53 213.67,82.53 213.33,82.87 211.28,82.87 211.28,82.87 207.07,82.87 206.69,83.25 202.82,83.25 198.51,87.56 169.88,87.56 168.69,86.36 167.37,86.36 166.96,85.96 166.96,85.59 v1(166.37,85)
  BOTTOM w0.076: U4555.BR4 168.29,75.48 168.29,76.04 168.23,76.18 168.21,76.2 168.11,76.43 168.11,76.58 168.17,76.74 168.17,76.94 168.12,77.06 168.12,77.38 168.3,77.56 168.3,78.4 165.63,81.07 165.63,81.83 165.6,81.86 165.6,81.87
  BOTTOM w0.119: 165.6,81.87 165.6,84.49 165.85,84.74 166.11,84.74 v1(166.37,85)
PCIE_TX10_DP: length 156.2
  TOP w0.119: C4613.2 253.98,15.44 253.98,16.41 254.15,16.58 254.44,16.58 v1(254.56,16.46)
  L6 w0.127: v1(254.56,16.46) 254.56,16.61 254.14,17.03 254.14,17.3 253.32,18.12 253.32,26.44 253.51,26.63 253.51,41.61 253.21,41.91 253.21,45.59 248.17,50.63 248.17,55.86 241.45,62.58 236.42,62.58 234.53,62.58 229.74,67.37 229.74,69.1 223.38,75.46 223.38,80.64 221.37,82.64 216.24,82.64 215.9,82.3 213.58,82.3 213.23,82.64 211.19,82.64 206.97,82.64 206.59,83.02 202.72,83.02 198.42,87.33 169.98,87.33 168.79,86.13 167.46,86.13 167.19,85.86 167.19,85.5 166.79,85.1 166.79,84.83 166.4,84.43 v2(166.4,84.32)
  BOTTOM w0.076: U4555.BR3 168.56,75.82 168.64,75.74 168.75,75.74 168.84,75.82 168.84,76.01 168.64,76.2 168.44,76.2 168.34,76.3 168.27,76.46 168.27,76.55 168.33,76.71 168.33,76.97 168.29,77.09 168.29,77.31 168.46,77.49 168.46,78.47 165.8,81.14 165.8,81.83 165.82,81.86 165.82,81.87
  BOTTOM w0.119: v2(166.4,84.32) 166.11,84.52 165.95,84.52 165.82,84.4 165.82,81.87
PCIE_TX11_C_DN: length 3
  TOP w0.119: v2(256.55,13.72) 256.82,13.95 256.82,14.51 C4820.1
  BOTTOM w0.119: v2(256.55,13.72) 256.82,13.43 256.82,13.15 256.65,12.98 CN1951.35
PCIE_TX11_C_DP: length 3
  TOP w0.119: v1(257.3,13.69) 257.04,13.95 257.04,14.49 C4821.1
  BOTTOM w0.119: CN1951.37 257.15,12.03 257.15,12.99 257.04,13.1 257.04,13.43 v1(257.3,13.69)
PCIE_TX11_DN: length 161
  TOP w0.119: v1(257.58,17.2) 257.31,16.93 256.89,16.93 256.64,16.68 256.64,15.42 256.64,15.42 C4820.2
  L6 w0.127: v1(165.1,85) 165.11,85 165.68,85.58 165.68,87.65 166.37,88.34 168.04,88.34 168.17,88.22 198.79,88.22 203.09,83.91 206.96,83.91 207.34,83.53 211.56,83.53 213.6,83.53 213.94,83.19 215.53,83.19 215.87,83.53 221.74,83.53 224.27,81.01 224.27,75.83 230.63,69.47 230.63,68.53 235.69,63.47 236.05,63.47 236.05,63.47 241.82,63.47 249.06,56.23 249.06,51 254.1,45.96 254.1,42.28 254.4,41.98 254.4,33.79 255,33.2 255,27.27 256.37,25.9 256.37,18.41 v1(257.58,17.2)
  BOTTOM w0.076: 164.33,81.9 164.33,81.88 164.36,81.85 164.36,81.64 165.24,80.76 165.38,80.76 166.21,79.93 166.93,79.22 166.93,77.91 167.52,77.32 167.52,77.09 167.46,76.94 167.46,76.75 167.51,76.61 167.51,76.43 167.41,76.19 167.15,76.19 166.98,76.02 166.98,75.69 167.1,75.48 U4555.BN4
  BOTTOM w0.119: v1(165.1,85) 164.82,84.72 164.59,84.72 164.33,84.47 164.33,81.9
PCIE_TX11_DP: length 161
  TOP w0.119: v1(257.58,16.46) 257.33,16.71 256.98,16.71 256.86,16.59 256.86,15.53 257.2,15.19 C4821.2
  L6 w0.127: v1(257.58,16.46) 257.58,16.61 257.16,17.03 257.16,17.3 256.14,18.32 256.14,25.81 254.77,27.18 254.77,33.1 254.17,33.7 254.17,41.88 253.87,42.19 253.87,45.86 248.83,50.91 248.83,56.14 241.73,63.24 236.15,63.24 236.14,63.24 235.6,63.24 230.4,68.44 230.4,69.37 224.04,75.74 224.04,80.91 221.65,83.3 215.97,83.3 215.62,82.96 213.85,82.96 213.51,83.3 211.46,83.3 207.25,83.3 206.86,83.68 203,83.68 198.69,87.99 168.07,87.99 167.94,88.11 166.47,88.11 165.91,87.56 165.91,85.48 165.52,85.09 165.52,84.83 165.12,84.44 v2(165.12,84.32)
  BOTTOM w0.076: U4555.BN3 167.24,75.66 167.32,75.59 167.44,75.59 167.52,75.66 167.52,75.84 167.52,75.84 167.52,76.02 167.59,76.2 167.68,76.39 167.68,76.64 167.63,76.78 167.63,76.91 167.68,77.07 167.68,77.39 167.09,77.98 167.09,79.29 166.33,80.05 165.45,80.92 165.31,80.92 164.53,81.71 164.53,81.85 164.56,81.88 164.56,81.9
  BOTTOM w0.119: v2(165.12,84.32) 165.12,84.38 165,84.49 164.67,84.49 164.56,84.38 164.56,81.9
PCIE_TX12_C_DN: length 3
  TOP w0.119: C4818.1 259.79,14.54 259.79,14.01 v1(259.55,13.77)
  BOTTOM w0.119: v1(259.55,13.77) 259.82,13.5 259.82,12.95 259.65,12.78 CN1951.47
PCIE_TX12_C_DP: length 3
  TOP w0.119: C4819.1 260.01,14.46 260.01,14.06 v1(260.28,13.77)
  BOTTOM w0.119: CN1951.49 260.15,12.03 260.15,12.63 260.04,12.74 260.04,13.5 v1(260.28,13.77)
PCIE_TX12_DN: length 164.3
  TOP w0.119: C4818.2 259.63,16.56 260.01,16.94 260.31,16.94 v1(260.58,17.2)
  L6 w0.127: v1(260.58,17.2) 260.31,17.2 257.46,20.05 257.46,21.05 257.03,21.48 257.03,26.18 255.66,27.55 255.66,33.47 255.06,34.07 255.06,42.3 254.76,42.61 254.76,46.23 249.72,51.28 249.72,56.51 242.1,64.13 235.97,64.13 231.29,68.81 231.29,69.74 224.93,76.11 224.93,81.28 222.02,84.19 216.88,84.19 216.82,84.25 207.55,84.25 207.23,84.57 203.36,84.57 197.94,89.99 167.09,89.99 165.02,87.93 165.02,86.43 164.39,85.79 164.39,85.57 v1(163.83,85)
  BOTTOM w0.076: 162.95,81.97 162.95,81.96 162.98,81.93 162.98,81.71 164.71,79.97 165.62,79.97 166.6,78.99 166.6,77.16 U4555.BN2
  BOTTOM w0.119: v1(163.83,85) 163.55,84.73 163.16,84.73 162.95,84.51 162.95,81.97
PCIE_TX12_DP: length 164.3
  TOP w0.119: v1(260.58,16.41) 260.59,16.59 260.48,16.72 260.11,16.72 259.86,16.47 259.86,15.53 260.19,15.19 C4819.2
  L6 w0.127: v2(163.83,84.32) 163.83,84.32 163.83,84.41 164.24,84.83 164.24,85.1 164.62,85.47 164.62,85.7 165.25,86.33 165.25,87.83 167.18,89.77 197.85,89.77 203.27,84.34 207.14,84.34 207.46,84.02 216.72,84.02 216.79,83.96 221.92,83.96 224.7,81.18 224.7,76.01 231.06,69.65 231.06,68.71 235.87,63.9 242,63.9 249.49,56.41 249.49,51.18 254.53,46.14 254.53,42.52 254.83,42.21 254.83,33.97 255.43,33.38 255.43,27.45 256.8,26.08 256.8,21.39 257.24,20.95 257.24,19.95 260.58,16.61 v1(260.58,16.41)
  BOTTOM w0.076: 163.17,81.97 163.14,81.94 163.14,81.77 164.78,80.13 165.69,80.13 166.76,79.06 166.76,77.23 166.98,77.01 167.09,77.01 U4555.BN1
  BOTTOM w0.119: v2(163.83,84.32) 163.59,84.51 163.25,84.51 163.17,84.42 163.17,81.97
PCIE_TX14_C_DN: length 4.7
  BOTTOM w0.119: C4651.1 73.76,28.05 73.56,28.05 73.23,27.72 73.23,27.21 72.19,26.17 72.19,25.9 72.04,25.75 CN1300.37
PCIE_TX14_C_DP: length 4.7
  BOTTOM w0.119: C4652.1 74.02,27.83 73.65,27.83 73.45,27.63 73.45,27.11 72.41,26.07 72.41,25.81 71.86,25.25 CN1300.35
PCIE_TX14_DN: length 125.6
  L6 w0.127: v1(76.21,27.36) 76.63,27.78 80.21,27.78 81.42,28.98 85.05,28.98 85.18,29.12 85.46,29.39 86.57,29.39 90.69,33.51 90.69,34.96 101.03,45.3 111.7,45.3 115.12,48.72 115.12,57.87 116.51,59.26 117.2,59.26 118.09,60.15 118.27,60.15 125.53,67.41 131.05,67.41 135.75,72.12 139.95,72.12 139.95,72.11 140.74,72.11 140.79,72.06 161.57,72.06 162.81,73.31 162.81,73.52 163.73,74.44 163.73,74.89 166.39,77.55 166.39,78.72 166.13,78.98 v1(165.46,78.98)
  BOTTOM w0.076: v1(165.46,78.98) 166.17,78.98 166.38,78.76 166.38,77.06 U4555.BL2
  BOTTOM w0.119: C4651.2 75.93,28.39 76.21,28.1 v1(76.21,27.36)
PCIE_TX14_DP: length 125.5
  L6 w0.127: v1(75.55,27.36) 75.62,27.36 76.04,27.78 76.31,27.78 76.54,28 80.11,28 81.32,29.21 84.96,29.21 85.36,29.62 86.47,29.62 90.46,33.61 90.46,35.06 100.93,45.53 111.6,45.53 114.89,48.82 114.89,57.96 116.42,59.49 117.11,59.49 118,60.38 118.17,60.38 125.43,67.64 130.95,67.64 135.66,72.34 140.04,72.34 140.04,72.34 140.83,72.34 140.88,72.29 161.47,72.29 162.58,73.4 162.58,73.61 163.5,74.53 163.5,74.99 166.16,77.65 166.16,78.62 166.04,78.75 165.82,78.75 165.46,78.38 v1(165.46,78.37)
  BOTTOM w0.076: U4555.BL1 166.22,77.26 166.22,77.5 166.06,77.66 166.06,77.79 166.21,77.94 166.21,78.04 166.01,78.24 166.01,78.35 166.22,78.55 166.22,78.69 166.1,78.81 165.83,78.81 165.46,78.44 v1(165.46,78.37)
  BOTTOM w0.119: v1(75.55,27.36) 75.55,27.39 75.99,27.83 75.99,28.01 75.83,28.17 75.54,28.17 75.4,28.03 75.19,28.03 75.05,28.17 74.91,28.17 74.59,27.84 C4652.2
PCIE_TX16_C_DN: length 17.5
  BOTTOM w0.119: CN1400.47 210.25,53.32 210.39,53.46 210.39,53.7 209.4,54.68 209.11,54.68 207.3,54.68 205.9,56.08 205.9,56.6 205.48,57.02 204.76,57.02 202.71,59.07 202.71,60.99 204.31,62.6 v4(204.31,63.18) 204.31,64 C4627.1
PCIE_TX16_C_DP: length 17.5
  BOTTOM w0.119: CN1400.49 210.75,53.29 210.61,53.43 210.61,53.79 209.5,54.9 209.02,54.9 207.39,54.9 206.12,56.17 206.12,56.69 205.57,57.24 204.85,57.24 202.93,59.16 202.93,60.9 204.54,62.51 204.54,63.99 C4650.1
PCIE_TX16_DN: length 108.3
  L6 w0.127: v1(217.42,86.3) 217.29,86.17 216.94,86.17 216.81,86.3 216.81,87.7 216.24,88.27 201.18,88.27 198.79,90.65 166.72,90.65 162.43,86.36 162.26,86.36 161.59,85.69 161.59,84.58 161.85,84.32 v2(162.53,84.32)
  BOTTOM w0.076: 162.02,81.93 162.02,81.92 161.99,81.89 161.99,81.67 162.44,81.22 163.04,81.22 165.06,79.2 165.06,77.57 165.23,77.4 165.23,77.06 165.18,76.91 165.18,76.78 165.24,76.62 165.24,76.54 165.23,76.38 165.07,76.02 165.07,75.76 U4555.BJ4
  BOTTOM w0.119: v2(162.53,84.32) 162.02,83.8 162.02,81.93 ; C4627.2 204.32,64.91 204.32,65.27 205.41,66.36 206.03,66.36 207.32,67.65 211.12,67.65 211.67,68.2 214.38,68.2 214.7,68.52 215.4,68.52 217.3,70.42 217.3,71.24 218.01,71.94 218.01,75.42 216.34,77.09 216.34,78.43 215.01,79.75 215.01,81.57 216.56,83.12 216.56,85.86 216.81,86.1 217.23,86.1 v1(217.42,86.3)
PCIE_TX16_DP: length 108.3
  L6 w0.127: v1(217.42,85.69) 217.17,85.94 216.84,85.94 216.58,86.2 216.58,87.6 216.14,88.04 201.08,88.04 198.7,90.43 166.81,90.43 162.52,86.13 162.36,86.13 161.82,85.59 161.82,84.67 161.95,84.55 162.17,84.55 162.53,84.91 v1(162.53,85.05)
  BOTTOM w0.076: U4555.BJ3 164.73,75.79 164.61,75.79 164.53,75.87 164.53,76.07 164.66,76.2 164.95,76.2 164.98,76.23 165.07,76.42 165.07,76.55 165.07,76.59 165.02,76.75 165.02,76.94 165.07,77.09 165.07,77.33 164.9,77.5 164.9,79.13 162.98,81.05 162.38,81.05 161.82,81.6 161.82,81.88 161.79,81.91 161.79,81.93
  BOTTOM w0.119: C4650.2 204.54,64.91 204.54,65.18 205.5,66.14 206.12,66.14 207.41,67.43 211.21,67.43 211.77,67.98 214.48,67.98 214.79,68.3 215.49,68.3 217.52,70.33 217.52,71.14 218.23,71.85 218.23,75.51 216.56,77.18 216.56,78.52 215.23,79.85 215.23,81.47 216.79,83.03 216.79,85.76 216.91,85.88 217.23,85.88 v1(217.42,85.69) ; 161.79,81.93 161.79,83.89 162.12,84.21 162.12,84.49 162.53,84.9 v1(162.53,85.05)
PD_ADP_DIS1: length 35.9
  TOP w0.076: v1(238.23,42.59) U300.H7
  TOP w0.102: R2627.2 257.99,49.44 v1(257.43,49.44) 256.73,49.44 256.44,49.14 Q2607.5
  L3 w0.076: 245.44,46.06 240.42,46.06 239.28,47.2 238.99,47.2 238.78,46.99 238.78,43.9 239.23,43.45 239.23,42.44 239.02,42.23 238.58,42.23 v1(238.23,42.59)
  L3 w0.102: 245.44,46.06 246.56,46.06 247.02,46.52 248.34,46.52 248.39,46.58 249.06,46.58 250.19,45.45 250.19,44.46 v1(251.38,43.27)
  BOTTOM w0.102: v1(251.38,43.27) 251.38,43.42 250.64,44.16 250.64,47.51 252.19,49.06 256.33,49.06 256.71,49.44 v1(257.43,49.44)
PD_ADP_DIS2: length 151.5
  TOP w0.076: v1(236.28,39.99) U300.D10
  TOP w0.102: v1(265.1,98.78) 265.2,98.68 R2615.2 265.11,98.2 264.54,97.63 Q2605.5
  L5 w0.076: 245.44,45.93 242.53,43.03 242.53,42.02 242.53,42.02 242.53,39.89 240.97,38.33 236.78,38.33 236.28,38.84 v1(236.28,39.99)
  L5 w0.102: 245.44,45.93 245.67,46.16 245.67,47.49 245.49,47.66 245.49,51.29 237.58,59.2 233.15,59.2 231.57,60.78 231.57,65.9 231.71,66.04 231.71,72.25 230.35,73.62 230.35,77.82 229.49,78.68 229.49,78.85 229.49,80.65 226.72,83.42 226.72,86.68 226.34,87.06 224.43,87.06 222.78,88.71 222.78,91.44 222.5,91.72 222.5,95.68 223.21,96.39 223.21,97.06 223.21,97.06 223.21,98.07 222.43,98.85 222.43,101.7 219.93,104.21 219.93,105.22 221.36,106.65 221.36,107.59 220.24,108.71 220.24,109.05 220.76,109.56 231.28,109.56 232.46,108.39 232.46,101.05 233.95,99.56 241.78,99.56 242.63,98.71 254.26,98.71 254.73,99.18 264.69,99.18 v1(265.1,98.78)
PLAY_MUTE_LED: length 5.8
  BOTTOM w0.102: v3(47.57,23.26) 47.64,23.18 R409.2 ; R409.2 47.97,22.54 48.56,21.95 48.56,21.61 47.74,20.8 R402.2 47.65,19.81 47.43,19.59 47.25,19.59 Q303.2 ; R409.2 R408.2
PLAY_MUTE_LED_AUDIO: length 48.4
  TOP w0.076: U500.1 19.85,37.29 19.46,36.91 18.86,36.91 18.59,36.64 18.59,36.57
  TOP w0.102: 18.59,36.57 18.59,34.84 v1(18.44,34.69)
  L3 w0.102: v1(48.54,33.47) 48.13,33.87 47.76,33.87 47.31,33.43 36.04,33.43 35.47,34 32.26,34 30.29,35.97 26.53,35.97 25.85,36.65 20.41,36.65 v1(18.44,34.69)
  BOTTOM w0.102: v1(48.54,33.47) 48.54,33.01 v3(48.28,32.76) 48.28,31.52 46.53,29.76 46.53,23.16 R409.1
PLAY_MUTE_LED_CNTR: length 8.8
  BOTTOM w0.102: Q303.6 45.37,19.95 44.93,19.5 v3(44.93,18.05) 45.31,18.05 45.77,18.51 47.99,18.51 48.23,18.27 48.23,17.94 47.26,16.96 R376.1 R365.1
PLAY_MUTE_LED_CNTR_R: length 5.2
  BOTTOM w0.102: CN300.9 43.79,13.3 v3(45.23,14.75) 46.1,15.62 46.47,15.62 46.67,15.82 R365.2
PLAY_MUTE_LED_PCH: length 160.6
  L6 w0.076: v1(175,60.49) 174.99,60.49 173.83,61.65 173.83,62.26 173.6,62.48 168.77,62.48 167.15,64.09 167.15,64.57 166.79,64.94 166.77,64.94 166.77,64.94
  L6 w0.102: 166.77,64.94 166.37,65.34 154.55,65.34 154.49,65.28 151.01,65.28 148.36,62.62 138.93,62.62 138.9,62.65 135.92,62.65 134.65,63.92 128.43,63.92 128.42,63.91 127.56,63.91 122.16,58.52 122.16,57.26 119.1,54.2 119.1,47.65 119.1,47.64 118.88,47.34 118.55,46.9 118.31,46.57 114.48,42.74 102.88,42.74 93.24,33.1 93.24,32.11 84.04,22.91 68.06,22.91 67.81,23.16 67.81,23.16 66.7,24.27 65.08,25.9 64.67,25.9 64.67,25.9 59.52,25.9 58.76,26.66 57.53,26.66 55.75,24.88 53.64,24.88 52.37,26.15 50.75,26.15 v2(46.61,22.01)
  BOTTOM w0.076: U4555.CF27 v1(175,60.49)
  BOTTOM w0.102: R408.1 47.04,22.01 v2(46.61,22.01)
PLT_DET: length 7.4
  TOP w0.076: U300.D2 242.12,39.35 242.58,39.35 242.61,39.37 243.85,39.37
  TOP w0.102: 243.85,39.37 244.09,39.37 244.81,38.65 v3(245.21,38.65) 245.41,38.44 R906.1 245.89,37.38 247.04,37.38 247.58,36.84 R309.1
PLT_ID1: length 9.1
  TOP w0.076: R4460.1 184.18,65.65 R4803.1
  TOP w0.102: R4803.1 183.11,66.11 181.71,67.5 179.91,67.5 v3(179.59,67.18) 179.28,66.87 178.26,66.87 178.16,66.98 177.76,66.98 v1(177.36,66.58)
  BOTTOM w0.076: U4555.CJ17 v1(177.36,66.58)
PLT_ID2: length 2.3
  TOP w0.102: R4804.1 203.83,65.26 203.27,64.7 R4761.1 202.89,64.7 202.29,64.7 R4580.1
PLT_ID2_PCH: length 27.5
  TOP w0.102: v2(201.43,64.23) 201.45,64.21 R4580.2
  L3 w0.076: 180.51,66.23 178.19,66.23 178.16,66.2 177.11,66.2 v1(176.73,66.58)
  L3 w0.102: v2(201.43,64.23) 201.43,64.89 200.94,65.38 196.07,65.38 195.46,65.99 182.25,65.99 182.01,66.23 180.51,66.23
  BOTTOM w0.076: U4555.CH17 v1(176.73,66.58)
PLT_ID3: length 227.6
  TOP w0.076: v1(178,66.58) 178.08,66.66 180.59,66.66 180.62,66.7 181.78,66.7 183.79,64.68 184.45,64.68 R4762.1 185.19,64.99 R4805.1
  L3 w0.102: v1(59.25,27.4) 59.25,27.04 59.25,27.04 57.43,25.21 53.71,25.21 53.71,25.21 52.79,25.21 52.79,25.21 49.41,25.21 48.56,26.06 v1(48.56,27.01) ; v1(5.75,43.05) 5.75,41.51 7.19,40.07 9.44,40.07 12.76,36.76 15.24,36.76 16.88,35.12 16.88,35.06 18.31,33.63 23.97,33.63 24.22,33.88 29.98,33.88 31.11,32.74 42.06,32.74 42.33,33.02 48.7,33.02 v1(49.15,33.47)
  L6 w0.076: v1(178,66.58) 177.62,66.96 175.52,66.96 175.03,67.46 175.03,67.78 175.13,67.88 175.13,68.16 174.91,68.38 173.29,68.38 172.45,67.54 168.43,67.54 168.43,67.54 168.12,67.54 166.89,66.32 166.77,66.32
  L6 w0.102: v1(59.25,27.4) 60.14,26.51 64.41,26.51 65.33,26.51 66.96,24.88 67.16,24.68 68.58,24.68 69.54,23.73 83.7,23.73 92.43,32.45 92.43,33.44 102.55,43.56 114.13,43.56 117.2,46.64 117.2,53.45 121.35,57.59 121.35,58.85 127.82,65.33 134.42,65.33 135.67,64.08 138.38,64.08 139.18,64.88 141.57,64.88 142.14,64.31 148.97,64.31 150.7,66.04 154.17,66.04 154.23,66.1 163.11,66.1 163.77,66.76 164.27,66.76 164.71,66.32 166.77,66.32
  BOTTOM w0.076: U4555.CK17 v1(178,66.58)
  BOTTOM w0.102: v1(49.15,33.47) 49.04,33.36 49.04,29.84 49.65,29.23 49.65,28.1 v1(48.56,27.01) ; CN2500.22 v1(5.75,43.05)
PLT_ID4: length 333.2
  TOP w0.102: 19.83,25.51 19.41,25.09 R3028.2 ; 19.83,25.51 R3027.2 19.38,26.76 19.38,27.86 v3(19.48,27.95) ; 19.83,25.51 20.01,25.34 20.98,25.34 21.1,25.47 21.1,25.47 v1(21.11,25.48)
  L5 w0.102: v1(21.11,25.48) 20.29,24.66 20.29,22.2 19.91,21.81 19.91,21.09 20.29,20.71 21.35,19.65 21.55,19.65 24.89,16.31 26.59,16.31 27.47,15.43 30.07,15.43 30.43,15.79 30.43,16.21 30.66,16.45 31,16.45 31.41,16.04 33.42,16.04 34.18,15.28 40.28,15.28 40.73,14.82 53.13,14.82 55.8,17.49 75.25,17.49 81.67,11.06 88.67,11.06 88.84,11.06 89.2,10.71 125.48,10.71 125.69,10.5 145,10.5 145.1,10.6 145.27,10.6 145.27,10.6 161.11,10.6 161.23,10.48 161.42,10.48 162.64,11.7 168.98,11.7 169.46,12.18 201.34,12.18 202.94,10.58 213.74,10.58 213.81,10.66 214.02,10.86 236.05,10.86 240.26,15.06 240.26,16.65 236.39,20.51 235.68,20.51 233.98,22.21 233.98,22.78 233.76,23.01 233.76,23.2 233.32,23.64 232.2,23.64 230.14,25.69 229.54,25.69 229.26,25.97 219.43,25.97 219.22,25.77 215.19,25.77 197.41,43.55 182.07,43.55 180.23,45.39 180.23,47.69 179.74,48.18 179.64,48.18 174.33,53.49 174.33,53.49 174.09,53.73 174.09,54.67 171.76,57 171.76,58.15 v1(171.34,58.57)
  BOTTOM w0.076: v1(171.34,58.57) 171.73,58.18 U4555.BY31
PLT_RST#: length 103.1
  TOP w0.102: R420.1 229.36,44.88 v1(229.05,44.57) ; R4941.2 195.99,47.03 196.79,46.23 197.93,46.23 198.47,46.77 v1(198.47,46.79) ; Q4754.1 248.06,47.88 247.76,47.59 247.76,47.59 247.52,47.35 247.52,47.34 247.14,46.96 v2(247.14,46.93)
  L3 w0.102: v1(198.47,46.79) 198.82,46.43 201.12,46.43 201.36,46.67 201.36,46.87 201.74,47.25 209.52,47.25 211.41,45.35 216.31,45.35 v1(216.51,45.15) 219.48,42.18 219.48,40.74 219.72,40.5 220.83,40.5 222.13,41.8 226.29,41.8 v1(229.05,44.57) 229.05,45.54 229.05,45.54 230.82,47.3 231.91,47.3 232.13,47.51 233.02,47.51 233.05,47.54 236.28,47.54 236.32,47.58 239.79,47.58 240.03,47.34 242.46,47.34 243.51,46.29 246.5,46.29 v2(247.14,46.93)
  L6 w0.102: v1(206.17,70.01) 206.68,70.01 206.9,69.79 206.9,69.59 206.9,69.42 207.94,68.39 211.7,68.39 214.18,65.91 214.18,62.34 213.28,61.44 213.28,58.29 213.67,57.9 213.67,55.07 214.3,54.44 214.3,53.13 213.97,52.8 213.97,49.66 215.58,48.05 216.1,48.05 216.73,47.41 216.73,45.38 v1(216.51,45.15)
  BOTTOM w0.102: v1(206.17,70.01) 206.27,69.91 R4564.1 206.72,68.87 206.72,68.18 205.93,67.39 204.83,67.39 204.72,67.5 U4700.2
PLT_RST#_KBC: length 13
  TOP w0.076: U300.J5 v1(240.18,43.24)
  TOP w0.102: R420.2 230.23,44.65 230.24,44.65 v2(230.98,44.65)
  BOTTOM w0.076: v1(240.18,43.24) 240.53,43.59 240.53,44.04 239.83,44.74 237.22,44.74 237.14,44.65 235.93,44.65 235.33,44.06 232.64,44.06 232.51,44.19
  BOTTOM w0.102: v2(230.98,44.65) 232.04,44.65 232.51,44.19
PLT_RST#_PCH: length 38.8
  TOP w0.102: v2(172.76,46.79) 172.76,47.36 173.43,48.03 174.16,48.03 176.1,49.97 190.51,49.97 192.8,47.68 194.44,47.68 195.09,47.03 R4941.1
  BOTTOM w0.076: U4555.BJ35 165.36,55.51 165.36,54.59 165.69,53.8 167.23,52.26 168.48,52.26 168.54,52.21 170.45,50.3 171.16,50.3 172.45,49.02 172.45,47.1 v2(172.76,46.79)
PM_EXTTS#0_R: length 2.6
  TOP w0.102: v1(128.3,13.89) 128.3,13.1 R4201.2
  BOTTOM w0.102: v1(128.3,13.89) 128.3,12.45 CN4100.134
PM_EXTTS#1_R: length 2.6
  TOP w0.102: R4200.2 204.07,13.79 v2(204.15,13.88)
  BOTTOM w0.102: CN4125.134 204.08,13.8 v2(204.15,13.88)
PM_PWROK: length 81.2
  TOP w0.076: U300.K4 240.83,43.9 241.28,43.9 241.47,44.08 241.47,44.33 241.67,44.53 241.92,44.53 242.13,44.75 242.13,46.48 242.47,46.81 242.47,47.6 242.46,47.61 R321.1 242.46,49.17 242.05,49.58 242.05,50.1
  TOP w0.102: v1(237.61,54.98) 237.61,54.57 240.36,51.83 240.36,51.76 240.59,51.53 240.81,51.53 v3(241.63,50.71) 241.63,50.62 242.05,50.2 242.05,50.1
  L3 w0.102: v1(183.69,71.08) 184.24,70.54 185.36,70.54 187.07,68.82 202.69,68.82 204.49,70.62 205.32,70.62 205.76,70.18 205.76,68.68 210.44,64.01 215,64.01 215.54,63.46 219.16,63.46 219.37,63.25 219.53,63.25 221.81,60.97 222.79,60.97 224.08,59.68 224.61,59.68 225.13,59.17 225.69,59.17 228.24,56.62 232.49,56.62 233.4,55.71 233.57,55.71 236.18,55.71 236.84,55.05 236.91,54.98 v1(237.61,54.98)
  BOTTOM w0.076: v1(183.69,71.08) 183.33,71.44 180.55,71.44 U4555.CR10
PM_SLP_A#: length 159.4
  TOP w0.102: R4860.1 177.92,43.49 177.92,45.63 177.73,45.83 177.73,46.39 v1(178.1,46.76) 178.27,46.94 178.3,46.94 179.16,47.81 179.16,47.95 179.89,48.67 189.97,48.67 192.26,46.38 193.9,46.38 194.68,45.61 195.58,45.61 196.25,44.93 203.72,44.93 205.18,46.39 209,46.39 209.66,45.73 211.33,45.73 211.66,45.4 211.99,45.4 v2(212.47,44.92) ; v1(214.02,69.05) 214.42,69.46 215.1,69.46 216.82,71.17 232.76,71.17 233.08,71.17 241.32,71.17 241.98,71.83 241.98,73.47 242.2,73.68 242.44,73.93 242.63,73.93 243.99,75.29 243.99,75.81 245.63,77.45 245.94,77.45 246.24,77.45 246.4,77.45 246.5,77.56 v1(246.71,77.56)
  L5 w0.102: v2(212.47,44.92) 213.08,45.53 213.08,46.39 212.82,46.64 212.82,47 212.59,47.23 212.23,47.23 212.04,47.43 212.04,60.87 213.34,62.18 213.34,62.27 214.2,63.12 214.2,63.63 214,63.83 214,69.03 v1(214.02,69.05)
  L6 w0.102: v1(246.71,77.56) 246.24,77.56 245.32,76.64 245.32,74.41 246.07,73.66 246.07,71.06 246.46,70.67 246.46,68.1 246.72,67.83 248.33,67.83 248.87,67.3 249.42,67.3 249.78,66.94 249.78,58.47 251.15,57.1 251.15,56.93 251.15,56.93 251.15,56.88 254.32,53.71 255.25,52.77 255.32,52.71 255.32,52.13 257.12,50.33 v1(258.19,50.33)
  BOTTOM w0.076: U4555.BU37 170.22,54.26 170.27,54.1 170.33,53.55 170.33,53.23 171.27,52.28 171.99,52.28 173.61,50.66 174.37,50.66 175.25,49.79 175.48,49.79 176.39,48.88 178.07,48.88 178.5,48.45 178.5,47.19 v1(178.1,46.76)
  BOTTOM w0.102: CN4941.6 256.62,47.9 256.84,48.12 256.84,48.5 256.94,48.6 257.91,48.6 258.29,48.99 258.29,50.23 v1(258.19,50.33) ; R7415.1 213.66,69.41 v1(214.02,69.05)
PM_SLP_A#_COMPARE: length 6.2
  BOTTOM w0.102: v3(207.54,69.28) 207.75,69.28 D7400.2 209.56,68.28 210.51,69.23 212.7,69.23 R7415.2
PP_DETECT: length 16
  TOP w0.102: v1(24.41,24.96) R3020.2 R3015.2 25.89,24.24 26.42,23.71 26.42,22.9 v3(26.26,22.75) 25.87,22.36 Q3003.G
  BOTTOM w0.102: v1(24.41,24.96) 24.81,24.55 25.26,24.55 25.5,24.79 25.5,26.32 24.28,27.54 24.28,28.73 24.17,28.83 23.17,28.83 22.25,29.75 CN3000.25
PP_DETECT#: length 290.5
  TOP w0.102: v1(33.17,15.43) 33.17,16.32 30.63,18.86 26.82,18.86 26.44,19.24 26.44,20.51 25.74,21.21 Q3003.D ; R433.2 229.98,42.43 229.83,42.58 229.23,42.58 228.66,43.15 227.02,43.15 226.66,42.79 v3(225.62,42.79) 224.66,42.79 v1(224.63,42.76)
  L5 w0.102: v1(224.63,42.76) 225.42,41.98 228.49,41.98 228.72,41.74 228.72,41.27 226.26,38.81 226.26,37.37 225.96,37.06 225.96,36.73 226.26,36.42 226.26,33.8 226.62,33.43 226.62,33.19 226.95,32.86 228.47,32.86 228.75,32.58 228.75,30.84 231.13,28.46 233.48,28.46 239.3,22.64 239.3,22.38 243.2,18.47 243.2,17.29 243.2,13.85 243.02,13.67 243.02,10.85 240.46,8.28 240.46,5.54 240.03,5.1 240.03,4.31 239.67,3.95 237.96,3.95 237.23,4.69 228.15,4.69 227.89,4.95 227.39,4.95 227.13,4.69 221.38,4.69 218.15,7.92 215.58,7.92 214.13,9.36 200.97,9.36 199.6,7.99 184.92,7.99 184.75,7.99 182.33,10.41 170.55,10.41 169.71,9.56 165.6,9.56 164.46,8.42 161.85,8.42 161.22,9.06 151.32,9.06 150.15,7.88 143.52,7.88 142.54,6.9 141.98,6.9 141.94,6.9 141.52,6.9 141.18,6.9 141.1,6.82 138.85,6.82 136.79,8.88 132.14,8.88 131.99,8.73 126.03,8.73 125.06,9.69 99.44,9.69 98.65,8.9 82.97,8.9 78.22,13.65 60.35,13.65 59.59,14.42 41.5,14.42 40.87,13.78 34.74,13.78 33.17,15.36 v1(33.17,15.43)
PP_DETECT#_R: length 6.1
  TOP w0.076: U300.G10 236.28,41.29 235.13,41.29 234.84,41.59 233.27,41.59 232.73,42.13 232.51,42.13
  TOP w0.102: R433.1 231.55,41.93 v3(231.75,42.13) 232.51,42.13
PP_HVA: length 242
  TOP w0.102: v1(23.26,24.96) 23.52,24.7 R3022.2 ; R387.1 224.56,38.8 v1(224.92,39.16) 224.25,39.82 R434.2 223.85,39.75 223.85,39.01 223.57,38.73 v3(223.57,38.52)
  L3 w0.102: v1(23.26,24.96) 23.67,24.55 23.67,18.1 26.62,15.15 26.62,11.85 26.36,11.6 26.36,10.92 27.04,10.24 30.75,10.24 31.57,9.43 47.12,9.43 48.99,11.3 48.99,13.17 50.19,14.37 63.25,14.37 64.52,13.1 85.5,13.1 98.17,25.76 99.29,25.76 99.76,26.23 99.76,26.52 103.5,30.26 v1(103.5,32.63)
  BOTTOM w0.102: v1(23.26,24.96) 21.21,27.01 21.21,27.27 20.22,28.25 CN3000.22 ; v1(224.92,39.16) 224.33,38.57 222.87,38.57 222.37,39.08 220.38,39.08 218.07,36.77 213.27,36.77 212.67,36.16 208.68,36.16 208.37,35.85 189.12,35.85 185.82,32.55 157.98,32.55 156.44,31.01 105.12,31.01 v1(103.5,32.63)
PP_HVA_R: length 21.2
  TOP w0.076: U300.H6 v1(238.88,42.59)
  TOP w0.102: v1(225.07,41.16) 224.23,40.32 R434.1 223.58,40.32 223.51,40.25 222.73,40.25 v3(222.37,39.89)
  BOTTOM w0.076: 232.51,43.49 232.75,43.73 235.47,43.73 236.07,44.32 237.28,44.32 237.36,44.41 238.44,44.41 238.75,44.1 238.75,43.87 239.23,43.39 239.23,42.94 v1(238.88,42.59)
  BOTTOM w0.102: v1(225.07,41.16) 225.07,41.98 226.23,43.12 232.14,43.12 232.51,43.49
PP_SELECT: length 2.7
  TOP w0.102: R3020.1 R3022.1 23.52,22.99 22.76,22.23 U3001.6
PRIVACY_LED#: length 251.3
  TOP w0.076: U300.D4 v1(240.83,39.34)
  L3 w0.076: 240.53,35.32 240.48,35.37 240.48,37.62 241.18,38.31 241.18,38.98 v1(240.83,39.34)
  L3 w0.102: 240.53,35.32 240.74,35.11 240.74,32.74 241.93,31.55 241.93,30.12 241.69,29.88 240.04,29.88 239.3,29.14 239.3,28.36 239.08,28.14 239.08,23.98 241.17,21.89 v1(241.39,21.89)
  L5 w0.102: v1(241.39,21.89) 241.39,20.57 243.43,18.53 243.43,13.79 243.23,13.59 243.23,10.76 240.66,8.2 240.66,5.45 240.23,5.02 240.23,4.22 239.75,3.75 237.88,3.75 237.14,4.48 228.05,4.48 228.05,4.51 227.81,4.74 227.47,4.74 227.24,4.51 227.24,4.48 221.29,4.48 218.07,7.71 215.5,7.71 214.05,9.16 201.05,9.16 199.68,7.79 185,7.79 185,7.79 184.66,7.79 182.25,10.2 173.02,10.2 172.18,9.36 165.69,9.36 164.54,8.22 161.77,8.22 161.13,8.85 151.41,8.85 150.23,7.68 143.61,7.68 142.63,6.69 141.98,6.69 141.94,6.69 141.6,6.69 141.26,6.69 141.19,6.62 138.76,6.62 136.71,8.68 132.22,8.68 132.07,8.52 125.94,8.52 124.98,9.49 99.52,9.49 98.73,8.7 82.88,8.7 78.19,13.4 60.05,13.4 59.67,13.78 46.68,13.78 v2(46.12,13.73)
  BOTTOM w0.102: R388.1 48.72,16.3 48.72,15.41 48.51,15.2 48.51,14.62 47.62,13.73 v2(46.12,13.73)
PRIVACY_LED#_R: length 5.8
  BOTTOM w0.102: CN300.5 45.79,12.86 46.24,13.32 47.49,13.32 48.99,14.82 v3(48.99,15) 49.17,15.18 R388.2
PV_VBUS_CNTR_1: length 44.9
  TOP w0.203: U2403.D1 263.59,25.81 264.03,25.81 264.58,25.26 v1(265.6,25.26) 265.88,25.26 266.16,24.98 267.87,24.98 TP2600.1
  TOP w0.254: C7601.1 268.37,37.71 ; C7600.1 272.16,34.48 ; U2602.C2 U2602.D2 ; C7602.1 269.14,37.73 ; R2619.2 R2602.2 257.48,46.19 256.83,45.55 Q2601.2 256.83,45.06 257.6,44.29 258.34,44.29 258.69,43.94 R2601.2 C2610.2 258.69,40.51 C2609.2 258.77,39.9 260.08,38.59 D2611.1 ; C7603.1 272.92,34.36 ; C7627.1 269.74,37.61
  TOP w0.356: v5(279.88,62.55) 279.9,62.57 CN2900.A4 281.75,62.57 282,62.31 CN2900.B9 283.23,62.31 283.38,62.17 283.38,62.17 v1(283.41,62.14) ; v1(283.48,64.89) 283.38,64.82 CN2900.B4 281.87,64.82 281.62,65.07 CN2900.A9 v5(279.87,65.07)
  L3 w0.254: v5(275.61,37.06) 275.61,36.51 272.08,32.98 271.29,32.98 269.21,30.9 269.21,28.36 268.69,27.84 267.11,27.84 265.6,26.33 v1(265.6,25.26)
  vias: v5(275.89,37.74) v5(276.37,37.06) v5(276.66,37.74) v5(277.14,37.05) v5(277.42,37.74) v5(279.14,65.07)
PV_VBUS_CNTR_2: length 83.3
  TOP w0.203: U2403.L3 262.57,29.84 263.47,30.75 v1(263.47,31.38)
  TOP w0.254: R2635.2 C2602.2 C2608.2 271.92,86.8 ; v1(262.18,93.26) 262,93.26 Q2603.2 262.02,94.87 R2613.2 R2611.2 ; C7607.1 270.06,80.3 ; U2600.C2 U2600.D2
  TOP w0.33: CN2800.A4 280.04,78.21 v5(279.83,77.99)
  TOP w0.356: v5(279.85,80.71) CN2800.A9 281.75,80.71 282,80.46 CN2800.B4 283.74,80.46 v1(283.84,80.53) ; v1(283.4,77.95) CN2800.B9 282,77.95 281.75,78.21 CN2800.A4
  TOP w0.381: C7605.1 270.44,81.07
  L3 w0.254: v5(272.72,82.18) 271.92,81.39 271.92,72.64 271.7,72.42 271.7,71.87 271.7,70.92 271.37,70.59 271.37,55.09 273.38,53.08 273.56,52.9 273.56,42.58 273.74,42.4 273.74,41.12 264,31.38 v1(263.47,31.38)
  L5 w0.254: v1(262.18,93.26) 262.66,93.74 270.97,93.74 v1(271,93.78)
  vias: v5(272.72,85.23) v5(272.72,84.47) v5(272.72,83.71) v5(272.72,82.95) v5(279.11,80.32)
PVADP: length 56.4
  TOP w0.254: 248.89,99.48 247.42,99.48 246.4,98.46 R60045.1 C60034.1 ; v5(231.42,99.51) 232.15,100.24 232.15,109.09 231.85,109.39 231.09,109.39 231.04,109.44 216.3,109.44 215.72,110.02 214.19,110.02 212.33,111.88 212.33,112.6 208.72,116.21 206.05,116.21 205.83,116.43 201.74,116.43 201.26,115.95 v1(201.25,115.95)
  TOP w0.381: 253.4,98.48 R60050.1
  BOTTOM w0.254: C6038.1 234.76,80.61 L6036.1 ; C6037.1 233.65,80.61 L6035.1 ; v1(201.25,115.95) 201.08,116.13 D60099.1 201.84,117.57 203.95,117.57 R68123.1
  vias: v1(236.8,81.73) v1(236.8,80.76) v1(237.56,80.76) v1(237.59,81.73) v3(226.16,97.86) v3(247.09,99.2) v5(231.95,98.97) v5(232.48,98.44) v5(233.02,97.91) v5(236.09,81.55) v5(236.09,80.79) v5(238.3,81.55) v5(238.3,80.79) v5(249.45,99.46) v5(250.19,99.43) v5(250.92,99.43) v5(251.69,99.43) v5(252.45,99.43)
PVADP_DC: length 3.8
  BOTTOM w0.102: C6035.1 232.25,79.8 v3(232.43,79.62)
  BOTTOM w0.254: C6035.1 232.25,81.66 D6035.1 232.86,81.54 C7623.1
PVCORE: length 28
  TOP w0.254: 162.36,71.91 C4550.1 ; 162.75,61.3 C4552.1 ; 161.55,71.7 C4563.1 ; C7532.1 154.55,60.36 ; C4590.1 155.03,76.49 ; v1(163.02,77.42) 163.01,77.41 C4589.1 162.69,76.92 ; C7527.1 135.91,91.37 ; 159.72,71.95 C4565.1 ; 160.58,61.33 C4558.1 ; 134.98,91.04 C7526.1 ; C7531.1 154.4,60.97 ; 162.02,61.49 C4551.1 ; 160.2,75.06 C4562.1 ; C7525.1 127.45,91.04 ; 155.89,71.9 C4559.1 ; C7528.1 136.85,91.04 ; 161.38,76.9 C4564.1 160.93,76.9 160.52,77.32 v1(160.52,77.61) ; 158.61,71.86 C4588.1 ; 160.2,73.01 C4561.1 ; 161.36,62.58 C4555.1 ; 163.68,61.05 C4554.1 ; 125.58,91.04 C7523.1 ; C7524.1 126.51,91.37 ; 161.55,73.31 C4560.1 ; 154.14,75.25 R4593.2 ; C7529.1 155.01,61.58
  BOTTOM w0.127: U4555.AK2 153.3,76.88 153.3,77.72 v1(153.31,77.73) ; v1(148.35,77.81) 148.35,76.87 U4555.AB2 ; v1(150.81,77.8) U4555.AF2
  BOTTOM w0.18: v1(155.67,77.69) U4555.AP2 ; v1(158.14,77.74) U4555.AV2 ; v1(145.81,77.71) 145.81,77.4 145.93,77.28 U4555.V2 ; v1(160.52,77.61) 160.57,77.56 160.58,77.55 U4555.BB2 ; v1(163.02,77.42) U4555.BF2
  BOTTOM w0.254: U4555.BD5 v1(161.37,74.67) U4555.BC5 ; U4555.AR6 v1(156.75,74.03) ; U4555.AU5 v1(157.68,74.67) ; U4555.AU8 v1(157.68,72.76) ; U4555.AR5 v1(156.75,74.67) ; U4555.AW6 v1(159.52,74.03) ; U4555.BC7 v1(161.35,73.41) ; U4555.AW7 v1(159.52,73.4) ; U4555.AW8 v1(159.52,72.76) ; U4555.AR7 v1(156.75,73.4) ; U4555.AV5 v1(158.6,74.67) ; U4555.AU7 v1(157.68,73.4) ; U4555.AW5 v1(159.52,74.67) ; U4555.AJ10 152.85,71.6 v1(153.06,71.4) ; U4555.BC6 v1(161.37,74.03) ; U4555.AU6 v1(157.68,74.03) ; U4555.AV7 v1(158.6,73.4) ; U4555.AR8 v1(156.75,72.76)
  vias: v1(147.51,72.76) v1(147.51,71.4) v1(147.76,70.85) v1(148.35,70.79) v1(148.44,72.76) v1(148.44,71.4) v1(149.37,72.71) v1(149.36,71.4) v1(149.88,70.98) v1(150.28,72.76) v1(150.29,71.4) v1(150.72,70.98) v1(151.21,72.76) v1(151.21,71.4) v1(152.13,74.03) v1(152.13,73.4) v1(152.13,72.76) v1(152.13,71.4) v1(152.54,70.8) v1(153.06,72.76) v1(153.15,70.81) v1(153.92,72.8) v1(154.9,72.76) v1(154.9,71.4) v1(154.95,63.06) v1(155.48,67.38) v1(155.49,66.49) v1(155.7,70.81) v1(155.84,71.39) v1(155.86,63.06) v1(155.86,60.49) v1(156.27,70.91) v1(156.31,62.41) v1(156.75,71.4) v1(156.71,67.38) v1(156.71,66.49) v1(156.75,62.99) v1(156.77,60.49) v1(157.23,62.41) v1(157.41,62.99) v1(157.68,71.4) v1(157.68,60.49) v1(158.14,70.91) v1(158.6,71.4) v1(158.59,63.06) v1(158.59,60.49) v1(158.9,70.83) v1(159.05,62.41) v1(159.38,71.21) v1(159.57,62.92) v1(159.96,62.41) v1(160.42,60.49) v1(160.6,71.21) v1(161.2,70.81) v1(161.37,71.4) v1(161.33,60.49) v1(161.78,62.41) v1(161.81,70.8) v1(162.24,62.9) v1(162.24,60.49) v1(162.29,71.4) v1(162.67,62.43) v1(163.15,60.49) v1(163.22,71.4) v5(125.88,91.63) v5(126.64,92.39) v5(126.9,91.63) v5(127.4,92.39) v5(127.91,94.68) v5(127.91,93.16) v5(127.91,91.63) v5(128.42,93.92) v5(128.42,92.39) v5(128.93,94.68) v5(128.93,93.16) v5(128.93,91.63) v5(129.44,93.92) v5(129.44,92.39) v5(129.94,94.68) v5(129.94,93.16) v5(129.94,91.63) v5(130.45,93.92) v5(130.45,92.39) v5(130.73,95.16) v5(131.29,94.4) v5(132,95.16) v5(132.31,94.4) v5(133.32,94.4) v5(134.34,94.4) v5(135.28,94.68) v5(135.28,93.16) v5(135.28,91.63) v5(135.79,93.92) v5(135.79,92.39) v5(136.29,94.68) v5(136.29,93.16) v5(136.29,91.63) v5(136.8,93.92) v5(136.8,92.39) v5(137.31,94.68) v5(138.58,94.68) v5(139.09,94.15) v5(139.6,94.68) v5(140.1,94.15) v5(140.61,94.68) v5(140.84,93.16) v5(141.25,93.92) v5(141.63,94.68) v5(141.75,93.16) v5(142.26,93.92) v5(142.26,92.39) v5(142.26,91.63) v5(142.64,94.68) v5(143.66,94.68) v5(144.29,94.17) v5(144.93,94.68) v5(145.44,94.15) v5(145.95,94.68) v5(147.27,94.88) v5(147.27,94.12) v5(147.27,93.23) v5(147.27,92.34) v5(148.1,94.91) v5(148.1,94.15) v5(148.1,93.38) v5(148.1,92.62) v5(154.84,79.31) v5(155.34,80.84) v5(155.34,80.08) v5(158.14,80.08) v5(158.14,79.31) v5(158.14,78.55) v5(158.9,80.08) v5(158.9,79.31)
PVCORE_PG: length 212.4
  TOP w0.102: R4511.1 197.95,47.26 198.66,47.26 199.69,46.23 203.18,46.23 204.64,47.69 212.17,47.69 v2(214.37,49.9)
  TOP w0.254: R66002.2 v1(99.08,93.38) 99.28,93.38 99.97,94.07 U66000.30
  L5 w0.102: v1(216.53,106.77) 216.07,106.31 216.07,100.42 216.33,100.17 216.33,98.69 217.59,97.42 217.59,87.31 217.83,87.08 217.83,83.89 215.67,81.73 215.67,70.4 215.67,70.4 215.67,70.06 216.46,69.27 216.46,66.49 217.42,65.53 217.42,62.87 214.37,59.82 v2(214.37,49.9)
  L6 w0.102: v1(99.08,93.38) 99.08,93.08 99.64,92.52 103.55,92.52 105.23,90.84 108.91,90.84 110.77,92.7 121.33,92.7 125.37,96.74 127.26,96.74 128.03,97.5 155.42,97.5 161.11,103.19 165.94,103.19 166.73,102.4 169.68,102.4 172.53,105.25 181.68,105.25 184.82,102.11 187.84,102.11 188.11,102.38 193.29,102.38 194.18,103.27 197.86,103.27 199.49,104.89 200.79,104.89 202.6,106.69 204.5,106.69 205.63,106.69 206.71,105.62 215.38,105.62 v1(216.53,106.77)
