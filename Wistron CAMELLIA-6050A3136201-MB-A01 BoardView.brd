# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ<47>: length 59.5
  L6 w0.089: 166.09,44.17 164.89,45.37 164.76,45.37 164.55,45.58 164.55,48.02 v1(164.94,48.38)
  L6 w0.097: 166.09,44.17 166.11,44.14 166.11,40.49 174.82,31.79 180.29,31.79 189.08,22.99 189.08,21.73 188.98,21.63 188.52,21.63 188.4,21.52 188.4,21.36 188.52,21.25 188.82,21.25 188.93,21.14 188.93,20.98 188.82,20.86 188.52,20.86 188.4,20.75 188.4,20.59 188.52,20.48 188.82,20.48 188.93,20.36 188.93,20.2 188.82,20.09 188.52,20.09 188.4,19.98 188.4,19.82 188.52,19.7 188.82,19.7 188.93,19.59 188.93,19.43 188.82,19.32 188.79,19.32 188.69,19.22 188.69,16.96 v2(187.72,15.98)
  BOTTOM w0.076: U4555.BG37 163.73,54.45 163.73,53.65 164.34,53.04 164.34,48.98 v1(164.94,48.38)
  BOTTOM w0.13: CN4125.70 188.08,15.62 v2(187.72,15.98)
M_B_DQ<48>: length 96.6
  L3 w0.097: v2(225.07,17.47) 224.95,17.6 224.89,18.03 224.89,19.16 225.28,21.04 225.3,21.06 225.3,22.25 225.4,22.35 225.64,22.35 225.73,22.45 225.73,22.64 225.64,22.74 225.4,22.74 225.3,22.83 225.3,24.88 209.33,40.85 169.11,40.85 165.1,44.86 164.65,44.86 162.76,46.75 162.76,52.55 162.56,52.74 162.56,54.16 162,54.72 161.5,54.72 160.09,56.12 160.09,56.42 159.5,57.01 v1(159.5,57.31)
  BOTTOM w0.076: U4555.BA32 v1(159.5,57.31)
  BOTTOM w0.13: v2(225.07,17.47) 225.48,17.47 226.08,18.07 226.08,18.53 226.33,18.78 CN4125.215
M_B_DQ<49>: length 97.5
  L3 w0.076: 159.78,56.11 159.78,56.37 159.13,57.02 159.13,57.58 v1(159.5,57.95)
  L3 w0.097: 159.78,56.11 159.78,56.08 161.39,54.47 161.95,54.47 162.33,54.09 162.33,52.71 162.46,52.58 162.46,46.62 164.51,44.56 164.97,44.56 168.99,40.55 207.85,40.55 208.19,40.39 212.56,37.2 225,24.75 225,21.18 224.99,21.11 224.99,21.11 224.59,19.19 224.59,18.01 224.88,15.91 v2(225.28,14.42)
  BOTTOM w0.076: U4555.BA31 v1(159.5,57.95)
  BOTTOM w0.13: v2(225.28,14.42) 225.58,13.75 CN4125.212
M_B_DQ<50>: length 99.2
  L3 w0.076: 162.3,56.97 v1(161.33,57.95)
  L3 w0.097: 162.3,56.97 162.39,56.97 165.25,54.12 165.25,52.79 166.29,51.75 166.89,51.15 166.89,46.05 169.99,42.96 210.21,42.96 228.53,24.63 228.53,23.83 228.64,23.71 229,23.71 229.12,23.6 229.12,23.44 229,23.33 228.64,23.33 228.53,23.22 228.53,23.06 228.64,22.94 229,22.94 229.12,22.83 229.12,22.67 229,22.56 228.64,22.56 228.53,22.44 228.53,22.28 228.64,22.17 229,22.17 229.12,22.06 229.12,21.9 229,21.78 228.64,21.78 228.53,21.67 228.53,21.51 228.64,21.4 229,21.4 229.12,21.29 229.12,21.13 229,21.01 228.64,21.01 228.53,20.9 228.53,20.74 228.64,20.63 229,20.63 229.12,20.51 229.12,20.35 229,20.24 228.64,20.24 228.5,20.09 228.5,18.74 v2(228.91,18.33)
  BOTTOM w0.076: U4555.BD31 v1(161.33,57.95)
  BOTTOM w0.13: v2(228.91,18.33) 229.4,18.83 229.4,19.17 228.83,19.74 CN4125.225
M_B_DQ<51>: length 99
  L3 w0.076: 162.27,56.67 162.08,56.86 161.78,56.86 v1(161.33,57.31)
  L3 w0.097: v2(228.96,17.01) 228.84,17.01 228.09,16.26 227.89,16.26 227.61,16.55 227.61,16.89 228.16,17.45 228.16,24.58 210.09,42.66 169.86,42.66 166.59,45.94 166.59,51.03 166.17,51.45 164.95,52.67 164.95,53.99 162.27,56.67
  BOTTOM w0.076: U4555.BD32 v1(161.33,57.31)
  BOTTOM w0.13: CN4125.229 229.83,19.61 230.01,19.42 230.01,18.06 v2(228.96,17.01)
M_B_DQ<52>: length 98.2
  L3 w0.076: v1(159.5,58.58) 159.87,58.21 159.87,57 160.43,56.45
  L3 w0.097: v2(225.37,18.89) 225.37,18.76 225.52,18.61 225.92,18.61 226.07,18.76 226.07,19.23 225.97,19.32 225.56,19.32 225.47,19.42 225.47,19.61 225.56,19.71 225.97,19.71 226.07,19.81 226.07,20 225.97,20.1 225.56,20.1 225.47,20.19 225.47,20.39 225.56,20.48 225.97,20.48 226.07,20.58 226.07,20.77 225.97,20.87 225.7,20.87 225.61,20.96 225.61,21.15 225.7,21.25 225.97,21.25 226.07,21.35 226.07,21.54 225.97,21.64 225.75,21.64 225.64,21.75 225.64,21.94 225.74,22.04 225.97,22.04 226.07,22.13 226.07,24.53 209.46,41.14 169.23,41.14 166.51,43.87 165.22,45.16 164.77,45.16 163.06,46.87 163.06,52.71 162.78,52.98 162.78,54.21 162.05,54.94 161.63,54.94 160.43,56.15 160.43,56.45
  BOTTOM w0.076: U4555.BA30 v1(159.5,58.58)
  BOTTOM w0.13: CN4125.211 225.33,18.94 v2(225.37,18.89)
M_B_DQ<53>: length 99.2
  L3 w0.076: 160.7,56.45 160.04,57.12 160.04,58.68 v1(159.5,59.22)
  L3 w0.097: 160.7,56.45 160.7,56.16 161.66,55.2 162.1,55.2 163.08,54.22 163.08,53.79 163.85,53.02 163.85,52.05 165.37,50.53 165.37,49.49 165.37,45.43 166.63,44.16 169.36,41.44 209.58,41.44 226.37,24.65 226.37,18.55 225.91,18.09 v2(225.91,15.91)
  BOTTOM w0.076: U4555.BA29 v1(159.5,59.22)
  BOTTOM w0.13: CN4125.216 226.58,14.65 v2(225.91,15.91)
M_B_DQ<54>: length 100.3
  L3 w0.097: v1(161.33,59.22) 162.27,58.49 162.7,58.07 162.7,57.22 163.02,56.9 163.18,56.9 164.27,55.81 164.4,55.81 165.84,54.37 165.84,53.04 166.54,52.34 167.49,51.4 167.49,46.89 170.83,43.55 210.45,43.55 229.79,24.21 229.79,15.64 229.92,15.52 229.92,14.82 229.25,14.16 228.64,14.16 v2(228.58,14.22)
  BOTTOM w0.076: U4555.BD29 v1(161.33,59.22)
  BOTTOM w0.13: CN4125.224 v2(228.58,14.22)
M_B_DQ<55>: length 99.6
  L3 w0.076: v1(161.33,58.58) 161.86,58.05 161.86,57.73 162.3,57.28
  L3 w0.097: v2(229.5,15.17) 229.37,15.3 228.98,15.3 228.88,15.41 228.88,15.83 228.98,15.94 229.26,15.94 229.48,16.15 229.48,24.11 210.33,43.25 170.11,43.25 167.19,46.18 167.19,51.28 167.18,51.28 166.41,52.05 166.41,52.05 165.55,52.92 165.55,54.24 163.08,56.71 162.94,56.71 162.37,57.28 162.3,57.28
  BOTTOM w0.076: U4555.BD30 v1(161.33,58.58)
  BOTTOM w0.13: v2(229.5,15.17) 229.58,15.09 CN4125.228
M_B_DQ<56>: length 98.3
  L6 w0.097: v2(231.13,15.81) 230.08,16.87 230.08,19.17 228.5,20.74 217.66,20.74 217.5,20.58 217.5,20.53 217.4,20.43 217.21,20.43 217.11,20.53 217.11,20.58 217.01,20.68 216.82,20.68 216.72,20.58 216.72,20.53 216.63,20.43 216.43,20.43 216.34,20.53 216.34,20.58 216.24,20.68 216.05,20.68 215.95,20.58 215.95,20.53 215.86,20.43 200.02,20.43 197.83,22.63 197.83,22.69 185.82,34.7 176.02,34.7 169.04,41.68 169.04,46.59 167.44,48.18 167.44,49.91 163.98,53.37 163.98,55.05 162.76,56.27 162.76,57.56 v1(163.15,57.95)
  BOTTOM w0.076: U4555.BG31 v1(163.15,57.95)
  BOTTOM w0.13: CN4125.236 231.58,14.04 231.68,14.15 231.68,15.26 v2(231.13,15.81)
M_B_DQ<57>: length 98.1
  L6 w0.097: v1(163.16,57.31) 163.15,56.31 165.05,54.41 165.05,52.74 167.79,49.99 167.79,48.26 169.08,46.96 169.08,46.96 169.33,46.71 169.33,41.8 176.14,35 186.45,35 198.29,23.15 200.59,23.15 202.7,21.04 208.85,21.04 208.96,20.93 208.96,20.85 209.08,20.73 209.24,20.73 209.35,20.84 209.35,20.93 209.46,21.04 209.62,21.04 209.73,20.93 209.73,20.85 209.85,20.73 210.01,20.73 210.12,20.84 210.12,20.93 210.23,21.04 210.39,21.04 210.51,20.93 210.51,20.88 210.62,20.77 210.78,20.77 210.89,20.88 210.89,20.93 211.01,21.04 211.17,21.04 211.28,20.93 211.28,20.88 211.39,20.77 211.55,20.77 211.66,20.88 211.66,20.93 211.78,21.04 211.94,21.04 212.05,20.93 212.05,20.88 212.16,20.77 212.32,20.77 212.44,20.88 212.44,20.93 212.55,21.04 212.71,21.04 212.82,20.93 212.82,20.88 212.94,20.77 213.1,20.77 213.21,20.88 213.21,20.93 213.32,21.04 213.48,21.04 213.59,20.93 213.59,20.88 213.71,20.77 213.87,20.77 213.98,20.88 213.98,20.93 214.09,21.04 214.25,21.04 214.37,20.93 214.37,20.88 214.48,20.77 214.64,20.77 214.75,20.88 214.75,20.93 214.87,21.04 215.03,21.04 215.14,20.93 215.14,20.88 215.25,20.77 215.41,20.77 215.53,20.88 215.53,20.93 215.64,21.04 228.75,21.04 230.47,19.32 230.47,17.78 v2(231.1,17.15)
  BOTTOM w0.076: U4555.BG32 v1(163.16,57.31)
  BOTTOM w0.13: v2(231.1,17.15) 231.83,17.88 CN4125.237
M_B_DQ<58>: length 98
  L6 w0.076: 165.57,56.68 165.57,56.71 v1(164.98,57.31)
  L6 w0.097: 165.57,56.68 165.57,55.62 166.36,54.83 166.36,53.48 169.36,50.47 169.36,48.84 170.85,47.36 170.85,42.43 176.54,36.74 176.75,36.53 187.08,36.53 187.09,36.52 198.94,24.67 201.26,24.67 201.93,24.01 212.56,24.01 212.64,23.92 224.05,23.92 224.6,23.37 227.25,23.37 228.03,22.59 229.41,22.59 230.47,21.53 230.49,21.53 233.54,18.49 233.54,15.94 234.26,15.22 234.26,14.54 234.36,14.45 v2(235.25,14.45)
  BOTTOM w0.076: U4555.BK32 v1(164.98,57.31)
  BOTTOM w0.13: CN4125.250 235.08,13.44 234.94,13.58 234.94,14.13 v2(235.25,14.45)
M_B_DQ<59>: length 98.7
  L6 w0.076: 165.75,56.68 165.75,57.07 165.14,57.69 165.14,57.78 v1(164.97,57.95)
  L6 w0.097: 165.75,56.68 165.75,56.1 167.35,54.5 167.35,52.91 169.29,50.97 169.29,50.97 169.66,50.6 169.66,48.97 171.15,47.48 171.15,43.38 177.69,36.83 187.2,36.83 199.07,24.97 201.38,24.97 202.05,24.3 212.68,24.3 212.77,24.22 224.17,24.22 224.72,23.67 227.37,23.67 228.15,22.89 230.39,22.89 230.94,22.34 230.94,21.51 233.85,18.6 233.85,16.55 234.61,15.79 v2(235.24,15.79)
  BOTTOM w0.076: U4555.BK31 v1(164.97,57.95)
  BOTTOM w0.13: CN4125.246 234.08,14.63 v2(235.24,15.79)
M_B_DQ<60>: length 99.2
  L6 w0.097: v1(163.15,59.22) 163.56,58.81 163.56,56.25 165.35,54.46 165.35,52.94 168.1,50.2 168.1,48.37 169.16,47.31 169.16,47.31 169.38,47.09 169.38,47.08 169.63,46.83 169.63,41.93 176.26,35.3 186.57,35.3 198.41,23.45 200.76,23.45 202.84,21.37 209.85,21.37 209.97,21.48 209.97,21.56 210.08,21.67 210.24,21.67 210.35,21.56 210.35,21.48 210.46,21.37 210.62,21.37 210.74,21.48 210.74,21.56 210.85,21.67 211.01,21.67 211.12,21.56 211.12,21.48 211.24,21.37 211.4,21.37 211.51,21.48 211.51,21.56 211.62,21.67 211.78,21.67 211.9,21.56 211.9,21.48 212.01,21.37 212.17,21.37 212.28,21.48 212.28,21.56 212.39,21.67 212.55,21.67 212.67,21.56 212.67,21.48 212.78,21.37 212.94,21.37 213.05,21.48 213.05,21.56 213.17,21.67 213.33,21.67 213.44,21.56 213.44,21.48 213.55,21.37 213.71,21.37 213.83,21.48 213.83,21.56 213.94,21.67 214.1,21.67 214.21,21.56 214.21,21.48 214.32,21.37 214.48,21.37 214.6,21.48 214.6,21.56 214.71,21.67 214.87,21.67 214.98,21.56 214.98,21.48 215.1,21.37 215.26,21.37 215.37,21.48 215.37,21.56 215.48,21.67 215.64,21.67 215.76,21.56 215.76,21.48 215.87,21.37 216.03,21.37 216.14,21.48 216.14,21.56 216.26,21.67 216.42,21.67 216.53,21.56 216.53,21.48 216.64,21.37 216.8,21.37 216.91,21.48 216.91,21.56 217.03,21.67 217.19,21.67 217.3,21.56 217.3,21.48 217.41,21.37 217.57,21.37 217.69,21.48 217.69,21.56 217.8,21.67 217.96,21.67 218.07,21.56 218.07,21.48 218.19,21.37 218.35,21.37 218.46,21.48 218.46,21.56 218.57,21.67 218.73,21.67 218.84,21.56 218.84,21.48 218.96,21.37 219.12,21.37 219.23,21.48 219.23,21.56 219.34,21.67 219.5,21.67 219.62,21.56 219.62,21.48 219.73,21.37 219.89,21.37 220,21.48 220,21.56 220.12,21.67 220.28,21.67 220.39,21.56 220.39,21.48 220.5,21.37 220.66,21.37 220.78,21.48 220.78,21.56 220.89,21.67 221.05,21.67 221.16,21.56 221.16,21.48 221.27,21.37 221.43,21.37 221.55,21.48 221.55,21.56 221.66,21.67 221.82,21.67 221.93,21.56 221.93,21.48 222.05,21.37 228.87,21.37 231,19.25 v2(231,18.79)
  BOTTOM w0.076: U4555.BG29 v1(163.15,59.22)
  BOTTOM w0.13: CN4125.233 230.83,18.96 v2(231,18.79)
M_B_DQ<61>: length 98.8
  L6 w0.097: v2(231.12,14.46) 231.12,14.54 229.78,15.88 229.78,19.04 228.69,20.13 219.82,20.13 219.72,20.23 219.72,20.24 219.62,20.34 219.43,20.34 219.33,20.24 219.33,20.23 219.24,20.13 219.05,20.13 218.95,20.23 218.95,20.24 218.85,20.34 218.66,20.34 218.56,20.24 218.56,20.23 218.47,20.13 218.27,20.13 218.18,20.23 218.18,20.24 218.08,20.34 217.89,20.34 217.79,20.24 217.79,20.23 217.69,20.13 199.9,20.13 197.53,22.51 197.53,22.57 185.7,34.4 175.9,34.4 168.74,41.56 168.74,46.46 167.13,48.07 167.13,49.87 163.7,53.3 163.7,55 162.52,56.18 162.52,57.62 162.71,57.81 162.71,58.14 v1(163.15,58.58)
  BOTTOM w0.076: U4555.BG30 v1(163.15,58.58)
  BOTTOM w0.13: CN4125.232 230.58,13.92 v2(231.12,14.46)
M_B_DQ<62>: length 99.7
  L6 w0.076: v1(164.97,58.58) 165.35,58.21 165.35,57.72 165.76,57.3 165.76,57.3 165.96,57.1 165.96,56.68
  L6 w0.097: v2(235.34,17.37) 235.34,17.1 235.02,16.79 234.32,16.79 234.14,16.96 234.14,17.19 234.24,17.29 234.38,17.29 234.48,17.38 234.48,17.58 234.38,17.67 234.24,17.67 234.14,17.77 234.14,18.72 231.23,21.63 231.23,22.52 230.57,23.18 228.27,23.18 227.5,23.96 224.85,23.96 224.29,24.52 212.89,24.52 212.8,24.6 202.17,24.6 201.51,25.27 199.23,25.27 187.34,37.16 177.79,37.16 171.44,43.5 171.44,47.6 169.96,49.09 169.96,50.72 169.58,51.09 169.58,51.1 168.91,51.77 168.91,51.78 167.55,53.13 167.55,54.58 165.96,56.17 165.96,56.68
  BOTTOM w0.076: U4555.BK30 v1(164.97,58.58)
  BOTTOM w0.13: CN4125.245 233.83,18.88 v2(235.34,17.37)
M_B_DQ<63>: length 100.3
  L6 w0.076: 166.15,56.68 166.15,57.15 165.51,57.79 165.51,58.68 v1(164.97,59.22)
  L6 w0.097: v2(235.29,18.69) 234.6,18.69 234.24,19.05 234.24,19.19 234.51,19.46 234.51,19.6 234.38,19.74 234.24,19.74 233.96,19.46 233.83,19.46 233.69,19.6 233.69,19.73 233.97,20.01 233.97,20.15 233.83,20.28 233.69,20.28 233.42,20.01 233.28,20.01 233.15,20.14 233.15,20.28 233.42,20.55 233.42,20.69 233.29,20.83 233.15,20.83 232.87,20.55 232.74,20.55 232.6,20.69 232.6,20.83 232.88,21.1 232.88,21.24 232.74,21.37 232.6,21.37 232.33,21.1 232.19,21.1 232.05,21.23 232.05,21.37 232.33,21.65 232.33,21.78 232.19,21.92 232.06,21.92 231.78,21.64 231.64,21.64 231.53,21.76 231.53,22.65 230.7,23.48 228.4,23.48 227.62,24.26 224.97,24.26 224.42,24.81 213.01,24.81 212.93,24.9 202.29,24.9 201.63,25.56 199.36,25.56 187.46,37.46 177.91,37.46 171.74,43.63 171.74,47.73 170.25,49.21 170.25,50.84 169.88,51.21 169.88,51.22 169.2,51.9 169.2,51.9 168.98,52.12 168.98,52.12 167.76,53.35 167.76,54.81 166.15,56.42 166.15,56.68
  BOTTOM w0.076: U4555.BK29 v1(164.97,59.22)
  BOTTOM w0.13: v2(235.29,18.69) 234.83,19.15 CN4125.249
M_B_DQS0_DN: length 55.7
  L6 w0.089: 155.91,45.37 155.91,45.39 155.9,45.41 155.9,46.27 156.26,46.63 156.26,47.51 155.99,47.77 155.89,47.77 155.61,48.06 v2(155.61,48.14)
  L6 w0.109: 155.91,45.37 155.91,30.26 165.38,20.8 170.45,20.8 172.39,18.86 172.39,17.49 172.67,17.21 172.86,17.21 172.98,17.33 172.98,17.64 v1(172.96,17.65)
  BOTTOM w0.076: U4555.AP35 155.66,55.62 155.62,55.71 155.5,55.76 155.4,55.71 155.36,55.59 155.36,55.42 155.4,55.3 155.4,55.07 155.36,54.95 155.36,54.77 155.42,54.59 155.42,53.5 155.22,53.3 155.22,50.6 155.05,50.43 155.05,49.9 155.08,49.87 155.08,49.85
  BOTTOM w0.119: v1(172.96,17.65) 172.88,17.56 172.88,17.37 173.03,17.22 173.3,17.22 173.58,17.49 173.58,19.49 173.34,19.73 173.34,20.81 CN4125.11 ; v2(155.61,48.14) 155.61,48.05 155.43,47.87 155.26,47.87 155.08,48.06 155.08,49.85
M_B_DQS0_DP: length 55.7
  L6 w0.089: 155.7,45.37 155.7,45.39 155.72,45.41 155.72,46.34 156.08,46.7 156.08,47.43 155.92,47.6 155.7,47.6 155.61,47.52 v1(155.61,47.47)
  L6 w0.109: v2(172.97,16.81) 172.77,17 172.58,17 172.18,17.4 172.18,18.78 170.37,20.59 165.29,20.59 155.7,30.17 155.7,45.37
  BOTTOM w0.076: 154.86,49.85 154.86,49.87 154.89,49.9 154.89,50.5 155.06,50.67 155.06,53.37 155.26,53.57 155.26,54.56 155.19,54.74 155.19,54.98 155.23,55.09 155.23,55.27 155.19,55.39 155.19,55.62 155.26,55.83 155.43,55.9 155.43,55.91 155.48,55.93 155.62,56.07 U4555.AP34
  BOTTOM w0.119: CN4125.13 173.8,20.8 173.8,17.4 173.39,17 173.16,17 v2(172.97,16.81) ; v1(155.61,47.47) 155.61,47.5 155.47,47.65 155.17,47.65 154.86,47.96 154.86,49.85
M_B_DQS1_DN: length 56.6
  L6 w0.089: 158.88,45.92 158.88,45.95 158.86,45.96 158.86,46.62 159.13,46.89 159.13,48.59 158.91,48.81 158.67,48.81 158.57,48.91 v1(158.57,49.04)
  L6 w0.109: 158.88,45.92 158.88,45 159.78,44.1 159.78,37.94 172.24,25.48 174.12,25.48 174.89,24.71 174.89,24.32 175.39,23.81 175.79,23.81 177.67,21.93 177.67,17.77 179.06,16.38 179.06,15.29 178.82,15.06 178.32,15.06 178.17,14.9 v1(178.17,14.83)
  BOTTOM w0.076: v1(158.57,49.04) 158.38,48.85 158.26,48.85 158.18,48.94 158.18,52.35 158.41,52.58 158.44,52.58 158.7,52.84 158.7,53.37 158.51,53.56 158.51,54.57 158.56,54.74 158.56,54.98 158.55,55.02 158.55,55.04 158.52,55.09 158.52,55.28 158.55,55.35 158.56,55.37 158.56,55.37 158.57,55.4 158.57,55.64 158.56,55.65 158.5,55.8 158.39,55.92 158.21,55.92 158.14,55.99 U4555.AV34
  BOTTOM w0.119: v1(178.17,14.83) 178.37,15.03 178.52,15.03 178.7,14.85 178.7,13.66 178.58,13.53 CN4125.32
M_B_DQS1_DP: length 56.6
  L6 w0.089: 158.67,45.92 158.67,45.95 158.68,45.96 158.68,46.69 158.96,46.97 158.96,48.52 158.84,48.64 158.63,48.64 158.54,48.54 v2(158.54,48.36)
  L6 w0.109: v1(178.17,15.54) 178.44,15.27 178.74,15.27 178.84,15.38 178.84,16.29 177.46,17.68 177.46,21.85 175.7,23.6 175.3,23.6 174.68,24.23 174.68,24.62 174.03,25.27 172.15,25.27 159.57,37.85 159.57,44.02 158.67,44.92 158.67,45.92
  BOTTOM w0.076: v2(158.54,48.36) 158.54,48.56 158.4,48.69 158.2,48.69 158.02,48.87 158.02,52.42 158.34,52.75 158.37,52.75 158.53,52.91 158.53,53.3 158.34,53.49 158.34,54.59 158.4,54.77 158.4,54.95 158.36,55.06 158.36,55.31 158.4,55.43 158.4,55.59 158.36,55.71 158.32,55.75 158.21,55.75 158.14,55.67 U4555.AV35
  BOTTOM w0.119: CN4125.34 179.08,13.57 178.92,13.73 178.92,14.94 178.61,15.25 178.45,15.25 v1(178.17,15.54)
M_B_DQS2_DN: length 97.8
  L3 w0.076: v2(153.12,57.96) 153.12,58.03 153.28,58.19 153.39,58.19 153.5,58.08 153.5,56.14 153.49,56.13 153.49,56.11
  L3 w0.089: 156.05,53.3 156.04,53.31 156.02,53.31 153.49,55.84 153.49,56.11
  L3 w0.109: 156.05,53.3 156.05,46.75 156.07,46.73 156.07,46.7 156.56,46.2 156.56,43.71 161.31,38.97 162.33,38.97 162.64,38.97 166.77,34.84 204.31,34.84 207.78,31.37 209.63,31.37 216.22,24.78 216.22,17.92 216.9,17.24 217.18,17.24 217.33,17.1 v1(217.33,16.71)
  BOTTOM w0.076: U4555.AL31 v2(153.12,57.96)
  BOTTOM w0.119: CN4125.177 216.83,19.69 216.97,19.54 216.97,19.35 216.5,18.89 216.5,17.46 216.9,17.06 217.2,17.06 217.33,16.94 v1(217.33,16.71)
M_B_DQS2_DP: length 97.8
  L3 w0.076: 153.67,56.11 153.67,56.13 153.66,56.14 153.66,58.15 153.46,58.35 153.21,58.35 153.12,58.44 v1(153.12,58.62)
  L3 w0.089: 156.26,53.32 156.26,53.37 156.14,53.49 156.09,53.49 153.67,55.91 153.67,56.11
  L3 w0.109: v1(217.3,18.01) 217.3,17.59 217.16,17.45 216.98,17.45 216.43,18 216.43,24.87 209.72,31.58 207.87,31.58 204.4,35.05 166.86,35.05 162.73,39.18 162.41,39.18 162.41,39.18 161.4,39.18 156.78,43.8 156.78,46.03 156.78,46.29 156.28,46.78 156.28,46.81 156.26,46.84 156.26,53.32
  BOTTOM w0.076: U4555.AL30 v1(153.12,58.62)
  BOTTOM w0.119: CN4125.179 217.33,19.66 217.19,19.53 217.19,19.26 216.72,18.79 216.72,17.55 216.99,17.28 217.17,17.28 217.3,17.41 v1(217.3,18.01)
M_B_DQS3_DN: length 99.6
  L3 w0.076: 157.68,56.11 157.68,56.13 157.69,56.14 157.69,56.37 157.15,56.89 157.15,58.1 157.07,58.18 156.89,58.18 156.77,58.06 v1(156.77,57.95)
  L3 w0.089: 159.85,53.34 159.85,53.36 159.86,53.38 159.86,54.03 159.57,54.32 159.11,54.32 157.68,55.75 157.68,56.11
  L3 w0.109: 159.85,53.34 159.85,52.9 159.63,52.69 159.63,48.74 159.89,48.48 159.89,45.34 162.76,42.47 163.78,42.47 163.78,42.47 164.09,42.47 168.12,38.44 206.61,38.44 210.05,35.01 211.27,35.01 213.6,32.67 214,32.67 221.86,24.81 221.86,15.99 222.28,15.57 222.28,15.31 222.17,15.2 v2(221.68,15.2)
  BOTTOM w0.076: U4555.AU31 v1(156.77,57.95)
  BOTTOM w0.119: CN4125.198 222.08,13.53 222.2,13.65 222.2,15.08 222.08,15.2 v2(221.68,15.2)
M_B_DQS3_DP: length 99.7
  L3 w0.076: 157.86,56.11 157.86,56.13 157.85,56.14 157.85,56.44 157.31,56.96 157.31,58.17 157.14,58.35 156.88,58.35 156.77,58.46 v1(156.77,58.58)
  L3 w0.089: 160.06,53.34 160.06,53.36 160.04,53.38 160.04,54.1 159.64,54.5 159.18,54.5 157.86,55.83 157.86,56.11
  L3 w0.109: 160.06,53.34 160.06,52.82 159.84,52.6 159.84,48.82 160.1,48.56 160.1,45.43 162.85,42.68 163.86,42.68 163.86,42.68 164.18,42.68 168.2,38.65 206.7,38.65 210.14,35.22 211.35,35.22 213.68,32.89 214.08,32.89 222.07,24.9 222.07,16.08 222.49,15.66 222.49,15.31 222.6,15.2 v2(222.95,15.2)
  BOTTOM w0.076: U4555.AU30 v1(156.77,58.58)
  BOTTOM w0.119: CN4125.200 222.58,13.53 222.42,13.68 222.42,15.08 222.54,15.2 v2(222.95,15.2)
M_B_DQS4_DN: length 57.5
  L6 w0.089: v1(161.9,49.35) 161.9,49.5 161.76,49.64 161.6,49.64 161.51,49.55 161.51,45.71 161.61,45.6 161.74,45.6 162.26,45.08 162.28,45.08 162.3,45.07
  L6 w0.109: v2(183.91,17.96) 183.91,17.68 183.8,17.57 183.55,17.57 183.27,17.85 183.27,18.7 184.15,19.58 184.15,22.54 177.71,28.99 173.68,28.99 163.29,39.37 163.29,39.79 163.29,44.07 163.17,44.2 162.3,45.07
  BOTTOM w0.076: 161.08,51.68 161.08,51.7 161.11,51.73 161.11,53.24 160.88,53.47 160.88,54.65 160.92,54.77 160.92,54.95 160.88,55.06 160.88,55.31 160.92,55.43 160.92,55.59 160.88,55.71 160.83,55.75 160.73,55.75 160.65,55.67 U4555.BB35
  BOTTOM w0.119: 161.08,51.68 161.08,50 161.43,49.65 161.72,49.65 161.9,49.47 v1(161.9,49.35) ; v2(183.91,17.96) 183.91,17.7 184.03,17.58 184.34,17.58 184.64,17.88 184.64,18.54 184.1,19.07 184.1,19.5 183.83,19.78 CN4125.53
M_B_DQS4_DP: length 57.5
  L6 w0.089: v2(161.9,50.01) 161.71,49.82 161.52,49.82 161.33,49.63 161.33,45.63 161.54,45.42 161.67,45.42 162.13,44.96 162.13,44.94 162.15,44.92
  L6 w0.109: 162.15,44.92 163.02,44.05 163.08,43.99 163.08,39.88 163.08,39.88 163.08,39.29 173.59,28.78 177.62,28.78 183.94,22.46 183.94,19.67 183.06,18.79 183.06,17.76 183.46,17.36 183.76,17.36 v1(183.96,17.16)
  BOTTOM w0.076: 161.3,51.68 161.3,51.7 161.27,51.73 161.27,53.31 161.04,53.54 161.04,54.62 161.08,54.74 161.08,54.98 161.04,55.09 161.04,55.28 161.07,55.35 161.08,55.37 161.09,55.4 161.09,55.64 161.08,55.65 161.02,55.8 160.66,56.16 U4555.BB34
  BOTTOM w0.119: CN4125.55 184.33,19.17 184.86,18.63 184.86,17.79 184.43,17.36 184.14,17.36 184.09,17.31 v1(183.96,17.16) ; 161.3,51.68 161.3,50.09 161.52,49.87 161.76,49.87 v2(161.9,50.01)
M_B_DQS5_DN: length 60.5
  L6 w0.109: v2(164.94,47.1) 165.19,46.85 165.44,46.85 166.84,45.45 166.84,40.78 175.11,32.5 180.61,32.5 189.8,23.32 189.8,17.52 189.52,17.25 189.52,16.81 189.8,16.53 189.8,14.8 189.56,14.57 189.28,14.57 v1(189.04,14.34)
  BOTTOM w0.076: U4555.BF34 163.17,55.99 163.25,55.92 163.42,55.92 163.54,55.8 163.59,55.65 163.6,55.64 163.6,55.4 163.56,55.28 163.56,55.09 163.6,54.98 163.6,54.74 163.56,54.62 163.56,53.54 164.06,53.04 164.06,48.47 164.08,48.44 164.08,48.43
  BOTTOM w0.119: v1(189.04,14.34) 189.2,14.49 189.48,14.49 189.6,14.37 189.6,14.03 189.23,13.66 189.23,13.54 189.09,13.4 189.09,12.37 CN4125.74 ; 164.08,48.43 164.08,47.25 164.45,46.88 164.72,46.88 v2(164.94,47.1)
M_B_DQS5_DP: length 60.6
  L6 w0.109: v2(189.04,15.09) 189.04,14.99 189.25,14.78 189.48,14.78 189.59,14.89 189.59,16.44 189.31,16.72 189.31,17.33 189.59,17.61 189.59,23.23 180.52,32.29 175.03,32.29 166.63,40.69 166.63,45.36 165.35,46.63 165.14,46.63 v1(164.94,46.44)
  BOTTOM w0.076: 163.86,48.43 163.86,48.44 163.89,48.47 163.89,52.98 163.39,53.47 163.39,54.65 163.43,54.77 163.43,54.95 163.39,55.06 163.39,55.31 163.44,55.43 163.44,55.59 163.4,55.71 163.35,55.75 163.25,55.75 163.17,55.67 U4555.BF35
  BOTTOM w0.119: v1(164.94,46.44) 164.72,46.66 164.36,46.66 163.86,47.16 163.86,48.43 ; CN4125.76 189.59,12.37 189.59,13.22 189.46,13.35 189.46,13.58 189.82,13.94 189.82,14.46 189.57,14.71 189.24,14.71 189.04,14.92 v2(189.04,15.09)
M_B_DQS6_DN: length 98.9
  L3 w0.076: 161.31,56.41 161.31,56.43 161.33,56.45 161.33,56.55 160.79,57.08 160.79,58.09 160.7,58.18 160.53,58.18 160.42,58.06 v2(160.42,57.96)
  L3 w0.109: v1(226.84,18.04) 226.73,17.93 226.73,17.66 226.84,17.55 227.07,17.55 227.4,17.87 227.4,20.34 227.1,20.64 227.1,21.43 227.4,21.73 227.4,24.34 209.79,41.94 169.57,41.94 166.84,44.67 166.84,44.67 165.87,45.64 165.87,50.74 164.24,52.37 164.24,52.63 164.24,53.29 163.76,53.76 163.76,54.19 162.33,55.63 161.82,55.63 161.31,56.15 161.31,56.41
  BOTTOM w0.076: v2(160.42,57.96) 160.43,57.95 U4555.BC31
  BOTTOM w0.119: CN4125.219 227.34,20.83 227.34,19.79 227.57,19.56 227.57,17.74 227.38,17.55 226.85,17.55 226.73,17.67 226.73,17.93 v1(226.84,18.04)
M_B_DQS6_DP: length 98.9
  L3 w0.076: v1(160.42,58.62) 160.42,58.47 160.54,58.35 160.76,58.35 160.96,58.15 160.96,57.15 161.49,56.61 161.49,56.45 161.52,56.43 161.52,56.41
  L3 w0.109: v2(226.83,17.09) 226.91,17.09 227.61,17.79 227.61,20.43 227.31,20.73 227.31,21.35 227.61,21.64 227.61,24.42 209.88,42.16 169.65,42.16 166.93,44.88 166.08,45.73 166.08,50.83 164.45,52.46 164.45,53.38 163.98,53.85 163.98,54.28 162.42,55.84 161.91,55.84 161.52,56.23 161.52,56.41
  BOTTOM w0.076: U4555.BC30 v1(160.42,58.62)
  BOTTOM w0.119: CN4125.221 227.84,20.83 227.84,19.73 227.79,19.68 227.79,17.65 227.47,17.33 227.07,17.33 v2(226.83,17.09)
M_B_DQS7_DN: length 98.6
  L6 w0.076: 164.41,57.08 164.41,57.09 164.43,57.12 164.43,58.08 164.33,58.18 164.14,58.18 164.06,58.1 v1(164.06,57.95)
  L6 w0.109: 164.41,57.08 164.41,56.79 164.86,56.33 164.86,55.53 165.79,54.61 165.79,53.02 168.65,50.17 168.65,48.55 169.49,47.7 169.49,47.69 169.66,47.52 169.66,47.52 169.89,47.29 169.89,47.29 170.13,47.04 170.13,42.14 176.46,35.81 186.79,35.81 198.64,23.96 200.97,23.96 201.63,23.29 212.26,23.29 212.35,23.21 223.75,23.21 224.3,22.65 226.95,22.65 227.73,21.87 229.11,21.87 232.77,18.22 232.77,15.31 232.51,15.05 v2(232.24,15.05)
  BOTTOM w0.076: U4555.BH31 v1(164.06,57.95)
  BOTTOM w0.119: CN4125.240 232.59,12.37 232.59,13.47 232.75,13.63 232.75,14.67 232.37,15.05 v2(232.24,15.05)
M_B_DQS7_DP: length 98.6
  L6 w0.076: v1(164.06,58.58) 164.06,58.45 164.16,58.35 164.4,58.35 164.6,58.15 164.6,57.12 164.62,57.09 164.62,57.08
  L6 w0.109: 164.62,57.08 164.62,56.88 165.08,56.42 165.08,55.62 166,54.69 166,53.11 168.86,50.25 168.86,48.63 169.7,47.79 169.7,47.78 169.88,47.61 169.88,47.6 170.1,47.38 170.1,47.38 170.35,47.13 170.35,42.22 176.55,36.02 186.88,36.02 198.73,24.17 201.05,24.17 201.72,23.5 212.35,23.5 212.43,23.42 223.84,23.42 224.39,22.86 227.04,22.86 227.82,22.09 229.2,22.09 232.98,18.31 232.98,15.59 v2(233.51,15.05)
  BOTTOM w0.076: U4555.BH30 v1(164.06,58.58)
  BOTTOM w0.119: v2(233.51,15.05) 232.97,14.51 232.97,13.59 233.08,13.49 CN4125.242
M_B_PAR: length 90.4
  L3 w0.089: v1(149.81,52.18) 150.72,51.28 150.72,43.36
  L3 w0.117: 150.72,43.36 150.03,42.67 150.03,40.9 158.56,32.37 158.57,32.37 158.57,32.36 159.9,32.36 164.03,28.23 201.43,28.23 206.65,23.01 206.65,19.85 206.52,19.71 206.47,19.71 206.34,19.57 206.34,19.38 206.47,19.24 206.52,19.24 206.65,19.1 206.65,18.91 206.52,18.77 206.47,18.77 206.34,18.64 206.34,18.44 206.47,18.31 206.52,18.31 206.65,18.17 206.65,17.76 206.54,17.65 v2(206.2,17.64)
  BOTTOM w0.076: v1(149.81,52.18) 149.51,52.49 149.51,53.59 149.71,53.79 149.71,54.1 149.51,54.31 149.51,54.69 149.64,54.94 149.64,55.96 149.77,56.09 149.77,56.32 U4555.AE34
  BOTTOM w0.16: v2(206.2,17.64) 206.41,17.85 206.41,20.74 CN4125.143
M_CKE0: length 58.7
  L6 w0.117: v1(141.45,47.22) 141.58,47.09 141.58,46.31 139.57,44.31 139.57,42.67 120.28,23.38 120.28,22.15 120.17,22.03 119.87,22.03 119.76,21.92 119.76,21.68 119.87,21.57 120.17,21.57 120.28,21.45 120.28,21.22 120.17,21.1 119.87,21.1 119.76,20.98 119.76,20.75 119.87,20.63 120.17,20.63 120.28,20.52 120.28,20.28 120.17,20.17 119.87,20.17 119.76,20.05 119.76,19.81 119.87,19.7 120.17,19.7 120.28,19.58 120.28,18.63 119.76,18.11 119.76,16.06 119.89,15.93 120.24,15.93 120.35,16.05 120.35,16.77 120.83,17.24 v1(121.06,17.24)
  BOTTOM w0.076: v1(141.45,47.22) 141.82,47.22 142.75,48.15 v3(142.75,48.62) 142.75,50.6 144.33,52.18 144.33,53.22 144.83,53.73 144.83,54.18 144.64,54.38 144.64,54.65 144.9,55.13 U4555.U36
  BOTTOM w0.16: v1(121.06,17.24) 121.06,18.79 122.13,19.85 CN4100.109
M_CKE1: length 58.4
  L6 w0.117: v1(140.78,46.11) 140.78,46.07 139.19,44.48 139.19,42.83 119.36,23 119.36,14.78 119.8,14.33 121.19,14.33 121.39,14.52 121.39,14.82 121.06,15.14 v1(121.06,15.77)
  BOTTOM w0.076: v1(140.78,46.11) 141.36,46.11 143.32,48.08 v3(143.32,50.2) 143.32,50.94 144.49,52.11 144.49,53.16 145,53.66 145,53.67 145.01,53.68 145.01,54.42 U4555.U37
  BOTTOM w0.16: CN4100.110 122.38,14.35 121.06,15.66 v1(121.06,15.77)
M_CKE2: length 90.5
  L3 w0.076: 143.65,56.21 144.47,57.22 144.47,59.37 v1(144.01,59.88)
  L3 w0.117: v1(196.52,17.4) 194.81,17.4 191.46,19.64 160.98,19.64 156.27,24.35 155.25,24.35 142.01,37.59 142.01,46.75 142.45,47.55 142.45,51.52 143.65,52.72 143.65,56.21
  BOTTOM w0.076: v1(144.01,59.88) U4555.T28
  BOTTOM w0.16: CN4125.109 197.83,19.34 196.52,18.04 v1(196.52,17.4)
M_CKE3: length 90.7
  L3 w0.076: v2(144.01,59.22) 143.47,58.68 143.47,56.69 143.44,56.66
  L3 w0.117: v1(196.52,15.8) 191.34,19.26 160.82,19.26 156.11,23.97 155.09,23.97 141.63,37.43 141.63,46.62 142.19,47.56 142.24,47.79 142.24,51.66 143.44,52.86 143.44,56.66
  BOTTOM w0.076: v2(144.01,59.22) U4555.T29
  BOTTOM w0.16: v1(196.52,15.8) 196.52,15.55 198.08,14 CN4125.110
M_CLK_DDR0_DN: length 57
  L6 w0.076: 145.28,56.88 145.28,56.89 145.3,56.91 145.3,57.5 145.22,57.58 145.08,57.58 144.92,57.42 v1(144.92,57.29)
  L6 w0.109: 145.28,56.88 145.28,54.62 147.34,52.56 147.34,51.74 147.59,51.49 148.2,51.49 148.32,51.36 148.32,51.18 148.2,51.06 147.59,51.06 147.34,50.8 147.34,50.46 148.26,49.53 148.26,39.07 130.87,21.67 130.87,20.56 130.74,20.43 130.33,20.43 130.08,20.18 130.08,19.82 130.33,19.57 130.74,19.57 130.97,19.34 130.97,18.18 130.77,17.98 130.27,17.98 130.12,18.13 v2(130.12,18.42)
  BOTTOM w0.076: U4555.V32 145.34,57.57 145,57.57 144.92,57.49 v1(144.92,57.29)
  BOTTOM w0.119: v2(130.12,18.42) 130.16,18.39 130.16,18.13 130,17.98 129.7,17.98 129.35,18.33 129.35,19.49 129.63,19.77 CN4100.139
M_CLK_DDR0_DP: length 57
  L6 w0.076: v2(144.92,57.96) 145.14,57.74 145.29,57.74 145.47,57.56 145.47,56.91 145.49,56.89 145.49,56.88
  L6 w0.109: 145.49,56.88 145.49,54.71 147.55,52.64 147.55,51.83 147.68,51.7 148.28,51.7 148.54,51.45 148.54,51.1 148.28,50.84 147.68,50.84 147.55,50.72 147.55,50.54 148.47,49.62 148.47,38.98 131.08,21.59 131.08,20.47 130.83,20.22 130.42,20.22 130.29,20.09 130.29,19.91 130.42,19.78 130.83,19.78 131.18,19.43 131.18,18.09 130.86,17.77 130.31,17.77 v1(130.12,17.59)
  BOTTOM w0.076: v2(144.92,57.96) 144.95,57.97 144.97,57.97 U4555.V31
  BOTTOM w0.119: v1(130.12,17.59) 129.95,17.76 129.61,17.76 129.12,18.24 CN4100.137
M_CLK_DDR1_DN: length 56.3
  L6 w0.076: v1(144.01,57.31) 144.01,57.31 144.27,57.58 144.39,57.46 144.39,56.98 144.37,56.96 144.37,56.94
  L6 w0.109: 144.37,56.94 144.37,56.77 144.69,56.45 144.69,54.42 145.95,53.16 146.86,49.95 147.69,49.13 147.69,43.93 147.43,43.67 147.43,39.4 129.26,21.23 129.26,16.21 129.66,15.81 129.75,15.81 v1(130.13,15.43)
  BOTTOM w0.076: U4555.T32 v1(144.01,57.31)
  BOTTOM w0.119: v1(130.13,15.43) 130.13,15.54 130,15.67 129.71,15.67 129.6,15.55 129.6,13.87 129.88,13.59 CN4100.140
M_CLK_DDR1_DP: length 56.3
  L6 w0.076: 144.58,56.94 144.55,56.96 144.55,57.53 144.29,57.8 144.16,57.8 v1(144.01,57.95)
  L6 w0.109: 144.58,56.94 144.58,56.86 144.9,56.53 144.9,54.51 146.14,53.27 147.05,50.06 147.9,49.21 147.9,43.84 147.64,43.58 147.64,39.31 129.47,21.14 129.47,16.3 129.74,16.02 129.97,16.02 v2(130.13,16.18)
  BOTTOM w0.076: U4555.T31 v1(144.01,57.95)
  BOTTOM w0.119: v2(130.13,16.18) 129.84,15.89 129.62,15.89 129.38,15.65 CN4100.138
M_CLK_DDR2_DN: length 97.5
  L3 w0.076: v1(150.39,59.85) 150.59,59.66 150.74,59.66 150.93,59.47 150.93,56.96 150.95,56.94 150.95,56.92
  L3 w0.109: 150.95,56.92 150.95,54.35 149.37,52.77 149.37,51.87 150.41,50.83 150.41,43.88 149.42,42.89 149.42,40.64 158.31,31.75 159.33,31.75 163.46,27.62 164.29,27.62 201.15,27.62 205.22,23.55 205.22,23.22 204.9,22.9 204.9,22.72 205.03,22.6 205.21,22.6 205.46,22.34 205.46,21.99 205.21,21.74 205.03,21.74 204.9,21.61 204.9,21.43 205.03,21.3 205.42,21.3 205.65,21.07 205.65,20.67 205.42,20.44 205.03,20.44 204.9,20.31 204.9,20.13 205.03,20.01 205.44,20.01 205.69,19.76 205.69,18.23 205.46,17.99 204.97,17.99 204.86,17.88 v2(204.86,17.62)
  BOTTOM w0.076: U4555.AF28 v1(150.39,59.85)
  BOTTOM w0.119: CN4125.139 205.33,19.67 205.74,19.25 205.74,18.35 205.41,18.03 204.98,18.03 204.86,17.91 v2(204.86,17.62)
M_CLK_DDR2_DP: length 97.3
  L3 w0.076: v1(150.39,59.22) 150.39,59.4 150.48,59.49 150.67,59.49 150.77,59.4 150.77,56.96 150.74,56.94 150.74,56.92
  L3 w0.109: 150.74,56.92 150.74,54.44 149.16,52.86 149.16,51.78 150.2,50.74 150.2,43.96 149.21,42.97 149.21,40.56 158.23,31.54 159.25,31.54 163.37,27.41 164.38,27.41 201.06,27.41 205.01,23.47 205.01,23.31 204.69,22.99 204.69,22.64 204.94,22.39 205.12,22.39 205.25,22.26 205.25,22.08 205.12,21.95 204.94,21.95 204.69,21.7 204.69,21.34 204.94,21.09 205.33,21.09 205.44,20.98 205.44,20.76 205.33,20.65 204.94,20.65 204.69,20.4 204.69,20.05 204.94,19.79 205.36,19.79 205.48,19.67 205.48,18.31 205.37,18.2 205,18.2 204.86,18.34 v2(204.86,18.9)
  BOTTOM w0.076: v1(150.39,59.22) 150.65,59.48 U4555.AF29
  BOTTOM w0.119: v2(204.86,18.9) 204.86,18.37 204.99,18.25 205.32,18.25 205.52,18.45 205.52,19.16 205.1,19.58 205.1,19.58 204.94,19.74 204.94,20.72 CN4125.137
M_CLK_DDR3_DN: length 97.1
  L3 w0.076: v1(149.48,59.85) 149.48,59.71 149.57,59.62 149.79,59.62 150.02,59.39 150.02,57.05 150.04,57.03 150.04,57.01
  L3 w0.109: 150.04,57.01 150.04,56.15 150.03,56.11 149.95,56.01 148.75,53.75 148.75,51.71 149.89,50.57 149.89,46.11 149.65,44.89 149.64,44.89 149.55,44.76 149.51,44.66 148.6,42.46 148.6,40.3 157.97,30.93 158.99,30.93 163.12,26.8 164.63,26.8 200.69,26.8 204.08,23.41 204.08,15.98 204.19,15.86 204.57,15.86 204.69,15.98 v2(204.69,16.35)
  BOTTOM w0.076: v1(149.48,59.85) U4555.AE28
  BOTTOM w0.119: v2(204.69,16.35) 204.69,15.95 204.81,15.83 205.31,15.83 205.58,15.56 CN4125.140
M_CLK_DDR3_DP: length 97
  L3 w0.076: 149.83,57.01 149.83,57.03 149.85,57.05 149.85,59.33 149.73,59.45 149.59,59.45 149.48,59.35 v1(149.48,59.22)
  L3 w0.109: 149.83,57.01 149.83,56.2 149.77,56.11 148.54,53.8 148.54,51.62 149.68,50.48 149.68,46.13 149.46,45.03 149.46,45.01 149.36,44.86 149.31,44.73 149.28,44.66 148.39,42.51 148.39,40.22 157.89,30.72 158.91,30.72 163.03,26.59 164.72,26.59 200.6,26.59 203.87,23.32 203.87,15.89 204.11,15.65 204.55,15.65 204.72,15.48 204.72,15.11 v2(204.69,15.08)
  BOTTOM w0.076: v1(149.48,59.22) U4555.AE29
  BOTTOM w0.119: CN4125.138 205.08,13.43 205.35,13.71 205.35,15.47 205.22,15.61 204.81,15.61 204.69,15.49 v2(204.69,15.08)
M_CS#0: length 60.2
  L6 w0.089: v1(149.48,57.31) 149.48,57.18 152.46,54.19 152.46,46.67
  L6 w0.117: 152.46,46.67 152.46,43.77 152.43,43.74 152.43,35.04 140.84,23.45 140.68,23.45 140.36,23.77 140.2,23.77 140.03,23.6 140.03,23.44 140.35,23.12 140.35,22.95 140.18,22.79 140.02,22.79 139.7,23.1 139.54,23.1 139.37,22.94 139.37,22.77 139.69,22.46 139.69,22.29 139.52,22.13 139.36,22.13 139.04,22.44 138.87,22.44 138.71,22.28 138.71,22.11 139.02,21.8 139.02,21.63 138.86,21.47 138.69,21.47 138.38,21.78 138.21,21.78 138.05,21.62 138.05,21.45 138.36,21.14 138.36,20.97 138.2,20.8 138.03,20.8 137.72,21.12 137.55,21.12 137.39,20.96 137.39,20.79 137.7,20.47 137.7,20.31 137.54,20.14 137.37,20.14 137.06,20.46 136.89,20.46 136.72,20.29 136.72,20.13 137.04,19.81 137.04,19.65 136.85,19.46 135.84,19.46 135.33,18.94 135.33,18.63 135.33,17.43 135.21,17.31 v2(134.86,17.31)
  BOTTOM w0.076: v1(149.48,57.31) U4555.AE32
  BOTTOM w0.16: v2(134.86,17.31) 134.13,18.07 CN4100.149
M_CS#1: length 60.1
  L6 w0.089: 153.56,44.58 153.56,52.63 153.75,52.83 153.75,53.5 150.39,56.86 v1(150.39,57.31)
  L6 w0.117: v2(136.25,18.66) 136.25,18.59 136.7,18.14 136.97,18.14 137.14,18.32 137.14,18.62 137.32,18.8 137.62,18.8 137.8,18.98 137.8,19.29 137.98,19.46 138.29,19.46 138.46,19.64 138.46,19.95 138.64,20.12 138.95,20.12 139.12,20.3 139.12,20.61 139.3,20.79 139.61,20.79 139.79,20.96 139.79,21.27 139.96,21.45 140.27,21.45 140.89,22.06 140.89,22.41 146.29,27.81 146.45,27.81 146.67,27.59 146.83,27.59 147,27.76 147,27.92 146.78,28.14 146.78,28.3 146.95,28.47 147.12,28.47 147.33,28.26 147.5,28.26 147.66,28.42 147.66,28.59 147.45,28.8 147.45,28.97 147.61,29.13 147.78,29.13 147.99,28.92 148.16,28.92 148.32,29.08 148.32,29.25 148.11,29.46 148.11,29.63 148.27,29.79 148.44,29.79 148.65,29.58 148.82,29.58 148.98,29.74 148.98,29.91 148.77,30.12 148.77,30.29 148.93,30.45 149.1,30.45 149.31,30.24 149.48,30.24 149.65,30.41 149.65,30.57 149.43,30.79 149.43,30.95 149.6,31.12 149.76,31.12 149.98,30.9 150.14,30.9 150.31,31.07 150.31,31.23 150.09,31.45 150.09,31.61 150.26,31.78 150.42,31.78 150.64,31.56 150.8,31.56 150.97,31.73 150.97,31.89 150.75,32.11 150.75,32.27 150.92,32.44 151.08,32.44 151.3,32.22 151.46,32.22 151.63,32.39 151.63,32.55 151.41,32.77 151.41,32.93 151.58,33.1 151.75,33.1 151.96,32.89 152.13,32.89 152.29,33.05 152.29,33.22 152.08,33.43 152.08,33.6 152.24,33.76 152.41,33.76 152.62,33.55 152.79,33.55 152.95,33.71 152.95,33.88 152.74,34.09 152.74,34.26 153.2,34.72 153.2,44.22 153.56,44.58
  BOTTOM w0.076: U4555.AF32 v1(150.39,57.31)
  BOTTOM w0.16: v2(136.25,18.66) 136.13,18.78 CN4100.157
M_CS#2: length 93.4
  L3 w0.089: 152.36,43.3 152.42,43.36 152.42,43.38 152.43,43.39 152.43,49.63 152.06,50 152.06,51.04 152.18,51.16 152.31,51.16 152.82,50.65 v1(152.85,50.65)
  L3 w0.117: 152.36,43.3 152.36,41.83 152.53,41.66 159.53,34.66 160.54,34.66 160.86,34.66 164.99,30.53 202.39,30.53 209.54,23.39 209.86,23.39 209.97,23.27 209.97,22.95 209.86,22.83 209.52,22.83 209.38,22.69 209.38,22.48 209.5,22.36 209.86,22.36 209.97,22.25 209.97,22 209.86,21.88 209.08,21.88 208.96,21.76 208.96,21.55 209.1,21.41 209.86,21.41 209.97,21.3 209.97,21.06 209.86,20.94 209.58,20.94 209.47,20.83 209.47,20.59 209.58,20.48 209.86,20.48 209.97,20.36 209.97,18.23 210.12,18.08 210.12,17.89 209.99,17.76 209.99,17.6 210.11,17.48 v2(210.39,17.48)
  BOTTOM w0.076: U4555.AL37 153.64,54.42 153.64,53.66 153.89,53.41 153.89,52.95 153.4,52.45 153.4,51.2 v1(152.85,50.65)
  BOTTOM w0.16: v2(210.39,17.48) 209.83,18.04 CN4125.149
M_CS#3: length 95
  L3 w0.089: v1(152.85,48.75) 152.85,48.69 153.49,48.05 153.49,45.1 153.39,45
  L3 w0.117: 153.39,45 153.39,42.43 160,35.81 161.02,35.81 161.02,35.81 161.34,35.81 165.46,31.68 202.87,31.68 206.46,28.09 207.59,28.09 211.23,24.44 211.23,16.13 211.42,15.94 212.17,15.94 212.31,16.08 212.31,16.95 212.2,17.06 v2(211.78,17.06)
  BOTTOM w0.076: U4555.AL35 154.08,55.24 154.08,54.87 154.18,54.69 154.18,54.31 153.97,54.1 153.97,53.8 154.27,53.5 154.27,52.86 153.75,52.33 153.75,49.77 v1(152.85,48.75)
  BOTTOM w0.16: v2(211.78,17.06) 212.2,17.48 212.2,19.16 211.83,19.53 CN4125.157
M_ODT0: length 60.3
  L6 w0.089: v1(149.48,57.95) 149.93,57.49 149.93,56.97 153.56,53.35 153.56,52.99 153.36,52.79 153.36,44.87
  L6 w0.117: v2(136.25,16.02) 136.71,15.56 136.71,15.06 136.53,14.88 135.83,14.88 135.71,15 135.71,18.79 136,19.08 137.01,19.08 152.81,34.88 152.81,44.32 153.36,44.87
  BOTTOM w0.076: U4555.AE31 v1(149.48,57.95)
  BOTTOM w0.16: CN4100.155 135.63,18.74 135.78,17.25 136.04,16.45 v2(136.25,16.02)
M_ODT1: length 60
  L6 w0.089: v1(150.39,57.95) 150.68,57.95 153.61,55.02 153.61,54.2 154,53.81 154,52.72 153.78,52.5 153.78,44.29 153.58,44.09
  L6 w0.117: v2(136.25,17.3) 136.29,17.35 136.74,17.35 140.33,20.94 140.76,20.94 141.63,21.81 141.63,21.81 142.14,22.32 142.14,22.49 141.93,22.7 141.93,22.86 142.1,23.03 142.26,23.03 142.47,22.82 142.64,22.82 142.8,22.98 142.8,23.15 142.59,23.36 142.59,23.52 142.76,23.69 142.92,23.69 143.13,23.48 143.3,23.48 143.47,23.64 143.47,23.81 143.26,24.02 143.26,24.18 143.42,24.35 143.59,24.35 143.8,24.14 143.96,24.14 144.13,24.31 144.13,24.47 143.92,24.68 143.92,24.85 144.08,25.01 144.25,25.01 144.46,24.8 144.62,24.8 144.79,24.97 144.79,25.13 144.58,25.34 144.58,25.51 144.74,25.67 144.91,25.67 145.12,25.46 145.28,25.46 145.45,25.63 145.45,25.79 145.24,26 145.24,26.17 145.41,26.33 145.57,26.33 145.78,26.12 145.95,26.12 146.11,26.29 146.11,26.45 145.9,26.66 145.9,26.83 146.07,26.99 146.23,26.99 146.44,26.79 146.61,26.79 153.58,33.76 153.58,44.09
  BOTTOM w0.076: U4555.AF31 v1(150.39,57.95)
  BOTTOM w0.16: v2(136.25,17.3) 136.6,17.65 137.13,18.89 CN4100.161
M_ODT2: length 95.5
  L3 w0.089: v1(152.85,50) 153.08,50 153.24,49.85 153.24,48.74 153.76,48.22 153.76,44.95 153.77,44.94
  L3 w0.117: 153.77,44.94 153.77,42.59 160.16,36.2 161.18,36.2 161.18,36.2 161.49,36.2 165.62,32.07 203.02,32.07 206.62,28.47 207.74,28.47 211.35,24.86 212.03,24.86 212.14,24.74 212.14,24.51 212.03,24.39 211.73,24.39 211.62,24.28 211.62,24.04 211.73,23.93 212.03,23.93 212.14,23.81 212.14,23.58 212.03,23.46 211.73,23.46 211.62,23.34 211.62,22 211.74,21.87 212.26,21.87 212.37,21.76 212.37,21.52 212.26,21.41 211.74,21.41 211.63,21.29 211.63,21.06 211.74,20.94 212.37,20.94 212.52,20.79 212.52,20.59 212.41,20.47 211.74,20.47 211.63,20.36 211.63,20.12 211.74,20 212.33,20 212.46,19.88 212.46,19.65 212.34,19.54 211.74,19.54 211.62,19.41 211.62,19.15 211.7,19.06 212.22,19.06 212.39,18.89 212.39,18.35 212.24,18.21 211.87,18.21 211.76,18.32 v2(211.76,18.58)
  BOTTOM w0.076: v1(152.85,50) 153.56,50.72 153.56,52.38 154.11,52.93 154.11,53.43 153.8,53.73 153.8,54.17 154.02,54.38 154.02,54.65 153.92,54.83 153.92,55.02 U4555.AL36
  BOTTOM w0.16: v2(211.76,18.58) 211.65,18.58 211.33,18.9 CN4125.155
M_ODT3: length 95.7
  L3 w0.089: 154.16,45.03 153.94,45.25 153.94,48.44 153.57,48.8 153.57,51.25 v1(152.85,51.97)
  L3 w0.117: 154.16,45.03 154.16,42.75 160.32,36.58 161.34,36.58 161.34,36.58 161.65,36.58 165.78,32.45 203.18,32.45 206.78,28.85 207.9,28.85 208.08,28.67 208.25,28.67 208.46,28.89 208.63,28.89 208.79,28.72 208.79,28.56 208.58,28.34 208.58,28.18 208.75,28.01 208.91,28.01 209.12,28.23 209.29,28.23 209.46,28.06 209.46,27.9 209.24,27.68 209.24,27.52 209.41,27.35 209.57,27.35 209.79,27.57 209.95,27.57 210.12,27.4 210.12,27.24 209.9,27.02 209.9,26.86 210.07,26.69 210.23,26.69 210.45,26.9 210.61,26.9 210.78,26.74 210.78,26.57 210.56,26.36 210.56,26.19 210.73,26.03 210.89,26.03 211.11,26.24 211.27,26.24 211.44,26.08 211.44,25.91 211.23,25.7 211.23,25.53 211.34,25.42 212.1,25.42 212.93,24.6 212.93,24.36 212.81,24.25 212.78,24.25 212.66,24.13 212.66,23.89 212.78,23.78 212.81,23.78 212.93,23.66 212.93,23.43 212.81,23.31 212.78,23.31 212.66,23.19 212.66,22.96 212.78,22.84 212.81,22.84 212.93,22.73 212.93,22.49 212.81,22.38 212.78,22.38 212.66,22.26 212.66,22.03 212.78,21.91 212.81,21.91 212.93,21.79 212.93,17.96 v2(212.8,17.83)
  BOTTOM w0.076: v1(152.85,51.97) 153.22,52.34 153.22,52.51 153.71,53 153.71,53.36 153.47,53.6 153.47,54.56 153.53,54.74 153.53,54.98 153.49,55.09 153.49,56.22 U4555.AL34
  BOTTOM w0.16: v2(212.8,17.83) 212.83,17.86 CN4125.161
MAIN_BAT_DET#: length 285.4
  TOP w0.102: R60012.1 185.52,103.95 v1(184.65,104.81) ; v1(223.85,41.16) 223.34,41.16 R406.1 223.11,41.38 223.11,41.44 223.01,41.54 222.68,41.54 222.51,41.72 R374.1
  L5 w0.102: v1(216.94,108.19) 217.19,107.94 217.19,106.23 216.48,105.52 216.48,100.59 216.53,100.54 216.73,100.34 216.73,100.34 218.69,98.38 218.69,98.04 218.31,97.66 218.31,87.46 218.44,87.33 218.44,82.38 218.31,82.25 218.31,79.88 216.91,78.48 216.91,73.28 217.07,73.12 217.07,68.43 218.58,66.91 218.58,65.93 219.12,65.39 219.12,62.78 224.81,57.09 224.81,52.92 226.11,51.63 226.11,48.13 226.11,47.96 225.24,47.1 225.24,46.47 223.42,44.64 223.42,41.59 v1(223.85,41.16) ; v1(184.65,104.81) 184.6,104.76 182.98,104.76 181.81,105.93 156.15,105.93 155.98,105.93 155.64,105.93 153.84,107.74 148.2,107.74 146.99,106.53 146.99,97.92 145.85,96.79 125.68,96.79 125.21,96.31 120.97,92.08 117.65,92.08 117.29,91.72 117.29,86.93 114.65,84.29 114.65,83.69 115.04,83.3 115.07,83.3 115.2,83.17 115.9,83.17 116.39,82.68 116.39,77.81 116.13,77.55 116.13,74.96 116.25,74.84 116.25,64.15 115.84,63.73 114.56,63.73 111.73,60.9 111.73,57.73 109.72,55.72 106.93,55.72 104.44,53.24 104.44,51.94 104.37,51.87 104.37,51.33 100.83,47.79 95.73,47.79 86.92,38.98 86.92,38.62 83.88,35.58 83.88,30.76 81.89,28.77 81.48,28.77 80.8,28.09 80.8,27.04 v1(81.2,26.63)
  L6 w0.102: v1(184.65,104.81) 185.49,103.98 187.79,103.98 188.37,104.55 194.02,104.55 195.02,105.55 196.49,105.55 199.54,108.6 204.69,108.6 206.81,110.72 209.19,110.72 211.29,108.62 214.05,108.62 214.25,108.42 216.09,108.42 216.32,108.19 v1(216.94,108.19)
  BOTTOM w0.102: v1(81.2,26.63) 80.96,26.88 R6052.1
MAIN_BAT_DET#_BAT: length 4.8
  BOTTOM w0.254: C7503.2 80.55,25.97 80.58,26 R6052.2 ; C7503.2 79.81,25.12 D7500.2 79.85,24.07 79.85,24.06 CN6050.6 ; C7503.2 79.81,26.6 TP6054.1
MAIN_BAT_DET#_EC: length 14.2
  TOP w0.076: 232.51,41.19 232.76,40.93 233.7,40.93 234.64,40 235.63,40 U300.E11
  TOP w0.102: R374.2 223.31,41.57 227.13,41.57 227.56,42 228.46,42 229.23,41.23 230.5,41.23 230.55,41.19 232.5,41.19 232.51,41.19
ME_UNLOCK#: length 15.7
  TOP w0.076: v1(240.83,41.94) U300.G4
  TOP w0.102: R317.1 250.72,45.5 Q4755.1 249.27,44.05 v1(249.27,44.05)
  L3 w0.076: v1(240.83,41.94) 241.71,41.94 242.2,41.45 245.44,41.45
  L3 w0.102: v1(249.27,44.05) 249.38,44.05 249.78,43.64 249.78,42.66 249.48,42.36 249.48,41.85 249.09,41.47 246.62,41.47 246.37,41.21 246.03,41.21 245.79,41.45 245.44,41.45
  BOTTOM w0.102: v1(249.27,44.05) v3(248.58,44.05)
MIC_PRIVA_EN: length 75.8
  TOP w0.076: U300.K10 236.27,43.9 236.27,44.35 236.08,44.53 235.78,44.53 235.62,44.69 235.62,45.01 234.83,45.8 233.59,45.8 v1(233.09,46.29)
  TOP w0.102: v1(220.57,97.5) 221.66,98.59 v3(221.66,99.71) 221.66,100.19 v1(221.43,100.42)
  L5 w0.102: v1(227,46.78) 227.33,47.11 227.33,55.44 219.73,63.03 219.73,66.81 220.27,67.35 220.37,67.35 220.98,67.96 221.56,67.96 222.12,68.52 222.12,69.03 220.8,70.35 220.8,75.82 222.5,77.52 222.5,78.09 223.14,78.73 223.14,81.52 221.05,83.61 221.05,87.16 219.3,88.91 219.3,96.23 v1(220.57,97.5)
  BOTTOM w0.076: 232.51,46.29 v1(233.09,46.29)
  BOTTOM w0.102: v1(221.43,100.42) 221.31,100.42 220.72,99.83 U3002.6 ; v1(220.57,97.5) 220.49,97.42 U3003.6 ; v1(227,46.78) 227.71,46.06 232.28,46.06 232.51,46.29
MSATA_DET: length 133.4
  TOP w0.102: Q1951.D 259.56,11.6 R1952.1 259.46,10.38 v3(258.77,10.38) 257.81,10.38 255.8,12.38 248.24,12.38 248.07,12.38 245.55,14.9 245.55,18.52 243.33,20.74 243.33,21.53 v1(243.94,22.14)
  L6 w0.102: v1(188.87,72.57) 189.1,72.19 189.1,70.96 189.49,70.57 198.35,70.57 201.36,70.57 201.92,71.13 201.92,71.47 201.57,71.82 201.57,72.62 202.54,73.59 204.84,73.59 205.2,73.23 205.2,72.74 207.72,70.22 207.72,69.76 208.07,69.4 208.93,69.4 209.52,69.99 211.25,69.99 214.99,66.25 214.99,66.08 214.99,58.88 214.69,58.58 214.69,55.49 215.31,54.87 215.31,51.65 219.99,46.98 219.99,46.69 219.99,46.69 219.99,42.24 220.9,41.33 220.9,41.04 222.12,39.82 222.12,39.61 223.16,38.57 224.47,38.57 224.86,38.18 224.86,37.53 226.11,36.29 226.28,36.29 226.47,36.29 227.61,35.14 228.5,35.14 228.67,35.14 230.25,33.57 232,33.57 232.22,33.57 232.43,33.36 232.71,33.36 233.27,33.36 233.6,33.03 235.71,33.03 236.16,32.58 236.42,32.32 236.42,31.71 238.05,30.09 238.05,25.59 238.05,25.42 239.93,23.53 242.55,23.53 v1(243.94,22.14)
  BOTTOM w0.076: 188,72.16 187.05,72.16 186.66,71.77 180.9,71.77 180.68,71.97 180.3,71.97 180.1,71.86 179.58,71.86 179.52,71.8 178.85,71.8 U4555.CM10
  BOTTOM w0.102: v1(188.87,72.57) 188.46,72.16 188,72.16
NFC_3V3: length 18.8
  TOP w0.381: R4352.2 231.87,3.71 R4350.2 230.91,3.71 230.19,4.42 228.67,4.42 v1(226.8,6.29)
  L3 w0.254: v1(226.8,6.29) 226.8,5.91 226.21,5.32 222.83,5.32 221.92,6.24 221,6.24 220.44,6.8 v1(220.44,7)
  BOTTOM w0.254: CN4350.2 227,6.49 v1(226.8,6.29) 226.61,6.47 226.56,6.47 226.5,6.54 CN4350.3 ; v1(220.44,7) 220.5,7.06 CN4350.15
NFC_3V3_R: length 11.2
  TOP w0.254: R4350.1 230.69,4.56 230.38,4.87 229.13,4.87 227.15,6.85 226.49,6.85 225.96,6.31 223.21,6.31 222.65,6.87 v1(222.65,7)
  BOTTOM w0.254: v1(222.65,7) 222.65,7.03 222.97,7.34 223,7.39 CN4350.10
NFC_CLICK_3S_SMCLK: length 249.4
  TOP w0.13: v1(223.95,7) 223.95,7.63 R4355.1 224.6,8.28 227.49,8.28 v3(227.76,8.55) 228.28,9.07 240.14,9.07 243.87,12.79 243.87,17.41 238.76,22.52 238.05,22.52 232.28,28.29 v1(232.28,29.17)
  L3 w0.097: v1(108.35,6.66) 108.81,6.2 109.94,6.2 113.67,9.93 128.47,9.93 129.42,10.87 134.71,10.87 135.68,9.9 144.77,9.9 145.71,8.96 150.32,8.96 150.69,8.96 151.63,9.9 157.08,9.9 157.44,10.27 159.27,10.27 159.69,9.84 160.53,9.84 162.54,9.84 163.15,9.24 164.12,9.24 164.19,9.31 164.34,9.46 168.83,9.46 169,9.63 171.21,9.63 171.89,10.31 191.71,10.31 192.67,9.35 214.1,9.35 215.62,7.83 223.12,7.83 v1(223.95,7)
  L6 w0.127: v1(232.28,29.17) 232.53,29.43 232.53,29.98 230.94,31.57 227.77,31.57 227.36,31.98 226.58,31.98 225.71,32.85 225.71,33.14 223.75,35.1 220.99,35.1 219.2,36.9 219.2,37.96 212.89,44.27 212.89,45.1 212.39,45.59 211.56,45.59 210.66,46.49 210.66,46.99 210.28,47.36 210.28,57.94 208,60.23 208,61.33 207.15,62.17 207.15,65.09 206.12,66.12 205.91,66.12 205.91,66.12 204.94,66.12 202.78,68.27 200.88,68.27 187.64,68.27 185.37,70.55 184.67,70.55 v1(184.25,70.13)
  BOTTOM w0.076: v1(184.25,70.13) 183.86,69.74 183.03,69.74 182.45,70.33 182.02,70.33 181.68,70.67 180.33,70.67 180.2,70.62 180.06,70.62 179.92,70.67 179.7,70.67 U4555.CN11
  BOTTOM w0.13: CN4350.8 224,7.05 v1(223.95,7) ; CN303.7 108.25,6.76 v1(108.35,6.66)
NFC_CLICK_3S_SMDATA: length 250
  TOP w0.13: v1(232.11,29.8) 231.86,29.55 231.86,28.35 237.95,22.26 238.65,22.26 243.61,17.31 243.61,12.89 240.04,9.32 227.01,9.32 v3(226.49,8.8) 226.25,8.56 224.09,8.56 R4354.1 223.39,7.76 v1(223.39,6.82)
  L3 w0.097: v1(107.69,6.66) 108.37,5.98 110.04,5.98 113.76,9.7 128.56,9.7 129.51,10.65 134.62,10.65 135.58,9.68 144.68,9.68 145.62,8.74 150.22,8.74 150.22,8.74 150.78,8.74 151.72,9.68 157.17,9.68 157.36,9.87 157.54,10.04 159.18,10.04 159.6,9.62 162.45,9.62 163.06,9.01 163.24,9.01 164.21,9.01 164.44,9.24 168.92,9.24 169.09,9.41 173.92,9.41 174.51,9.99 179.67,9.99 179.77,10.09 191.62,10.09 192.66,9.05 214.08,9.05 215.52,7.61 222.98,7.61 223.39,7.2 v1(223.39,6.82)
  L6 w0.127: v1(183.54,70.13) 184.26,69.4 186.03,69.4 187.41,68.02 199.4,68.02 199.4,68.02 200.77,68.02 202.67,68.02 204.83,65.87 204.83,65.86 206.01,65.86 206.89,64.98 206.89,60.97 210.03,57.84 210.03,47.26 210.41,46.88 210.41,46.39 218.94,37.85 218.94,36.79 220.88,34.85 223.64,34.85 225.46,33.03 225.46,32.74 226.48,31.73 227.26,31.73 227.67,31.32 227.88,31.32 230.6,31.32 v1(232.11,29.8)
  BOTTOM w0.076: U4555.CM11 179.09,71.15 179.57,71.15 179.68,71.11 179.93,71.11 179.94,71.12 180.03,71.15 180.22,71.15 180.35,71.11 182.29,71.11 182.32,71.11 182.54,70.88 182.54,70.64 183.05,70.13 183.06,70.13 v1(183.54,70.13)
  BOTTOM w0.13: CN303.6 107.75,6.72 v1(107.69,6.66) ; CN4350.9 223.5,6.93 v1(223.39,6.82)
NFC_DETECT#: length 113.9
  TOP w0.102: v1(183.59,60.75) 183.86,60.75 183.89,60.72 185.01,60.72 R4353.1
  L5 w0.102: v1(227.73,7.02) 228.18,7.02 231.41,10.25 235.8,10.25 235.8,10.25 236.37,10.25 241.12,15 241.12,16.91 236.74,21.29 236.33,21.29 234.37,23.26 234.37,23.82 233.94,24.25 232.45,24.25 230.32,26.38 229.72,26.38 229.51,26.58 219.17,26.58 218.97,26.38 215.45,26.38 197.67,44.16 182.69,44.16 182.59,44.26 182.59,45.37 183.2,45.98 183.2,46.89 183.58,47.27 183.85,47.27 184.09,47.51 184.09,47.84 183.76,48.17 183.76,60.29 183.74,60.31 183.74,60.59 v1(183.59,60.75)
  BOTTOM w0.076: v1(183.59,60.75) 182.61,60.75 182.05,61.31 182.04,61.31 182.03,61.31 181.47,61.31 181.35,61.19 180.36,61.19 180.27,61.23 180.26,61.23 180,61.23 179.9,61.19 179.71,61.19 179.62,61.23 179.47,61.37 U4555.CN26
  BOTTOM w0.102: v1(227.73,7.02) 227.5,7.26 CN4350.1
