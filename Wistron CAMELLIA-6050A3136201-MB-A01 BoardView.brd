# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Nets (continued)
PVCCIO: C4521.1(A) C4525.1(A) C4526.1(A) C4527.1(A) PAD60500.2 R4530.2(B) R4544.1(A) R4940.2(B) TP60500.1 U4555.AK24(VCCIO_OUT_1) U4555.AK26(VCCIO_OUT_2) U4555.AL24(VCCIO_OUT_3) U4555.AL25(VCCIO_OUT_4) U4555.AL26(VCCIO_OUT_5) U4555.AL27(VCCIO_OUT_6) U4555.AM25(VCCIO_OUT_7) U4555.AM27(VCCIO_OUT_8) U4555.BH24(VCCIO_OUT_9) U4555.BH25(VCCIO_OUT_10) U4555.BH26(VCCIO_OUT_11) U4555.BH27(VCCIO_OUT_12) U4555.BJ24(VCCIO_OUT_13) U4555.BJ26(VCCIO_OUT_14) U4555.BP16(VCCIO_OUT_15) U4555.BP18(VCCIO_OUT_16)
PVCCSA: C4522.1(A) C4528.1(A) C4577.1(A) C4585.1(A) C4586.1(A) C4587.1(A) C66600.1(A) C66601.1(A) L66610.2 L66610.4 R4522.2(B) TP66600.1 U4555.BG8(VCCSA_1) U4555.BG10(VCCSA_2) U4555.BH9(VCCSA_3) U4555.BJ8(VCCSA_4) U4555.BJ9(VCCSA_5) U4555.BJ10(VCCSA_6) U4555.BK8(VCCSA_7) U4555.BK25(VCCSA_8) U4555.BK27(VCCSA_9) U4555.BL8(VCCSA_10) U4555.BL9(VCCSA_11) U4555.BL10(VCCSA_12) U4555.BL24(VCCSA_13) U4555.BL26(VCCSA_14) U4555.BM24(VCCSA_15) U4555.BN25(VCCSA_16)
PVCCSFR: C325.2(B) C4516.2(B) C4529.1(A) C4624.2(B) C4625.2(B) C4626.2(B) C7027.1(A) C66100.1(A) Q7151.4(S0) R383.1(A) R4594.2(B) R4595.2(B) R4604.1(A) R4605.1(A) R4739.1(A) R66100.1(A) R66101.1(A) R66104.1(A) U4555.BP2(VCCST_1) U4555.BP11(VCCST_2) U4555.BR11(VCCPLL_1) U4555.BT11(VCCPLL_2)
PVCCSFR_EN: C7025.1(A) Q7151.3(G) Q7307.6 R7311.1(A)
PVCCSFR_EN#: Q7307.2 Q7307.3 R7301.1(A)
PVCCSFR_PWRGD_R: R4626.1(A) R4722.2(B) R4739.2(B)
PVCCSFR_PWRGD_R_R: Q4751.6 R4626.2(B)
PVCCSTG: C4512.2(B) Q7153.4(S0) R4507.2(B) R4508.2(B) R4517.1(A) R4807.1(A) R4886.1(A) R4891.1(A) R4920.2(B) R7013.2(B) U4555.BG1(VCCSTG_1) U4555.BG2(VCCSTG_2) U4555.BG3(VCCSTG_3)
PVCCSTG_EN: C7023.1(A) Q7000.5 Q7153.3(G) Q7300.6 R7006.1(A) R7304.1(A)
PVCCSTG_EN#: Q7300.2 Q7300.3 R7306.1(A)
PVDDI_EMMC: C3801.1(A) U3800.C2
VBAT: C60019.2(B) C60031.1(A) R60013.1(A) U60000.31
VCC0V9_LVR_OUT: C2773.1(A) C2774.1(A) C2775.1(A) C2776.1(A) U2700.H6(VCC0P9_LVR_SENSE) U2700.H8(VCC0P9_LVR)
VCC0V9_SVR: C2756.1(A) C2757.1(A) C2758.1(A) C2759.1(A) C2760.1(A) C2761.1(A) C2762.1(A) C2763.1(A) C2764.1(A) C2765.1(A) C2766.1(A) C2767.1(A) C2782.1(A) C2783.1(A) C2784.1(A) C2785.1(A) C2786.1(A) L2701.2(INB) U2700.E8(VCC0P9_SVR_BRD_SENSE) U2700.H9(VCC0P9_SVR_PAB_ANA<5>) U2700.H11(VCC0P9_SVR_PAB_ANA<0>) U2700.H12(VCC0P9_SVR_PAB_ANA<1>) U2700.H13(VCC0P9_SVR_PAB_ANA<2>) U2700.H15(VCC0P9_SVR_PAB_ANA<3>) U2700.H16(VCC0P9_SVR_PAB_ANA<4>) U2700.J13(VCC0P9_SVR<0>) U2700.L11(VCC0P9_SVR<1>) U2700.L13(VCC0P9_SVR<2>) U2700.M8(VCC0P9_SVR<3>) U2700.M11(VCC0P9_SVR<4>) U2700.M13(VCC0P9_SVR<5>) U2700.N6(VCC0P9_SVR_DPAUX_ANA) U2700.N8(VCC0P9_SVR<6>) U2700.N11(VCC0P9_SVR<7>) U2700.N13(VCC0P9_SVR<8>) U2700.R8(VCC0P9_SVR<9>) U2700.R11(VCC0P9_SVR<10>) U2700.R13(VCC0P9_SVR<11>) U2700.R16(VCC0P9_SVR<12>) U2700.T8(VCC0P9_SVR<13>) U2700.T9(VCC0P9_SVR_USB_ANA<0>) U2700.T11(VCC0P9_SVR_USB_ANA<1>) U2700.T12(VCC0P9_SVR_PC_ANA<0>) U2700.T13(VCC0P9_SVR_PC_ANA<1>) U2700.T15(VCC0P9_SVR_PC_ANA<2>) U2700.T16(VCC0P9_SVR<14>)
VCC1_R_RST#: CN375.16 R395.2(B)
VCC1_RST#: R325.1(A) R342.1(A) R395.1(A) U300.K6(VCC1_RST#/GPO77)
VCC_HDA: C4530.2(B) R4610.1(A) U4555.BT20(VCCHDA)
VCC_HV_SYS1: Q2609.5(D3) Q2609.6(D2) Q2609.7(D1) Q2609.8(D0) Q68101.5(D3) Q68101.6(D2) Q68101.7(D1) Q68101.8(D0) Q68104.3(D)
VCC_HV_SYS_2: Q2600.5(D3) Q2600.6(D2) Q2600.7(D1) Q2600.8(D0) Q68106.5(D3) Q68106.6(D2) Q68106.7(D1) Q68106.8(D0) Q68108.3(D)
VCC_PRIM_PG: R7026.1(A) R7424.1(A) U61400.13
VCCA_XTAL_1P05: C4517.1(A) R4609.2(B) U4555.CP5(VCCA_XTAL_1P05)
VCCAMPHYPLL_1P05: C4518.2(B) R4583.2(B) U4555.BV2(VCCAMPHYPLL_1P05)
VCCAPLL_1P05_3: C4532.2(B) R4585.2(B) U4555.BR15(VCCAPLL_1P05_3)
VCCDPHY: U4555.BY23(VCCDPHY_1P24_1) U4555.BY24(VCCDPHY_1P24_4) U4555.CA23(VCCDPHY_1P24_2) U4555.CA24(VCCDPHY_1P24_5)
VCCDPHY_EC: C4544.1(A) U4555.CP25(VCCDPHY_1P24_3)
VCCDSW_1P05: C4534.2(B) TP4503.1 U4555.BT24(VCCDSW_1P05)
VCCIO_LP#: R60520.2(B) R60522.2(B) U60500.6
VCCIO_PG: R4552.1(A) R7422.2(B) U60500.13
VCCIO_VCCSENSE: R4530.1(A) U4555.BP28(VCCIO_SENSE) U60500.12
VCCIO_VSSSENSE: C60509.1(A) R4531.1(A) R60526.1(A) U4555.BP29(VSSIO_SENSE) U60500.11
VCCPLL_OC: C4515.2(B) Q7159.4(S0) U4555.BL27(VCCPLL_OC_1) U4555.BM26(VCCPLL_OC_2)
VCCPLL_OC_EN: D4702.3(C) R7002.1(A) R7003.1(A) R7004.2(B) U4921.1
VCCPLL_OC_Q_EN: C7029.1(A) Q7159.3(G) R7006.2(B)
VCCPLL_OC_XDP_EN: Q7300.5 R7002.2(B) U4921.4
VCCSA_VCCSENSE: R4522.1(A) R66680.2(B) U4555.BG7(VCCSA_SENSE)
VCCSA_VSSSENSE: R4524.1(A) R66681.2(B) U4555.BE7(VSSSA_SENSE)
VCCSENSE: R4593.1(A) R66829.2(B) U4555.AN6(VCC_SENSE)
VCCST_PWRGD: R4722.1(A) U4555.BJ2(VCCST_PWRGOOD)
VCCST_PWRGD_XDP: CN4920.39(PWRGOOD_HOOK0) R4926.2(B)
VDDQ_PG: R7416.1(A) U60300.12
VSSSENSE: R4598.1(A) R66831.2(B) U4555.AN5(VSS_SENSE)
1ALS_HUB_INT#_DB: CN9302.4 U9302.3
1ALS_HUB_SMCLK_DB: CN9302.3 U9302.5
1ALS_HUB_SMDATA_DB: CN9302.2 U9302.2
8051_RX_CAPS_LED#: CN375.14 R324.1(A) R360.2(B) U300.J7(GPIOB7/PWM5_LED1) U302.3(A2)
8051_TX_LED_PWRSTBY#: CN375.13 R322.1(A) R361.2(B) U300.H8(GPIOC0/PWM6_LED2) U302.1(A1)
A_LINEINL: TP506.1 U500.36(LINE2-L)
A_LINEINR: TP505.1 U500.35(LINE2-R)
A_SD#: R396.1(A) R502.1(A) U300.L8(GPIO92/I2C2_SCL0)
ABMON: C60027.1(A) R444.1(A) R60011.2(B)
ADDRP: R66111.2(B) R66112.1(A) U66000.25(ADDR_P)
ADP_DET: D60097.1(A1) R60002.1(A) R60021.2(B) U300.M5(GPIO71/PS2_DAT3/TB2) U60000.24
ADP_PRES_OUT: R4743.2(B) U300.H3(GPOD6/JEN1#) U4555.BU35(GPD1/ACPRESENT)
ALS_DETECT#: CN3001.20 R4782.2(B) U4555.CP4(GPP_E22/DPPD_CTRLCLK)
ALS_HUB_INT#_DB: CN9300.4 U9300.3
ALS_HUB_SMCLK_DB: CN9300.3 U9300.5
ALS_HUB_SMDATA_DB: CN9300.2 U9300.2
ALS_LOW_LIGHT_EC: R4622.2(B) U300.D3(GPIO42/ADC3/RI#)
ALS_LOW_LIGHT_PCH: R4603.1(A) R4622.1(A) U4555.BW36(GPP_A17/SD_VDD1_PWR_EN#/ISH_GP7)
ALS_PL_INT#_DB: CN9301.4 U9301.3
ALS_PL_SMCLK_DB: CN9301.5 U9301.5
ALS_PL_SMDATA_DB: CN9301.3 U9301.2
AMD_PD#_DB: CN9202.29 R9204.2(B) R9205.2(B) TP9202.1 TP9205.1 U9201.5 U9203.5
AUDIO_AVDD: C512.1(A) C513.1(A) C518.1(A) C519.1(A) R521.2(B) U500.41(PVDD1) U500.46(PVDD2)
AUDIO_AVDD1: C516.2(B) C517.2(B) C526.2(B) R518.2(B) R520.2(B) U500.33(AUX) U500.40(AVDD1)
AUDIO_AVDD1_R: C514.2(B) Q500.D R518.1(A)
AUDIO_CBN: C509.2(B) U500.24(CBN)
AUDIO_CBP: C509.1(A) U500.23(CBP)
AUDIO_CPVEE: C500.2(B) U500.25(CPVEE)
AUDIO_DMIC_CLK: R7600.1(A) TP513.1 U500.5(GPIO1/DMIC-CLK)
AUDIO_I2C_SCL: TP515.1 U500.7(I2C_SCL)
AUDIO_I2C_SDA: U500.6(I2C_SDA)
AUDIO_I2S_DIN: TP504.1 U500.8(I2S_DIN)
AUDIO_I2S_DOUT: TP503.1 U500.9(I2S_DOUT)
AUDIO_I2S_MCLK: TP501.1 U500.11(I2S_MCLK)
AUDIO_I2S_SCLK: TP502.1 U500.10(I2S_SCLK)
AUDIO_LDO1_CAP: C507.2(B) R506.2(B) U500.39(LDO1_CAP)
AUDIO_LDO2_CAP: C508.1(A) U500.21(LDO2_CAP)
AUDIO_LDO3_CAP: C510.1(A) U500.19(LDO3_CAP)
AUDIO_MIC_CAP: C506.2(B) U500.32(MIC_CAP)
AUDIO_PDB: R515.2(B) U500.2(PDB)
AUDIO_VREF: C501.2(B) U500.38(VREF)
BARREL_ADP_DET: Q68121.3(C) R424.2(B) R68120.2(B) R68121.1(A)
BARREL_ADP_DET_EC: C327.1(A) R424.1(A) U300.H5(GPIO74)
BARREL_ADP_EN: Q60032.S R60053.1(A) U300.F4(GPIOE0)
BAT_AMBERLED#: D300.4 U300.L9
BAT_AMBERLED#_R: D300.2 R435.1(A)
BAT_WHITELED#: D300.3 U300.F7(GPIO02)
BAT_WHITELED#_R: D300.1 R413.1(A)
BATLOW#: Q302.D R2704.1(A) R4744.2(B) U300.A9(GPIOD4/JTAG_TDO1_SWO1) U4555.BV36(GPD0/BATLOW#)
BATLOW#_N: R2704.2(B) U2700.U2(BATLOW#)
BKLT_EN: CN3000.19 D3001.1(A1) R3002.2(B) R3009.2(B)
BOOT_SPI#: R4837.2(B) U4555.CA30(GPP_B22/GSPI1_MOSI)
BRD_ID1: R4571.2(B) R4572.2(B) U4555.CR28(GPP_H12/M2_SKT2_CFG0)
BRD_ID2: R4573.2(B) R4574.2(B) U4555.CP28(GPP_H13/M2_SKT2_CFG1)
BRD_ID3: R4575.2(B) R4576.2(B) U4555.CN28(GPP_H14/M2_SKT2_CFG2)
BRD_ID4: R4577.2(B) R4578.2(B) U4555.CM28(GPP_H15/M2_SKT2_CFG3)
BT_OFF: R1308.1(A) R4562.2(B) U4555.CC35(GPP_B4/CPU_GP3)
BT_OFF#: CN1300.54 Q1302.D R1306.2(B)
BT_OFF_R: Q1302.G R1308.2(B)
BUF_PLT_RST#: CN1951.50(PERST#/NC) Q302.G Q2620.5 Q3800.5 R1347.1(A) R4502.1(A) R4713.1(A) U1300.1 U1401.1 U2701.1 U4700.4(OUT)
CAMERA_ON: CN3001.5 R3033.1(A) R4565.2(B) U4555.CA31(GPP_B19/GSPI1_CS0#)
CAMERA_WP#: CN3001.15 R3001.2(B) R3007.1(A) R3034.2(B)
CAMERA_WP#_EC: R3001.1(A) U300.E8(GPIOF5/I2C5_SCL1)
CAPS_LED#: R341.1(A) R360.1(A) R392.1(A) U302.4(Y2)
CAPS_LED#_R: CN300.12 R392.2(B)
CATERR#: R4604.2(B) U4555.AA4(CATERR#)
CCG5_A_CC1: C2422.1(A) CN2900.A5 D2619.1 U2403.K2
CCG5_A_CC2: C2419.1(A) CN2900.B5 D2603.1 U2403.H2
CCG5_B_CC1: C2421.1(A) CN2800.A5 D2806.1 U2403.K9
CCG5_B_CC2: C2420.1(A) CN2800.B5 D2807.1 U2403.K10
CCG5_BOT_A_L_DN: CN2900.B7 D2614.1 D2614.10 U2403.C1
CCG5_BOT_A_L_DP: CN2900.B6 D2614.2 D2614.9 U2403.B1
CCG5_BOT_B_L_DN: CN2800.B7 D2606.1 D2606.10 U2403.L1
CCG5_BOT_B_L_DP: CN2800.B6 D2606.2 D2606.9 U2403.K1
CCG5_I2C_EC_INT#: CN2701.12 R397.1(A) R2626.1(A) U300.A11(GPIOE2/JTAG_TDI1)
CCG5_I2C_EC_R_INT#: R2626.2(B) U2403.L5
CCG5_I2C_EC_R_SCL: R2660.2(B) U2403.L6
CCG5_I2C_EC_R_SDA: R2684.2(B) U2403.K6
CCG5_I2C_EC_SCL: CN2701.14 R375.1(A) R2660.1(A) U300.F8(GPIOD1/I2C3_SCL0)
CCG5_I2C_EC_SDA: CN2701.13 R356.1(A) R2684.1(A) U300.F9(GPIOD0/I2C3_SDA0)
CCG5_MOD_ID1: R2465.2(B) R2466.1(A) U2403.A8
CCG5_MOD_ID2: R2463.1(A) R2464.2(B) U2403.A9
CCG5_PD_ADP_DIS1#: Q2607.3 Q2607.6 R2621.1(A)
CCG5_PD_ADP_DIS1#_R: Q2601.1(G) R2619.1(A) R2621.2(B)
CCG5_PD_ADP_DIS2#: Q2605.3 Q2605.6 R2612.1(A)
CCG5_PD_ADP_DIS2#_R: Q2603.1(G) R2611.1(A) R2612.2(B)
CCG5_PVCC_PD: C2423.1(A) C2424.1(A) C2425.1(A) R2421.2(B) R2422.2(B) R2441.1(A) R2458.2(B) R2463.2(B) R2466.2(B) U2403.C10 U2403.D10
CCG5_SBU1_A_DP: CN2900.A8 D2615.1 U2403.A3
CCG5_SBU1_B_DP: CN2800.A8 D2605.1 U2403.E1
CCG5_SBU2_A_DN: CN2900.B8 D2618.1 U2403.A4
CCG5_SBU2_B_DN: CN2800.B8 D2604.1 U2403.F1
CCG5_SWD_CLK: CN375.26 R2457.2(B) R2458.1(A) U2403.C2
CCG5_SWD_IO: CN375.25 R2418.1(A) R2449.1(A) U2403.B2
CCG5_SWD_XRES: C2432.1(A) CN375.27 R2441.2(B) U2403.H6
CCG5_TOP_A_L_DN: CN2900.A7 D2614.5 D2614.6 U2403.A2
CCG5_TOP_A_L_DP: CN2900.A6 D2614.4 D2614.7 U2403.A1
CCG5_TOP_B_L_DN: CN2800.A7 D2606.5 D2606.6 U2403.H1
CCG5_TOP_B_L_DP: CN2800.A6 D2606.4 D2606.7 U2403.G1
CCG5_TR_RST#: R2449.2(B) R2742.1(A) R2749.1(A) U2700.E5(RESET#)
CCG5_VBUS_C_CTRL_P1: Q2607.2 R2602.1(A) R2606.2(B) U2403.K4
CCG5_VBUS_C_CTRL_P2: Q2605.2 R2613.1(A) R2614.2(B) U2403.B5
CCG5_VBUS_CSN1: C2612.1(A) C2614.1(A) C2630.1(A) C2633.1(A) C2634.1(A) R2620.1(A) R2625.2(B) R2669.2(B) R2671.2(B) U2602.A1(VIN1) U2602.A2(VIN2)
CCG5_VBUS_CSN1_D: D2611.2(A2) U2602.B1(VCP1) U2602.B2(VCP2) U2602.C1(VCP3)
CCG5_VBUS_CSN1_R: R2620.2(B) U2602.A4(NFLT)
CCG5_VBUS_CSN2: C2603.1(A) C2604.1(A) C2605.1(A) C2615.1(A) C2616.1(A) R2604.1(A) R2638.2(B) R2639.2(B) R2647.2(B) U2600.A1(VIN1) U2600.A2(VIN2)
CCG5_VBUS_CSN2_D: D2612.2(A2) U2600.B1(VCP1) U2600.B2(VCP2) U2600.C1(VCP3)
CCG5_VBUS_CSN2_R: R2604.2(B) U2600.A4(NFLT)
CCG5_VBUS_P_CTRL_P1: Q2613.G R2422.1(A) U2403.K3
CCG5_VBUS_P_CTRL_P1#: Q2613.D R2628.1(A) U2602.B4(EN)
CCG5_VBUS_P_CTRL_P2: Q2602.G R2421.1(A) U2403.B4
CCG5_VBUS_P_CTRL_P2#: Q2602.D R2618.1(A) U2600.B4(EN)
CCG51_VCCD: C2427.1(A) U2403.B10
CFG<0>: CN4920.9(OBSDATD_A0) R4822.1(A) U4555.T4(CFG_0)
CFG<1>: CN4920.11(OBSDATD_A1) U4555.R4(CFG_1)
CFG<2>: CN4920.15(OBSDATD_A2) U4555.T3(CFG_2)
CFG<3>: CN4920.17(OBSDATD_A4) R4932.1(A) U4555.R3(CFG_3)
CFG<4>: CN4920.27(OBSDATA_B0) R4523.1(A) U4555.J4(CFG_4)
CFG<5>: CN4920.29(OBSDATA_B1) U4555.M4(CFG_5)
CFG<6>: CN4920.33(OBSDATA_B2) U4555.J3(CFG_6)
CFG<7>: CN4920.35(OBSDATA_B3) U4555.M3(CFG_7)
CFG<8>: CN4920.10(OBSDATA_C0) U4555.R2(CFG_8)
CFG<9>: CN4920.12(OBSDATA_C1) R4534.1(A) U4555.N2(CFG_9)
CFG<10>: CN4920.16(OBSDATA_C2) U4555.R1(CFG_10)
CFG<11>: CN4920.18(OBSDATA_C3) U4555.N1(CFG_11)
CFG<12>: CN4920.28(OBSDATA_D0) U4555.J2(CFG_12)
CFG<13>: CN4920.30(OBSDATA_D1) U4555.L2(CFG_13)
CFG<14>: CN4920.34(OBSDATA_D2) U4555.J1(CFG_14)
CFG<15>: CN4920.36(OBSDATA_D3) U4555.L1(CFG_15)
CFG<16>: CN4920.6(OBSFN_C1) R4566.1(A) U4555.L3(CFG_16)
CFG<17>: CN4920.4(OBSFN_C0) U4555.L4(CFG_17)
CFG<18>: CN4920.24(OBSFN_D1) R4597.1(A) U4555.N3(CFG_18)
CFG<19>: CN4920.22(OBSFN_D0) U4555.N4(CFG_19)
CFG_RCOMP: R4519.2(B) U4555.AB5(CFG_RCOMP)
CL_CLK1: CN1300.42 U4555.CH7(CL_CLK)
CL_DATA1: CN1300.40 U4555.CH8(CL_DATA)
CL_RST#1: CN1300.38 U4555.CH9(CL_RST#)
CLICK_PS2_CLK: CN303.3 R401.1(A)
CLICK_PS2_CLK_R: R401.2(B) R426.1(A) U300.C1(GPIO37/PS2_CLK2/ADC5)
CLICKPAD_DISABLE#: CN303.1 R407.1(A) R415.1(A) R449.2(B)
CLICKPAD_DISABLE#_R: R415.2(B) U300.D8(KSO17/GPIOB1)
CLICKPAD_INT#: CN303.4 R4584.2(B) R4625.1(A)
CLIK_KBL_INFO: CN303.2 R318.1(A) U300.B2(GPIO34/PS2_DAT2/ADC6)
CLK_PCIE0_DN: CN1951.53(REFCLKN) U4555.AW2(CLKOUT_PCIE_N0)
CLK_PCIE0_DP: CN1951.55(REFCLKP) U4555.AY3(CLKOUT_PCIE_P0)
CLK_PCIE1_DN: CN1400.53(REFCLKN) U4555.BC1(CLKOUT_PCIE_N1)
CLK_PCIE1_DP: CN1400.55(REFCLKP) U4555.BC2(CLKOUT_PCIE_P1)
CLK_PCIE3_DN: CN1300.49 U4555.BH3(CLKOUT_PCIE_N3)
CLK_PCIE3_DP: CN1300.47 U4555.BH4(CLKOUT_PCIE_P3)
CLK_PCIE5_DN: U2700.T19(REFCLK_100_IN*) U4555.BE1(CLKOUT_PCIE_N5)
CLK_PCIE5_DP: U2700.V19(REFCLK_100_IN_P) U4555.BE2(CLKOUT_PCIE_P5)
CLK_PCIE_XDP_DN: CN4920.42(ITPCLK#_HOOK5) U4555.AU1(CLKOUT_ITPXDP*)
CLK_PCIE_XDP_DP: CN4920.40(ITPCLK_HOOK4) U4555.AU2(CLKOUT_ITPXDP_P)
CLKIN_XTAL: R1336.2(B) R1337.1(A) U4555.CM3(CLKIN_XTAL)
CLKIN_XTAL_R: CN1300.64 R1337.2(B)
CLKREQ#_DGPU: R4711.2(B) U4555.CE30(GPP_B9/SRCCLKREQ4#)
CLKREQ#_SSD: CN1951.52(CLKREQ#/NC) R4718.2(B) U4555.CF32(GPP_B5/SRCCLKREQ0#)
CLKREQ#_TBT_D: D2700.1(A1) R2728.2(B) U2700.Y6(PCIE_CLKREQ#)
CLKREQ#_TR: D2700.2(A2) R4725.2(B) U4555.CF31(GPP_B10/SRCCLKREQ5#)
CLKREQ#_WLAN: R1351.1(A) R4705.2(B) U4555.CE31(GPP_B8/SRCCLKREQ3#)
CLKREQ#_WWAN: CN1400.52(CLKREQ#) R4721.2(B) U4555.CE32(GPP_B6/SRCCLKREQ1#)
CLKREQ_WLAN_R_N: CN1300.53 R1304.2(B) R1351.2(B)
CN1951_PEDET: CN1951.69(PEDET) Q1951.G R1952.2(B) R1954.2(B)
CNV_BRI_DT: R1312.2(B) R1344.1(A) R1345.2(B) U4555.CJ20(GPP_F4/CNV_BRI_DT)
CNV_BRI_DT_R: CN1300.36 R1312.1(A)
CNV_BRI_RSP: R1313.2(B) R4905.1(A) U4555.CK20(GPP_F5/CNV_BRI_RSP)
CNV_BRI_RSP_R: CN1300.22 R1313.1(A)
CNV_CLKREQ: R1318.1(A) R1332.1(A) U4555.CH29(GPP_H2/I2S2_TXD/CNV_BT_I2S_SDI/MODEM_CLKREQ)
CNV_CLKREQ_C: CN1300.14 R1318.2(B)
CNV_RF_RESET#: R1319.1(A) R4970.2(B) U4555.CJ32(GPP_H1/I2S2_SFRM/CNV_BT_I2S_BCLK/CNV_RF_RESET#)
CNV_RGI_DT: R1309.1(A) R1314.2(B) R1333.2(B) U4555.CG19(GPP_F6/CNV_RGI_DT)
CNV_RGI_DT_R: CN1300.32 R1314.1(A)
CNV_RGI_RSP: R1316.2(B) R4908.1(A) U4555.CH19(GPP_F7/CNV_RGI_RSP)
CNV_RGI_RSP_R: CN1300.34 R1316.1(A)
COMPARE_PWR_GOOD_3: C7403.1(A) D7400.3(C) R7405.2(B) R7409.1(A) R7411.2(B) R7413.2(B) R7416.2(B) R7418.1(A)
COMPARE_R_PWR_GOOD_3: R7407.1(A) R7409.2(B) U7400.3(+IN)
COMPARE_R_RSMRST_PG: R7406.1(A) R7408.2(B) U7400.5(+IN)
COMPARE_RSMRST_PG: C7401.1(A) R7401.1(A) R7408.1(A) R7420.2(B) R7425.2(B) R7428.2(B) R7429.2(B)
COMPARE_VRP3V3A_LDO: C7402.2(B) R7410.2(B) R7412.2(B) U7400.2(-IN) U7400.6(-IN)
CPPWR_EN: U300.E9(GPIOF4/I2C5_SDA1) U2501.8
CPU_C10_GATE#: D4702.1(A1) R4563.2(B) R60520.1(A) U4555.CN27(GPP_H18/CPU_C10_GATE#)
CPU_GPP_B7: R4798.2(B) U4555.CF30(GPP_B7/SRCCLKREQ2#)
CPU_GPP_B18: TP4504.1 U4555.CE29(GPP_B18/GSPI0_MOSI)
CPU_GPP_H11: TP4501.1 U4555.CJ29(GPP_H11/I2C5_SCL/ISH_I2C2_SCL)
CPU_GPPH20: TP4506.1 U4555.CH25(GPP_H20/IMGCLKOUT1)
CPU_POPI_RCOMP: R4587.2(B) U4555.BP27(PROC_POPIRCOMP)
CPU_PROCHOT#: C4514.1(A) R4515.1(A) R4517.2(B) R66001.1(A) R66104.2(B) R68054.2(B) R68055.2(B)
CPU_PROCHOT#_R: R4515.2(B) U4555.Y4(PROCHOT#)
CPU_SPI0_CS1#: TP4502.1 U4555.CG35(SPI0_CS1#)
CS_X360_DET: R357.1(A) R385.1(A) U300.E5(GPIO40/TA1_TACH1)
CSON: C60021.1(A) C60023.2(B) R60020.1(A) U60000.1
CSOP: C60023.1(A) C60024.1(A) R60018.1(A) U60000.2
CSUMA: R66154.2(B) R66454.2(B) R66455.2(B) U66000.18(CSSUMA)
CSUMB: R66155.2(B) U66000.19(CSSUMB)
D_COVER_OPEN: Q1004.D R423.1(A) R1018.1(A) U300.H2(GPIO62/PS2_CLK1)
DCI_STRAP: R4525.2(B) U4555.CC34(GPP_B23/SML1ALERT#/PCHHOT#)
DCIN: C60009.2(B) R60009.2(B) U60000.17
DCPRTC: C4520.1(A) U4555.BP24(DCPRTC)
DDR4_DRAMRST#: C4119.1(A) CN4100.108(RESET#) CN4125.108(RESET#) R4553.2(B) U4555.BU31(DRAM_RESET#)
DDR_PG_CTRL: R1013.1(A) U4555.C35(DDR_VTT_CTL)
DDR_PG_CTRL_R: R1013.2(B) U1000.3
DDR_RCOMP_0: R4518.1(A) U4555.BN28(DDR_RCOMP_0)
DDR_RCOMP_1: R4541.1(A) U4555.BN27(DDR_RCOMP_1)
DDR_RCOMP_2: R4540.1(A) U4555.BN29(DDR_RCOMP_2)
DDR_VTT_PG_CTRL: R1006.1(A) R1021.1(A) R7119.1(A)
DDR_VTT_PG_CTRL_R: R1006.2(B) U1000.4
DDR_WR_C_VREF01: C4124.2(B) R4136.2(B)
DDR_WR_C_VREF02: C4122.2(B) R4111.2(B)
DDR_WR_VREF01: C4124.1(A) R4503.2(B) U4555.F36(DDR_VREF_CA)
DDR_WR_VREF02: C4122.1(A) R4112.2(B) U4555.E36(DDR1_VREF_DQ)
DEV_MODE_DET_EC: R334.1(A) U300.M2(GPIO56/CLKRUN#)
DEVSLP1: CN1951.38(DEVSLP) U4555.CR8(GPP_E5/DEVSLP1)
DG_GPIO_0: R2738.2(B) U2700.W1(GPIO_0)
DG_GPIO_1: R2741.2(B) U2700.W2(GPIO_1)
DG_TMU_CLKIN: R2730.2(B) R2737.2(B) U2700.W6(GPIO_8)
DGPU_HOLD_RST#: TP4521.1 U4555.CK6(GPP_E9/USB2_OC0#/GP_BSSB_CLK)
DGPU_PRSNT#: TP4520.1 U4555.CK5(GPP_E10/USB2_OC1#/GP_BSSB_DI)
DGPU_PWR_EN#: TP4519.1 U4555.CK8(GPP_E11/USB2_OC2#)
DGPU_PWRGD: TP4518.1 U4555.CK9(GPP_E12/USB2_OC3#)
DIS_DPWROK: Q1002.2 Q1002.3 R1017.1(A)
DIS_DPWROK#: Q1002.5 R1015.1(A) R1016.2(B)
DIS_P1V8S: Q7011.D R7038.1(A)
DIS_P3V3A_PRIME: Q7006.D R7001.1(A)
DIS_P3V3S_LCDVDD: R3029.1(A) U3000.4
DIS_P3V3S_TOUCH_VCC: Q3001.6 R3031.1(A)
DIS_P5V0S: Q7005.6 R7014.1(A)
DIS_PVCCSTG: Q7000.6 R7013.1(A)
DIS_PVCCSTG_EN: Q7000.2 Q7000.3 R7010.2(B)
DISP_RCOMP: R4544.2(B) U4555.AM6(DISP_RCOMP)
DMIC_CLK0: CN3001.10 R3012.1(A) R4551.2(B)
DMIC_CLK0_DB: CN9354.5 MIC9350.2 MIC9352.2
DMIC_CLK1: CN3001.1 R3023.1(A) R4513.1(A)
DMIC_DATA0: CN3001.9 R3016.2(B) U3002.4
DMIC_DATA0_DB: CN9354.4 MIC9350.1 MIC9352.1
DMIC_DATA0_PCH: R3016.1(A) R4510.2(B) R4546.2(B) U3002.3
DMIC_DATA0_PP: R3035.2(B) U3002.1
DMIC_DATA1: CN3001.2 R3014.2(B) U3003.4
DMIC_DATA1_PCH: R3014.1(A) R4532.1(A) R4559.2(B) U3003.3
DMIC_DATA1_PP: R3036.2(B) U3003.1
DMIC_MUTE_LED: TP302.1 U300.J10(GPIOB3/I2C7_SCL0/DCD#)
DMIC_R_CLK0: R4551.1(A) U4555.CP24(GPP_D19/DMIC_CLK0/SNDW4_CLK)
DMIC_R_CLK1: R4513.2(B) U4555.CK25(GPP_D17/DMIC_CLK1/SNDW3_CLK)
DMIC_R_DATA0: R4546.1(A) U4555.CN24(GPP_D20/DMIC_DATA0/SNDW4_DATA)
DMIC_R_DATA1: R4532.2(B) U4555.CJ25(GPP_D18/DMIC_DATA1/SNDW3_DATA)
DP_UTIL: TP4500.1 U4555.AM7(DISP_UTILS)
DPB0_TR_C_DN: C2709.1(A) U2700.B5(DPSNK2_ML0*)
DPB0_TR_C_DP: C2708.1(A) U2700.A5(DPSNK2_ML0_P)
DPB0_TR_DN: C2709.2(B) U3300.39(DP_D0N)
DPB0_TR_DP: C2708.2(B) U3300.40(DP_D0P)
DPB1_TR_C_DN: C2711.1(A) U2700.A3(DPSNK2_ML1*)
DPB1_TR_C_DP: C2710.1(A) U2700.B3(DPSNK2_ML1_P)
DPB1_TR_DN: C2711.2(B) U3300.36(DP_D1N)
DPB1_TR_DP: C2710.2(B) U3300.37(DP_D1P)
DPB2_TR_C_DN: C2713.1(A) U2700.C1(DPSNK2_ML2*)
DPB2_TR_C_DP: C2712.1(A) U2700.C2(DPSNK2_ML2_P)
DPB2_TR_DN: C2713.2(B) U3300.33(DP_D2N)
DPB2_TR_DP: C2712.2(B) U3300.34(DP_D2P)
DPB3_TR_C_DN: C2715.1(A) U2700.E1(DPSNK2_ML3*)
DPB3_TR_C_DP: C2714.1(A) U2700.E2(DPSNK2_ML3_P)
DPB3_TR_DN: C2715.2(B) U3300.30(DP_D3N)
DPB3_TR_DP: C2714.2(B) U3300.31(DP_D3P)
DPB_AUX_C_DN: C3304.2(B) U3300.51(IN_AUXN)
DPB_AUX_C_DP: C3305.2(B) U3300.52(IN_AUXP)
DPB_AUX_DN: C3304.1(A) U4555.AC7(DDI1_AUX*)
DPB_AUX_DP: C3305.1(A) U4555.AC6(DDI1_AUX_P)
DPB_DDCCLK: R4786.2(B) U3300.50(IN_DDC_SCL) U4555.CC8(GPP_E18/DPPB_CTRLCLK/CNV_BT_HOST_WAKE#)
DPB_DDCDATA: R4787.2(B) U3300.49(IN_DDC_SDA) U4555.CC9(GPP_E19/DPPB_CTRLDATA)
DPB_DP_CFG0: R3339.1(A) R3355.1(A) U3300.44(DP_CFG0/SCL_CTL)
DPB_DP_CFG1: R3319.1(A) R3320.1(A) U3300.29(DP_CFG1)
DPB_HDMI_CLK_DN: CN3150.12 U3300.15(TMDS_CLKN)
DPB_HDMI_CLK_DP: CN3150.10 U3300.16(TMDS_CLKP)
DPB_HDMI_DDC_CLK: CN3150.15 R3151.1(A) U3300.48(TMDS_SCL)
DPB_HDMI_DDC_DATA: CN3150.16 R3150.1(A) U3300.47(TMDS_SDA)
DPB_HDMI_HPD: CN3150.19 U3300.17(TMDS_HPD)
DPB_HDMI_TX0_DN: CN3150.9 U3300.18(TMDS_CH0N)
DPB_HDMI_TX0_DP: CN3150.7 U3300.19(TMDS_CH0P)
DPB_HDMI_TX1_DN: CN3150.6 U3300.21(TMDS_CH1N)
DPB_HDMI_TX1_DP: CN3150.4 U3300.22(TMDS_CH1P)
DPB_HDMI_TX2_DN: CN3150.3 U3300.24(TMDS_CH2N)
DPB_HDMI_TX2_DP: CN3150.1 U3300.25(TMDS_CH2P)
DPB_HPD: R4758.1(A) U3300.5(IN_HPD) U4555.CN6(GPP_E13/DDPB_HPD0/DISP_MISC0)
DPB_I2C_CTL_EN: R3309.1(A) R3310.1(A) U3300.38(I2C_CTL_EN)
DPB_IN_CA_DET: R3308.1(A) TP3303.1 U3300.11(IN_CA_DET)
DPB_MODE: R3341.1(A) R3342.1(A) U3300.53(MODE)
DPB_PD#: TP3301.1 U3300.46(PD)
DPB_PEQ: R3340.1(A) R3356.1(A) U3300.8(PEQ)
DPB_REXT: R3324.2(B) U3300.27(REXT)
DPB_SW: R3322.1(A) R3323.1(A) U3300.45(SW/SDA_CTL)
DPB_TMDS_DDCBUF: R3300.1(A) R3301.1(A) U3300.2(TMDS_DDCBUF)
DPB_TMDS_PRE: R3311.1(A) R3312.1(A) U3300.20(TMDS_PRE)
DPB_TMDS_RT: R3303.1(A) R3305.1(A) U3300.23(TMDS_RT)
DPB_TR_AUX_C_DN: C2717.1(A) U2700.P2(DPSNK2_AUX*)
DPB_TR_AUX_C_DP: C2716.1(A) U2700.P1(DPSNK2_AUX_P)
DPB_TR_AUX_CN_DN: CN2701.2 R2774.1(A)
DPB_TR_AUX_CN_DP: CN2701.3 R2773.1(A)
DPB_TR_AUX_DN: C2717.2(B) R2774.2(B) R3302.1(A) R3306.2(B) U3300.54(DP_AUXN_SDA)
DPB_TR_AUX_DP: C2716.2(B) R2773.2(B) R3304.1(A) R3307.2(B) U3300.55(DP_AUXP_SCL)
DPB_TR_CA_DET: R3314.1(A) U3300.42(DP_CA_DET)
DPB_TR_HPD: CN2701.1 U2700.Y4(DPSNK2_HPD) U3300.32(DP_HPD)
DPB_TX0_C_DN: C3307.2(B) U3300.4(IN_D0N)
DPB_TX0_C_DP: C3306.2(B) U3300.3(IN_D0P)
DPB_TX0_DN: C3307.1(A) U4555.AL5(DDI1_TXN_0)
DPB_TX0_DP: C3306.1(A) U4555.AL6(DDI1_TXP_0)
DPB_TX1_C_DN: C3309.2(B) U3300.7(IN_D1N)
DPB_TX1_C_DP: C3308.2(B) U3300.6(IN_D1P)
DPB_TX1_DN: C3309.1(A) U4555.AJ5(DDI1_TXN_1)
DPB_TX1_DP: C3308.1(A) U4555.AJ6(DDI1_TXP_1)
DPB_TX2_C_DN: C3311.2(B) U3300.10(IN_D2N)
DPB_TX2_C_DP: C3310.2(B) U3300.9(IN_D2P)
DPB_TX2_DN: C3311.1(A) U4555.AF6(DDI1_TXN_2)
DPB_TX2_DP: C3310.1(A) U4555.AF5(DDI1_TXP_2)
DPB_TX3_C_DN: C3313.2(B) U3300.13(IN_D3N)
DPB_TX3_C_DP: C3312.2(B) U3300.12(IN_D3P)
DPB_TX3_DN: C3313.1(A) U4555.AE5(DDI1_TXN_3)
DPB_TX3_DP: C3312.1(A) U4555.AE6(DDI1_TXP_3)
DPC0_TR_C_DN: C2719.1(A) U2700.AB7(DPSNK1_ML0*)
DPC0_TR_C_DP: C2718.1(A) U2700.AC7(DPSNK1_ML0_P)
DPC1_TR_C_DN: C2721.1(A) U2700.AC9(DPSNK1_ML1*)
DPC1_TR_C_DP: C2720.1(A) U2700.AB9(DPSNK1_ML1_P)
DPC2_TR_C_DN: C2722.1(A) U2700.AB11(DPSNK1_ML2*)
DPC2_TR_C_DP: C2723.1(A) U2700.AC11(DPSNK1_ML2_P)
DPC3_TR_C_DN: C2724.1(A) U2700.AC13(DPSNK1_ML3*)
DPC3_TR_C_DP: C2725.1(A) U2700.AB13(DPSNK1_ML3_P)
DPC_AUX_DN: C2727.2(B) CN2701.5 U4555.AD4(DDI2_AUX*)
DPC_AUX_DP: C2726.2(B) CN2701.6 U4555.AD3(DDI2_AUX_P)
DPC_DDCCLK: R4854.2(B) U4555.CH4(GPP_E20/DPPC_CTRLCLK)
DPC_DDCDATA: R4870.2(B) U4555.CH3(GPP_E21/DPPC_CTRLDATA)
DPC_HPD: CN2701.4 R4759.1(A) U2700.AA2(DPSNK1_HPD) U4555.CM6(GPP_E14/DDPC_HPD1/DISP_MISC1)
DPC_TR_AUX_C_DN: C2727.1(A) U2700.N2(DPSNK1_AUX*)
DPC_TR_AUX_C_DP: C2726.1(A) U2700.N1(DPSNK1_AUX_P)
DPC_TX0_DN: C2719.2(B) U4555.AC4(DDI2_TXN_0)
DPC_TX0_DP: C2718.2(B) U4555.AC3(DDI2_TXP_0)
DPC_TX1_DN: C2721.2(B) U4555.AC1(DDI2_TXN_1)
DPC_TX1_DP: C2720.2(B) U4555.AC2(DDI2_TXP_1)
DPC_TX2_DN: C2722.2(B) U4555.AE4(DDI2_TXN_2)
DPC_TX2_DP: C2723.2(B) U4555.AE3(DDI2_TXP_2)
DPC_TX3_DN: C2724.2(B) U4555.AE1(DDI2_TXN_3)
DPC_TX3_DP: C2725.2(B) U4555.AE2(DDI2_TXP_3)
DPWROK: Q1002.6 R1014.1(A) R4936.1(A) U300.E7(GPIO00) U7000.4
DSW_PWROK: R4936.2(B) R4945.1(A) U4555.BP30(DSW_PWROK)
EC_ADC0: C309.1(A) R443.2(B) U300.F2(GPIO45/ADC0)
EC_ADC1: C320.1(A) R444.2(B) U300.E3(GPIO44/ADC1)
EC_ADC2: C301.1(A) R300.2(B) U300.E2(GPIO43/ADC2)
EC_ADC4: C304.1(A) R302.2(B) U300.C2(GPIO41/ADC4)
EC_AVCC: C313.2(B) C318.2(B) R381.2(B) U300.D1(AVCC)
EC_AVCC_R: R381.1(A) R384.2(B)
EC_CAP: C302.1(A) U300.A6
EC_GPIO57: TP307.1 U300.L3(SER_IRQ/ESPI_ALERT#/GPIO57)
EC_GPIO67: R353.2(B) U300.J3(GPIO67/PS2_CLK0)
EC_GPIOF2: TP303.1 U300.F6(GPIOF2/I2C4_SDA1)
EC_RSMRST_PG: R377.2(B) U300.H9(GPIOC1/I2C6_SDA0)
EC_RTCRST_CTRL: D1000.1(A1) R1019.2(B) U300.J11(GPIOA7/PS2_DAT3/TB2/SHD_DIO3)
EC_VCC: C131.1(A) C303.1(A) C308.1(A) C310.1(A) C314.1(A) C315.1(A) C319.1(A) R379.2(B) U300.A7(VCC1_1) U300.B1(VCC1_2) U300.D12(VCC1_4) U300.M8(VCC1_3)
EC_VHIF: C307.1(A) C317.1(A) R359.2(B) U300.F1(VHIF)
EC_VSPI: C316.1(A) C324.1(A) CN366.8 R344.2(B) R346.2(B) R347.1(A) R355.1(A) U300.H12(VSPI) U366.8
EDP_AUX_C_DN: C3009.2(B) CN3000.26
EDP_AUX_C_DP: C3010.2(B) CN3000.27
EDP_AUX_DN: C3009.1(A) U4555.AH4(EDP_AUX*)
EDP_AUX_DP: C3010.1(A) U4555.AH3(EDP_AUX_P)
EDP_BKLT_EN: R3008.1(A) R3009.1(A) U4555.CK11(EDP_BKLTEN)
EDP_HPD: CN3000.21 R3021.1(A) U4555.CM7(GPP_E17/EDP_HPD/DISP_MISC4)
EDP_PWM_OUT: R430.2(B) R3017.1(A) U4555.CH11(EDP_BKLTCTL)
EDP_PWM_OUT_R: R3017.2(B) U3001.3
EDP_PWM_OUT_RC: C306.2(B) R430.1(A) R432.2(B)
EDP_PWM_R: CN3000.18 R428.2(B) R3004.2(B)
EDP_PWM_R_OUT: R3004.1(A) U3001.4
EDP_TX0_C_R_DN: C3012.2(B) CN3000.30 L7503.1(IN+) L7503.2(OUT+)
EDP_TX0_C_R_DP: C3011.2(B) CN3000.29 L7503.3(OUT-) L7503.4(IN-)
EDP_TX0_DN: C3012.1(A) U4555.AG4(EDP_TXN_0)
EDP_TX0_DP: C3011.1(A) U4555.AG3(EDP_TXP_0)
EDP_TX1_C_R_DN: C3014.2(B) CN3000.33 L7502.1(IN+) L7502.2(OUT+)
EDP_TX1_C_R_DP: C3013.2(B) CN3000.32 L7502.3(OUT-) L7502.4(IN-)
EDP_TX1_DN: C3014.1(A) U4555.AG2(EDP_TXN_1)
EDP_TX1_DP: C3013.1(A) U4555.AG1(EDP_TXP_1)
EDP_TX2_C_R_DN: C3016.2(B) CN3000.36 L7501.1(IN+) L7501.2(OUT+)
EDP_TX2_C_R_DP: C3015.2(B) CN3000.35 L7501.3(OUT-) L7501.4(IN-)
EDP_TX2_DN: C3016.1(A) U4555.AJ4(EDP_TXN_2)
EDP_TX2_DP: C3015.1(A) U4555.AJ3(EDP_TXP_2)
EDP_TX3_C_R_DN: C3018.2(B) CN3000.39 L7500.1(IN+) L7500.2(OUT+)
EDP_TX3_C_R_DP: C3017.2(B) CN3000.38 L7500.3(OUT-) L7500.4(IN-)
EDP_TX3_DN: C3018.1(A) U4555.AJ2(EDP_TXN_3)
EDP_TX3_DP: C3017.1(A) U4555.AJ1(EDP_TXP_3)
EDP_VDD_EN: R3003.1(A) U3000.3 U4555.CG11(EDP_VDDEN)
EMMC_CLK: R3801.2(B) R3803.1(A) U4555.CP16(GPP_F21/EMMC_CLK)
EMMC_CLK_IC: R3803.2(B) U3800.M6
EMMC_CMD: R3802.1(A) R3823.1(A) U4555.CR16(GPP_F11/EMMC_CMD)
EMMC_CMD_IC: R3802.2(B) U3800.M5
EMMC_DATA_0: R3800.1(A) R3804.1(A) U4555.CR20(GPP_F12/EMMC_DATA0)
EMMC_DATA_0_IC: R3804.2(B) U3800.A3
EMMC_DATA_1: R3805.1(A) R3814.1(A) U4555.CM20(GPP_F13/EMMC_DATA1)
EMMC_DATA_1_IC: R3805.2(B) U3800.A4
EMMC_DATA_2: R3806.1(A) R3815.1(A) U4555.CN19(GPP_F14/EMMC_DATA2)
EMMC_DATA_2_IC: R3806.2(B) U3800.A5
EMMC_DATA_3: R3807.1(A) R3816.1(A) U4555.CM19(GPP_F15/EMMC_DATA3)
EMMC_DATA_3_IC: R3807.2(B) U3800.B2
EMMC_DATA_4: R3808.1(A) R3817.1(A) U4555.CN18(GPP_F16/EMMC_DATA4)
EMMC_DATA_4_IC: R3808.2(B) U3800.B3
EMMC_DATA_5: R3809.1(A) R3818.1(A) U4555.CR18(GPP_F17/EMMC_DATA5)
EMMC_DATA_5_IC: R3809.2(B) U3800.B4
EMMC_DATA_6: R3810.1(A) R3819.1(A) U4555.CP18(GPP_F18/EMMC_DATA6)
EMMC_DATA_6_IC: R3810.2(B) U3800.B5
EMMC_DATA_7: R3811.1(A) R3820.1(A) U4555.CM18(GPP_F19/EMMC_DATA7)
EMMC_DATA_7_IC: R3811.2(B) U3800.B6
EMMC_PLT_RST#: Q3800.6 R3826.2(B) U3800.K5
EMMC_PRSNT#: R4620.2(B) R4621.2(B) U4555.CM27(GPP_H19/TIMESYNC_0)
EMMC_RCLK: R3813.2(B) R3822.1(A) U4555.CM16(GPP_F20/EMMC_RCLK)
EMMC_RCLK_IC: R3822.2(B) U3800.H5
EMMC_RCOMP: R4812.1(A) U4555.CK15(EMMC_RCOMP)
EN_1V5: R7124.2(B) TP61701.1 U61700.1
EN_1V05A: R7026.2(B) R60903.2(B) TP60901.1 U60900.9(EN)
EN_1V8: R4800.2(B) TP60601.1 U60600.9(EN)
EN_2V5: R1002.2(B) TP60410.1 U1000.8 U60400.1
EN_3V: R7112.2(B) R60110.2(B) TP60101.1 U60100.11
EN_5V: R7113.2(B) R60204.1(A) R60254.1(A) R60255.2(B) TP60204.1 TP60251.1 U60250.12
EN_5V_3V: R1000.1(A) R1005.2(B) R7112.1(A) R7113.1(A) U4413.3(OT)
EN_EMMC_PLT_RST#: Q3800.2 Q3800.3 R3825.2(B)
EN_PVCORE: R66000.1(A)
EN_USB5V: R60202.1(A) R60206.1(A) TP60202.1 U300.K11(GPIOA5/A20M/PVT_CS1#)
EN_VCC_PRIM: R7025.2(B) R61421.1(A) TP61401.1 U61400.5
EN_VCCIO: R4821.2(B) R60523.1(A) TP60501.1 U60500.5
EN_VDDQ: R1003.2(B) TP60301.1 U1000.10 U60300.15
EN_VTT: R7119.2(B) TP60351.1 U60300.16
ESDIO_RCOMP: R4819.1(A) U4555.CK33(SD_1P8_RCOMP) U4555.CM34(SD_3P3_RCOMP)
ESIM_CLK: C7505.1(A) CN1400.44(GNSS2) U1400.D1
ESIM_DATA: C7506.1(A) CN1400.42(GNSS1) R1401.1(A) U1400.C3
ESIM_PWR: C1402.1(A) C1409.1(A) CN1400.48(GNSS4) R1401.2(B) U1400.A1
ESIM_RST: C7507.1(A) CN1400.46(GNSS3) U1400.D2
ESPI_0: R4846.1(A) U4555.CA29(GPP_A1/LAD0/ESPI_IO0)
ESPI_1: R4847.1(A) U4555.BY29(GPP_A2/LAD1/ESPI_IO1)
ESPI_2: R4848.1(A) U4555.BY27(GPP_A3/LAD2/ESPI_IO2)
ESPI_3: R4849.1(A) U4555.BV27(GPP_A4/LAD3/ESPI_IO3)
ESPI_ALERT#: CN375.4 R417.2(B)
ESPI_CLK: R4850.1(A) U4555.BV32(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
ESPI_FLASH_SHARING: R4536.2(B) U4555.CM26(GPP_H23)
ESPI_LPC#: R2703.1(A) R4702.2(B) U4555.CG15(GPP_C5/SML0ALERT#)
EXT_MIC_JACK: CN2500.26 R511.2(B) TP2516.1 U500.31(SLEEVE)
EXT_MIC_JACK_DB: CN9202.5 R9217.2(B)
EXT_MIC_JACK_R_DB: C9226.1(A) D9204.1 JACK9200.4 R9217.1(A)
EXT_PWR_GATE#: R4623.2(B) U4555.CC37(GPP_B11/EXT_PWR_GATE#)
EXT_SMI#: R4809.2(B) U300.J4(GPIO70/PS2_DAT0) U4555.CP6(GPP_E16/DPPE_HPD3/DISP_MISC3)
FAN1_PWM: C7530.1(A) Q4300.2 R333.2(B)
FAN1_PWM_EC: R333.1(A) U300.G8(GPIOC4/PWM2_TACH2PWM_OUT)
FAN1_PWM_Q: Q4300.6 R4302.1(A) R4303.1(A)
FAN1_PWM_Q_R: CN4300.4 D4301.1 R4302.2(B) TP4303.1
FAN2_PWM_EC: TP308.1 U300.G9(GPIOC3/PWM0)
FN_KEY_LED#: R366.1(A) R389.1(A) U300.A10(GPIOD5/JTAG_TCK1_SWCLK1)
FN_KEY_LED#_R: CN300.11 R366.2(B)
FPR_LID_SW#_3: CN2200.1 Q307.6 R400.1(A) R407.2(B)
FPR_LOCK#: CN2200.3 R2200.1(A) U4555.CN14(GPP_C10/UART0_RTS#)
FPR_OFF#: CN2200.2 R4533.2(B) R4650.2(B) U4555.CC36(GPP_B2/VRALERT#)
FPR_PWR: C2200.1(A) C2201.1(A) CN2200.7 CN2200.8 F2200.2(B)
FRONT_L_SEL_DB: MIC9350.3 R9350.2(B)
FRONT_R_SEL_DB: MIC9352.3 R9352.2(B)
GC6_FB_EN: TP4526.1 U4555.CN3(GPP_E7/CPU_GP1)
GPD7: R4554.2(B) U4555.BV35(GPD7)
GPIO63: TP309.1 U300.J2(GPIO63/PS2_DAT1)
GPIOC7: R378.1(A) U300.F10(GPIOC7/DTR#_BOUT)
GPP_A7: R4539.2(B) U4555.CC32(GPP_A7/PIRQA#/GSPI0_CS1#)
GPP_A8: R4537.2(B) U4555.BY30(GPP_A8/CLKRUN#)
GPP_A20: R4629.2(B) U4555.CA37(GPP_A20/ISH_GP2)
GPP_A21: R4628.2(B) U4555.CA36(GPP_A21/ISH_GP3)
GPP_A22: R4707.2(B) U4555.CA35(GPP_A22/ISH_GP4)
GPP_A23: R4549.2(B) U4555.CA34(GPP_A23/ISH_GP5)
GPP_D12: R4703.2(B) U4555.CP22(GPP_D12/ISH_SPI_MOSI/GSPI2_MOSI)
GPP_F22: R4538.1(A) R4811.1(A) U4555.CN16(GPP_F22/EMMC_RESET#)
GPP_F23: R4555.2(B) U4555.CF17(GPP_F23/A4WP_PRESENT)
GPP_H0: TP4508.1 U4555.CH32(GPP_H0/I2S2_SCLK/CNV_BT_I2S_SCLK)
GPP_H8: R4542.2(B) U4555.CJ30(GPP_H8/I2C4_SDA)
GPP_H9: R4543.2(B) U4555.CJ31(GPP_H9/I2C4_SCL)
GPS_XMIT_OFF#: CN1400.26(AUDIO_3) R4708.2(B) U4555.CM24(GPP_D13/ISH_UART0_RXD)
GPU_THRM_DMINUS: C4412.2(B) Q4412.2(E) U4411.3
GPU_THRM_DPLUS: C4412.1(A) Q4412.1(B) Q4412.3(C) U4411.2
H_BPM0_XDP#: CN4920.21(OBSFN_B0) U4555.U1(BPM#_0)
H_BPM1_XDP#: CN4920.23(OBSFN_B1) U4555.U2(BPM#_1)
H_PECI: R328.2(B) R4606.2(B) U4555.AR1(PECI)
H_PECI_R: R328.1(A) U300.M7(PECI_DATA/GPIO81)
H_PRDY#: CN4920.5(OBSFN_A1) U4555.W1(PROC_PRDY#)
H_PREQ#: CN4920.3(OBSFN_A0) R4933.2(B) U4555.W2(PROC_PREQ#)
H_PWRGD: R4527.1(A) U4555.AR2(PROCPWRGD)
H_TCK: CN4920.57(TCK0) R4500.1(A) R4509.1(A) U4555.T6(PROC_TCK)
H_TDI: R4508.1(A) R4615.2(B) U4555.U6(PROC_TDI)
H_TDO: R4612.2(B) R4920.1(A) U4555.Y5(PROC_TDO)
H_TMS: R4507.1(A) R4614.1(A) U4555.T5(PROC_TMS)
H_TRST#: R4526.1(A) R4613.1(A) U4555.AB6(PROC_TRST#) U4555.Y6(PCH_TRST#)
HDA_BCLK: C7625.1(A) R4910.1(A) U500.14(BCLK)
HDA_BCLK_PCH: R4910.2(B) U4555.BN37(HDA_BCLK/I2S0_SCLK)
HDA_RST#: R4901.1(A)
HDA_RST#_PCH: R4901.2(B) U4555.BL35(HDA_RST#/I2S1_SCLK/SNDW1_CLK)
HDA_SDI0: R504.2(B) U4555.BN35(HDA_SDI0/I2S0_RXD)
HDA_SDI0_R: R504.1(A) U500.16(SDATA_IN)
HDA_SDO: Q4754.3(D) Q4756.D U4555.BN36(HDA_SDO/I2S0_TXD)
HDA_SDO_Q: Q4756.S R4869.2(B)
HDA_SDO_R: R4869.1(A) U500.17(SDATA_OUT)
HDA_SYNC: R4903.1(A) U500.15(SYNC)
HDA_SYNC_PCH: R4903.2(B) U4555.BN34(HDA_SYNC/I2S0_SFRM)
HP_OUT_L1: CN2500.24 TP2515.1 U500.27(HP-OUT-L)
HP_OUT_L1_DB: CN9202.7 R9230.1(A)
HP_OUT_R1: CN2500.25 TP2517.1 U500.26(HP-OUT-R)
HP_OUT_R1_DB: CN9202.6 R9231.1(A)
HP_OUT_R_L1_DB: R9200.1(A) R9230.2(B)
HP_OUT_R_R1_DB: R9201.1(A) R9231.2(B)
HP_OUT_R_R_L1_DB: C9228.1(A) JACK9200.1 R9200.2(B)
HP_OUT_R_R_R1_DB: C9227.1(A) JACK9200.2 R9201.2(B)
HP_VERF_L: R511.1(A) U500.28(MIC2-VREFO-L)
HP_VERF_R: TP508.1 U500.29(MIC2-VREFO-R)
HPOUT_DET: CN2500.27 R503.2(B) TP2518.1
HPOUT_DET_DB: CN9202.4 JACK9200.6
I2C_ALS_SMCLK: CN3001.18 R4591.2(B) U4555.CJ22(GPP_D8/ISH_I2C1_SCL)
I2C_ALS_SMDATA: CN3001.19 R4590.2(B) U4555.CH22(GPP_D7/ISH_I2C1_SDA)
I2C_TOUCH_CLK: Q3005.3 R3010.2(B) U4555.CJ12(GPP_C19/I2C1_SCL)
I2C_TOUCH_DAT: Q3005.6 R3013.2(B) U4555.CK12(GPP_C18/I2C1_SDA)
I2C_TOUCH_Q_CLK: CN3000.11 Q3005.4 R4928.2(B)
I2C_TOUCH_Q_DAT: CN3000.10 Q3005.1 R4927.2(B)
I_SET: Q68051.3(C) R60094.2(B)
ILIM_HI: R2500.2(B) U2501.16
ILIM_LO: R2501.1(A) U2501.15
ILIM_SEL: R2427.1(A) R2502.1(A) R2503.2(B) U300.A12(GPIOE5/JTAG_TMS1_SWIO1) U2501.4
ILIM_SEL_PD: R2427.2(B) U2403.H10
IMVP_PSYS: R443.1(A) R60022.1(A) R66195.1(A) U60000.30
INPUT3VSEL: R4579.2(B) R4582.1(A) U4555.BT27(INPUT3VSEL)
INTRUDER#: R1008.2(B) R1011.1(A) SW1001.1 SW1001.2 SW1002.1 SW1002.2
INTRUDER#_PCH: C1002.1(A) Q1004.G R1009.1(A) R1011.2(B) SW1001.3 SW1001.4 SW1002.3 SW1002.4 U4555.BR35(INTRUDER#)
IOT_I2C_EC_INT#: R354.1(A) R1409.2(B) U300.D5(GPIO33/I2C5_SCL0/CTS#)
IOT_I2C_EC_SCL: R391.1(A) R1407.2(B) U300.J8(GPIO85/I2C4_SCL0/RXD)
IOT_I2C_EC_SDA: R394.1(A) R1402.2(B) U300.J9
IOT_I2C_WWAN_INT#: CN1400.28(UIM-RFU) R1409.1(A)
IOT_I2C_WWAN_SCL: CN1400.20(AUDIO_0) R1407.1(A)
IOT_I2C_WWAN_SDA: CN1400.24(AUDIO_2) R1402.1(A)
ISH_ACCEL_INT1#: R4714.2(B) U4555.BW35(GPP_A18/ISH_GP0)
ISH_ACCEL_INT2#: R4715.2(B) U4555.BW34(GPP_A19/ISH_GP1)
ISH_ALS_INT#: CN3001.17 R4950.2(B) U4555.BW37(GPP_A12/ISH_GP6/BM_BUSY#/SX_EXIT_HOLDOFF#)
ISH_I2C0_SCL: R4557.2(B) U4555.CH20(GPP_D6/ISH_I2C0_SCL)
ISH_I2C0_SDA: R4556.2(B) U4555.CK22(GPP_D5/ISH_I2C0_SDA)
JD1: R501.1(A) R503.1(A) U500.48(JD1)
JD2: TP509.1 U500.47(JD2)
JTAGK_TCK: R4500.2(B) U4555.P6(PCH_JTAGX)
KB_PIN3: CN300.3 TP300.1
KB_PIN14: CN300.14 TP305.1
KB_PIN15: CN300.15 TP304.1
KBC_PWR_ON: Q7003.5 R326.1(A) R4800.1(A) R7018.1(A) R7024.1(A) U300.G7(GPIOD2)
KBL_DET#: CN301.3 R4729.2(B) U4555.CB34(GPP_B3/CPU_GP2)
KSCAN_3S_IN<0>: CN300.34 D302.1
KSCAN_3S_IN<1>: CN300.31 D302.5
KSCAN_3S_IN<2>: CN300.32 D304.1
KSCAN_3S_IN<3>: CN300.30 D304.5
KSCAN_3S_IN<4>: CN300.33 D303.1
KSCAN_3S_IN<5>: CN300.22 D303.5
KSCAN_3S_IN<6>: CN300.21 D301.2(A2)
KSCAN_3S_IN<8>: CN300.37 D302.2
KSCAN_3S_IN<9>: CN300.17 D302.4
KSCAN_3S_IN<10>: CN300.35 D304.2
KSCAN_3S_IN<11>: CN300.18 D304.4
KSCAN_3S_IN<12>: CN300.36 D303.2
KSCAN_3S_IN<13>: CN300.19 D303.4
KSCAN_3S_IN<14>: CN300.38 D301.1(A1)
LAN_DISABLE#: TP4505.1 U4555.BU34(GPD11/LANPHYPC)
LAN_WAKE#: R4717.2(B) U4555.BU32(GPD2/LAN_WAKE#)
LANLINK_STATUS: R4734.2(B) U4555.CG20(GPP_D0/SPI1_CS0#/BK0/SBK0)
LED_3S_SATA#: R4816.2(B) U4555.CN7(GPP_E8/SATALED#/SPI1_CS1#)
LED_PWRSTBY: Q305.2 Q305.3 R403.2(B)
LED_PWRSTBY#: Q305.5 R303.1(A) R361.1(A) R404.1(A) U302.6(Y1)
LED_PWRSTBY#_CNTR: Q305.6 R371.1(A) R404.2(B)
LED_PWRSTBY#_CNTR_R: CN300.1 R371.2(B)
LED_WWAN_LINK#: CN1400.10(LED1#/DAS/DSS#)
LFRAM#_ESPI_CS#: R308.1(A) U300.L2(LFRAME#/ESPI_CS#/GPIO53) U4555.CA28(GPP_A5/LFRAME#/ESPI_CS#)
LFRAM#_ESPI_CS#_R: CN375.6 R308.2(B)
LID_SW#_3: CN2500.29 D3001.3(C) Q307.5 Q1003.G R129.1(A) TP2521.1 U300.H4(GPIO65)
LID_SW#_3_DB: CN9202.2 D9206.1 U9204.OUTPUT
LID_SW_3: Q307.2 Q307.3 R445.2(B)
LIMIT_SIGNAL: CN6000.4 D6035.2 R68068.1(A) TP6001.1
LOW_PWR_VTG_SHIFT: R60524.2(B)
LOW_PWR_VTG_SHIFT_N: R60525.2(B) R61424.2(B)
LP#: R7155.2(B) R61422.2(B) U61400.6
LPC_ESPI_<0>: R319.1(A) R4846.2(B) U300.H1(LAD0/ESPI_IO0/GPIO46)
LPC_ESPI_<1>: R323.1(A) R4847.2(B) U300.J1(LAD1/ESPI_IO1/GPIO47)
LPC_ESPI_<2>: R340.1(A) R4848.2(B) U300.K1(LAD2/ESPI_IO2/GPIO51)
LPC_ESPI_<3>: R358.1(A) R4849.2(B) U300.L1(LAD3/ESPI_IO3/GPIO52)
LPC_ESPI_CLK: CN375.11 R4850.2(B) U300.M1(PCI_CLK/ESPI_CLK/GPIO55)
LPC_ESPI_R_<0>: CN375.10 R319.2(B)
LPC_ESPI_R_<1>: CN375.9 R323.2(B)
LPC_ESPI_R_<2>: CN375.8 R340.2(B)
LPC_ESPI_R_<3>: CN375.7 R358.2(B)
LPC_ESPI_RESET#: CN375.12 R4806.1(A) U300.K3(LRESET#/ESPI_RST#/GPIO54) U4555.CA27(GPP_A14/SUS_STAT#/ESPI_RESET#)
M_A_A_0: CN4100.144(A0) U4555.AC37(DDR0_CAB_9/DDR0_MA_0)
M_A_A_1: CN4100.133(A1) U4555.AC36(DDR0_CAB_8/DDR0_MA_1)
M_A_A_2: CN4100.132(A2) U4555.AC34(DDR0_CAB_5/DDR0_MA_2)
M_A_A_3: CN4100.131(A3) U4555.AC35(NC/DDR0_MA_3)
M_A_A_4: CN4100.128(A4) U4555.AA35(NC/DDR0_MA_4)
M_A_A_5: CN4100.126(A5) U4555.AB35(DDR0_CAA_0/DDR0_MA_5)
M_A_A_6: CN4100.127(A6) U4555.AA37(DDR0_CAA_2/DDR0_MA_6)
M_A_A_7: CN4100.122(A7) U4555.AA36(DDR0_CAA_4/DDR0_MA_7)
M_A_A_8: CN4100.125(A8) U4555.AB34(DDR0_CAA_3/DDR0_MA_8)
M_A_A_9: CN4100.121(A9) U4555.W36(DDR0_CAA_1/DDR0_MA_9)
M_A_A_10: CN4100.146(A10/AP) U4555.Y31(DDR0_CAB_7/DDR0_MA_10)
M_A_A_11: CN4100.120(A11) U4555.W34(DDR0_CAA_7/DDR0_MA_11)
M_A_A_12: CN4100.119(A12) U4555.AA34(DDR0_CAA_6/DDR0_MA_12)
M_A_A_13: CN4100.158(A13) U4555.AC32(DDR0_CAB_0/DDR0_MA_13)
M_A_A_14: CN4100.151(A14/WE#) U4555.AC31(DDR0_CAB_2/DDR0_MA_14)
M_A_A_15: CN4100.156(A15/CAS#) U4555.AB32(DDR0_CAB_1/DDR0_MA_15)
M_A_A_16: CN4100.152(A16/RAS#) U4555.Y32(DDR0_CAB_3/DDR0_MA_16)
M_A_ACT#: CN4100.114(ACT#) U4555.V35(DDR0_CAA_8/DDR0_ACT#)
M_A_ALERT#: CN4100.116(ALERT#) U4555.W37(NC/DDR0_ALERT#)
M_A_BG0: CN4100.115(BG0) U4555.V34(DDR0_CAA_5/DDR0_BG_0)
M_A_BG1: CN4100.113(BG1) U4555.W35(DDR0_CAA_9/DDR0_BG_1)
M_A_BS0: CN4100.150(BA0) U4555.W32(DDR0_CAB_4/DDR0_BA_0)
M_A_BS1: CN4100.145(BA1) U4555.AB31(DDR0_CAB_6/DDR0_BA_1)
M_A_DQ<0>: CN4100.8(DQ_0) U4555.A26(DDR0_DQ_0/DDR0_DQ_0)
M_A_DQ<1>: CN4100.16(DQ_6) U4555.D26(DDR0_DQ_1/DDR0_DQ_1)
M_A_DQ<2>: CN4100.4(DQ_4) U4555.D28(DDR0_DQ_2/DDR0_DQ_2)
M_A_DQ<3>: CN4100.21(DQ_3) U4555.C28(DDR0_DQ_3/DDR0_DQ_3)
M_A_DQ<4>: CN4100.3(DQ_5) U4555.B26(DDR0_DQ_4/DDR0_DQ_4)
M_A_DQ<5>: CN4100.7(DQ_1) U4555.C26(DDR0_DQ_5/DDR0_DQ_5)
M_A_DQ<6>: CN4100.20(DQ_2) U4555.B28(DDR0_DQ_6/DDR0_DQ_6)
M_A_DQ<7>: CN4100.17(DQ_7) U4555.A28(DDR0_DQ_7/DDR0_DQ_7)
M_A_DQ<8>: CN4100.29(DQ_9) U4555.B30(DDR0_DQ_8/DDR0_DQ_8)
M_A_DQ<9>: CN4100.24(DQ_12) U4555.D30(DDR0_DQ_9/DDR0_DQ_9)
M_A_DQ<10>: CN4100.38(DQ_14) U4555.B33(DDR0_DQ_10/DDR0_DQ_10)
M_A_DQ<11>: CN4100.42(DQ_11) U4555.D32(DDR0_DQ_11/DDR0_DQ_11)
M_A_DQ<12>: CN4100.28(DQ_8) U4555.A30(DDR0_DQ_12/DDR0_DQ_12)
M_A_DQ<13>: CN4100.25(DQ_13) U4555.C30(DDR0_DQ_13/DDR0_DQ_13)
M_A_DQ<14>: CN4100.41(DQ_10) U4555.B32(DDR0_DQ_14/DDR0_DQ_14)
M_A_DQ<15>: CN4100.37(DQ_15) U4555.C32(DDR0_DQ_15/DDR0_DQ_15)
M_A_DQ<16>: CN4100.195(DQ_40) U4555.J22(DDR1_DQ_0/DDR0_DQ_16)
M_A_DQ<17>: CN4100.204(DQ_47) U4555.H25(DDR1_DQ_1/DDR0_DQ_17)
M_A_DQ<18>: CN4100.194(DQ_41) U4555.G22(DDR1_DQ_2/DDR0_DQ_18)
M_A_DQ<19>: CN4100.191(DQ_44) U4555.H22(DDR1_DQ_3/DDR0_DQ_19)
M_A_DQ<20>: CN4100.203(DQ_46) U4555.F25(DDR1_DQ_4/DDR0_DQ_20)
M_A_DQ<21>: CN4100.207(DQ_42) U4555.J25(DDR1_DQ_5/DDR0_DQ_21)
M_A_DQ<22>: CN4100.208(DQ_43) U4555.G25(DDR1_DQ_6/DDR0_DQ_22)
M_A_DQ<23>: CN4100.190(DQ_45) U4555.F22(DDR1_DQ_7/DDR0_DQ_23)
M_A_DQ<24>: CN4100.170(DQ_36) U4555.D22(DDR1_DQ_8/DDR0_DQ_24)
M_A_DQ<25>: CN4100.173(DQ_33) U4555.C22(DDR1_DQ_9/DDR0_DQ_25)
M_A_DQ<26>: CN4100.186(DQ_35) U4555.C24(DDR1_DQ_10/DDR0_DQ_26)
M_A_DQ<27>: CN4100.187(DQ_34) U4555.D24(DDR1_DQ_11/DDR0_DQ_27)
M_A_DQ<28>: CN4100.174(DQ_32) U4555.A22(DDR1_DQ_12/DDR0_DQ_28)
M_A_DQ<29>: CN4100.169(DQ_37) U4555.B22(DDR1_DQ_13/DDR0_DQ_29)
M_A_DQ<30>: CN4100.183(DQ_38) U4555.A24(DDR1_DQ_14/DDR0_DQ_30)
M_A_DQ<31>: CN4100.182(DQ_39) U4555.B24(DDR1_DQ_15/DDR0_DQ_31)
M_A_DQ<32>: CN4100.46(DQ_20) U4555.H37(DDR0_DQ_16/DDR0_DQ_32)
M_A_DQ<33>: CN4100.45(DQ_21) U4555.H34(DDR0_DQ_17/DDR0_DQ_33)
M_A_DQ<34>: CN4100.58(DQ_22) U4555.K34(DDR0_DQ_18/DDR0_DQ_34)
M_A_DQ<35>: CN4100.62(DQ_18) U4555.K35(DDR0_DQ_19/DDR0_DQ_35)
M_A_DQ<36>: CN4100.49(DQ_17) U4555.H36(DDR0_DQ_20/DDR0_DQ_36)
M_A_DQ<37>: CN4100.50(DQ_16) U4555.H35(DDR0_DQ_21/DDR0_DQ_37)
M_A_DQ<38>: CN4100.63(DQ_19) U4555.K36(DDR0_DQ_22/DDR0_DQ_38)
M_A_DQ<39>: CN4100.59(DQ_23) U4555.K37(DDR0_DQ_23/DDR0_DQ_39)
M_A_DQ<40>: CN4100.67(DQ_29) U4555.N36(DDR0_DQ_24/DDR0_DQ_40)
M_A_DQ<41>: CN4100.66(DQ_28) U4555.N34(DDR0_DQ_25/DDR0_DQ_41)
M_A_DQ<42>: CN4100.79(DQ_30) U4555.R37(DDR0_DQ_26/DDR0_DQ_42)
M_A_DQ<43>: CN4100.83(DQ_26) U4555.R34(DDR0_DQ_27/DDR0_DQ_43)
M_A_DQ<44>: CN4100.70(DQ_24) U4555.N37(DDR0_DQ_28/DDR0_DQ_44)
M_A_DQ<45>: CN4100.71(DQ_25) U4555.N35(DDR0_DQ_29/DDR0_DQ_45)
M_A_DQ<46>: CN4100.80(DQ_31) U4555.R36(DDR0_DQ_30/DDR0_DQ_46)
M_A_DQ<47>: CN4100.84(DQ_27) U4555.R35(DDR0_DQ_31/DDR0_DQ_47)
M_A_DQ<48>: CN4100.211(DQ_52) U4555.G31(DDR1_DQ_16/DDR0_DQ_48)
M_A_DQ<49>: CN4100.216(DQ_48) U4555.G32(DDR1_DQ_17/DDR0_DQ_49)
M_A_DQ<50>: CN4100.229(DQ_51) U4555.H29(DDR1_DQ_18/DDR0_DQ_50)
M_A_DQ<51>: CN4100.225(DQ_55) U4555.H28(DDR1_DQ_19/DDR0_DQ_51)
M_A_DQ<52>: CN4100.212(DQ_53) U4555.G28(DDR1_DQ_20/DDR0_DQ_52)
M_A_DQ<53>: CN4100.215(DQ_49) U4555.G29(DDR1_DQ_21/DDR0_DQ_53)
M_A_DQ<54>: CN4100.224(DQ_54) U4555.H31(DDR1_DQ_22/DDR0_DQ_54)
M_A_DQ<55>: CN4100.228(DQ_50) U4555.H32(DDR1_DQ_23/DDR0_DQ_55)
M_A_DQ<56>: CN4100.236(DQ_57) U4555.L31(DDR1_DQ_24/DDR0_DQ_56)
M_A_DQ<57>: CN4100.232(DQ_60) U4555.L32(DDR1_DQ_25/DDR0_DQ_57)
M_A_DQ<58>: CN4100.245(DQ_62) U4555.N29(DDR1_DQ_26/DDR0_DQ_58)
M_A_DQ<59>: CN4100.250(DQ_59) U4555.N28(DDR1_DQ_27/DDR0_DQ_59)
M_A_DQ<60>: CN4100.233(DQ_61) U4555.L28(DDR1_DQ_28/DDR0_DQ_60)
M_A_DQ<61>: CN4100.237(DQ_56) U4555.L29(DDR1_DQ_29/DDR0_DQ_61)
M_A_DQ<62>: CN4100.249(DQ_58) U4555.N31(DDR1_DQ_30/DDR0_DQ_62)
M_A_DQ<63>: CN4100.246(DQ_63) U4555.N32(DDR1_DQ_31/DDR0_DQ_63)
M_A_DQS0_DN: CN4100.11(DQS0_C) U4555.C27(DDR0_DQSN_0/DDR0_DQSN_0)
M_A_DQS0_DP: CN4100.13(DQS0_T) U4555.D27(DDR0_DQSP_0/DDR0_DQSP_0)
M_A_DQS1_DN: CN4100.32(DQS1_C) U4555.D31(DDR0_DQSN_1/DDR0_DQSN_1)
M_A_DQS1_DP: CN4100.34(DQS1_T) U4555.C31(DDR0_DQSP_1/DDR0_DQSP_1)
M_A_DQS2_DN: CN4100.198(DQS5_C) U4555.H24(DDR1_DQSN_0/DDR0_DQSN_2)
M_A_DQS2_DP: CN4100.200(DQS5_T) U4555.G24(DDR1_DQSP_0/DDR0_DQSP_2)
M_A_DQS3_DN: CN4100.177(DQS4_C) U4555.C23(DDR1_DQSN_1/DDR0_DQSN_3)
M_A_DQS3_DP: CN4100.179(DQS4_T) U4555.D23(DDR1_DQSP_1/DDR0_DQSP_3)
M_A_DQS4_DN: CN4100.53(DQS2_C) U4555.J35(DDR0_DQSN_2/DDR0_DQSN_4)
M_A_DQS4_DP: CN4100.55(DQS2_T) U4555.J34(DDR0_DQSP_2/DDR0_DQSP_4)
M_A_DQS5_DN: CN4100.74(DQS3_C) U4555.P34(DDR0_DQSN_3/DDR0_DQSN_5)
M_A_DQS5_DP: CN4100.76(DQS3_T) U4555.P35(DDR0_DQSP_3/DDR0_DQSP_5)
M_A_DQS6_DN: CN4100.219(DQS6_C) U4555.G30(DDR1_DQSN_2/DDR0_DQSN_6)
M_A_DQS6_DP: CN4100.221(DQS6_T) U4555.H30(DDR1_DQSP_2/DDR0_DQSP_6)
M_A_DQS7_DN: CN4100.240(DQS7_C) U4555.L30(DDR1_DQSN_3/DDR0_DQSN_7)
M_A_DQS7_DP: CN4100.242(DQS7_T) U4555.N30(DDR1_DQSP_3/DDR0_DQSP_7)
M_A_PAR: CN4100.143(PARITY) U4555.W31(NC/DDR0_PAR)
M_B_A_0: CN4125.144(A0) U4555.AG36(DDR1_CAB_9/DDR1_MA_0)
M_B_A_1: CN4125.133(A1) U4555.AG35(DDR1_CAB_8/DDR1_MA_1)
M_B_A_2: CN4125.132(A2) U4555.AF34(DDR1_CAB_5/DDR1_MA_2)
M_B_A_3: CN4125.131(A3) U4555.AG37(NC/DDR1_MA_3)
M_B_A_4: CN4125.128(A4) U4555.AE35(NC/DDR1_MA_4)
M_B_A_5: CN4125.126(A5) U4555.AF35(DDR1_CAA_0/DDR1_MA_5)
M_B_A_6: CN4125.127(A6) U4555.AE37(DDR1_CAA_2/DDR1_MA_6)
M_B_A_7: CN4125.122(A7) U4555.AC29(DDR1_CAA_4/DDR1_MA_7)
M_B_A_8: CN4125.125(A8) U4555.AE36(DDR1_CAA_3/DDR1_MA_8)
M_B_A_9: CN4125.121(A9) U4555.AB29(DDR1_CAA_1/DDR1_MA_9)
M_B_A_10: CN4125.146(A10/AP) U4555.AG34(DDR1_CAB_7/DDR1_MA_10)
M_B_A_11: CN4125.120(A11) U4555.AC28(DDR1_CAA_7/DDR1_MA_11)
M_B_A_12: CN4125.119(A12) U4555.AB28(DDR1_CAA_6/DDR1_MA_12)
M_B_A_13: CN4125.158(A13) U4555.AK35(DDR1_CAB_0/DDR1_MA_13)
M_B_A_14: CN4125.151(A14/WE#) U4555.AJ35(DDR1_CAB_2/DDR1_MA_14)
M_B_A_15: CN4125.156(A15/CAS#) U4555.AK34(DDR1_CAB_1/DDR1_MA_15)
M_B_A_16: CN4125.152(A16/RAS#) U4555.AJ34(DDR1_CAB_3/DDR1_MA_16)
M_B_ACT#: CN4125.114(ACT#) U4555.W28(DDR1_CAA_8/DDR1_ACT#)
M_B_ALERT#: CN4125.116(ALERT#) U4555.Y29(NC/DDR1_ALERT#)
M_B_BG0: CN4125.115(BG0) U4555.W29(DDR1_CAA_5/DDR1_BG_0)
M_B_BG1: CN4125.113(BG1) U4555.Y28(DDR1_CAA_9/DDR1_BG_1)
M_B_BS0: CN4125.150(BA0) U4555.AJ37(DDR1_CAB_4/DDR1_BA_0)
M_B_BS1: CN4125.145(BA1) U4555.AJ36(DDR1_CAB_6/DDR1_BA_1)
M_B_DQ<0>: CN4125.8(DQ_0) U4555.AN35(DDR0_DQ_32/DDR1_DQ_0)
M_B_DQ<1>: CN4125.7(DQ_1) U4555.AN34(DDR0_DQ_33/DDR1_DQ_1)
M_B_DQ<2>: CN4125.20(DQ_2) U4555.AR35(DDR0_DQ_34/DDR1_DQ_2)
M_B_DQ<3>: CN4125.16(DQ_6) U4555.AR34(DDR0_DQ_35/DDR1_DQ_3)
M_B_DQ<4>: CN4125.3(DQ_5) U4555.AN37(DDR0_DQ_36/DDR1_DQ_4)
M_B_DQ<5>: CN4125.4(DQ_4) U4555.AN36(DDR0_DQ_37/DDR1_DQ_5)
M_B_DQ<6>: CN4125.21(DQ_3) U4555.AR36(DDR0_DQ_38/DDR1_DQ_6)
M_B_DQ<7>: CN4125.17(DQ_7) U4555.AR37(DDR0_DQ_39/DDR1_DQ_7)
M_B_DQ<8>: CN4125.29(DQ_9) U4555.AU35(DDR0_DQ_40/DDR1_DQ_8)
M_B_DQ<9>: CN4125.28(DQ_8) U4555.AU34(DDR0_DQ_41/DDR1_DQ_9)
M_B_DQ<10>: CN4125.38(DQ_14) U4555.AW35(DDR0_DQ_42/DDR1_DQ_10)
M_B_DQ<11>: CN4125.25(DQ_13) U4555.AW34(DDR0_DQ_43/DDR1_DQ_11)
M_B_DQ<12>: CN4125.41(DQ_10) U4555.AU37(DDR0_DQ_44/DDR1_DQ_12)
M_B_DQ<13>: CN4125.24(DQ_12) U4555.AU36(DDR0_DQ_45/DDR1_DQ_13)
M_B_DQ<14>: CN4125.42(DQ_11) U4555.AW36(DDR0_DQ_46/DDR1_DQ_14)
M_B_DQ<15>: CN4125.37(DQ_15) U4555.AW37(DDR0_DQ_47/DDR1_DQ_15)
M_B_DQ<16>: CN4125.174(DQ_32) U4555.AJ29(DDR1_DQ_32/DDR1_DQ_16)
M_B_DQ<17>: CN4125.173(DQ_33) U4555.AJ30(DDR1_DQ_33/DDR1_DQ_17)
M_B_DQ<18>: CN4125.182(DQ_39) U4555.AM32(DDR1_DQ_34/DDR1_DQ_18)
M_B_DQ<19>: CN4125.186(DQ_35) U4555.AM31(DDR1_DQ_35/DDR1_DQ_19)
M_B_DQ<20>: CN4125.183(DQ_38) U4555.AM30(DDR1_DQ_36/DDR1_DQ_20)
M_B_DQ<21>: CN4125.187(DQ_34) U4555.AM29(DDR1_DQ_37/DDR1_DQ_21)
M_B_DQ<22>: CN4125.170(DQ_36) U4555.AJ31(DDR1_DQ_38/DDR1_DQ_22)
M_B_DQ<23>: CN4125.169(DQ_37) U4555.AJ32(DDR1_DQ_39/DDR1_DQ_23)
M_B_DQ<24>: CN4125.194(DQ_41) U4555.AR31(DDR1_DQ_40/DDR1_DQ_24)
M_B_DQ<25>: CN4125.190(DQ_45) U4555.AR32(DDR1_DQ_41/DDR1_DQ_25)
M_B_DQ<26>: CN4125.207(DQ_42) U4555.AV30(DDR1_DQ_42/DDR1_DQ_26)
M_B_DQ<27>: CN4125.203(DQ_46) U4555.AV29(DDR1_DQ_43/DDR1_DQ_27)
M_B_DQ<28>: CN4125.191(DQ_44) U4555.AR30(DDR1_DQ_44/DDR1_DQ_28)
M_B_DQ<29>: CN4125.195(DQ_40) U4555.AR29(DDR1_DQ_45/DDR1_DQ_29)
M_B_DQ<30>: CN4125.204(DQ_47) U4555.AV32(DDR1_DQ_46/DDR1_DQ_30)
M_B_DQ<31>: CN4125.208(DQ_43) U4555.AV31(DDR1_DQ_47/DDR1_DQ_31)
M_B_DQ<32>: CN4125.45(DQ_21) U4555.BA35(DDR0_DQ_48/DDR1_DQ_32)
M_B_DQ<33>: CN4125.46(DQ_20) U4555.BA34(DDR0_DQ_49/DDR1_DQ_33)
M_B_DQ<34>: CN4125.62(DQ_18) U4555.BC35(DDR0_DQ_50/DDR1_DQ_34)
M_B_DQ<35>: CN4125.58(DQ_22) U4555.BC34(DDR0_DQ_51/DDR1_DQ_35)
M_B_DQ<36>: CN4125.49(DQ_17) U4555.BA37(DDR0_DQ_52/DDR1_DQ_36)
M_B_DQ<37>: CN4125.50(DQ_16) U4555.BA36(DDR0_DQ_53/DDR1_DQ_37)
M_B_DQ<38>: CN4125.63(DQ_19) U4555.BC36(DDR0_DQ_54/DDR1_DQ_38)
M_B_DQ<39>: CN4125.59(DQ_23) U4555.BC37(DDR0_DQ_55/DDR1_DQ_39)
M_B_DQ<40>: CN4125.83(DQ_26) U4555.BE35(DDR0_DQ_56/DDR1_DQ_40)
M_B_DQ<41>: CN4125.66(DQ_28) U4555.BE34(DDR0_DQ_57/DDR1_DQ_41)
M_B_DQ<42>: CN4125.80(DQ_31) U4555.BG35(DDR0_DQ_58/DDR1_DQ_42)
M_B_DQ<43>: CN4125.84(DQ_27) U4555.BG34(DDR0_DQ_59/DDR1_DQ_43)
M_B_DQ<44>: CN4125.79(DQ_30) U4555.BE37(DDR0_DQ_60/DDR1_DQ_44)
M_B_DQ<45>: CN4125.71(DQ_25) U4555.BE36(DDR0_DQ_61/DDR1_DQ_45)
M_B_DQ<46>: CN4125.67(DQ_29) U4555.BG36(DDR0_DQ_62/DDR1_DQ_46)
M_B_DQ<47>: CN4125.70(DQ_24) U4555.BG37(DDR0_DQ_63/DDR1_DQ_47)
M_B_DQ<48>: CN4125.215(DQ_49) U4555.BA32(DDR1_DQ_48/DDR1_DQ_48)
M_B_DQ<49>: CN4125.212(DQ_53) U4555.BA31(DDR1_DQ_49/DDR1_DQ_49)
M_B_DQ<50>: CN4125.225(DQ_55) U4555.BD31(DDR1_DQ_50/DDR1_DQ_50)
M_B_DQ<51>: CN4125.229(DQ_51) U4555.BD32(DDR1_DQ_51/DDR1_DQ_51)
M_B_DQ<52>: CN4125.211(DQ_52) U4555.BA30(DDR1_DQ_52/DDR1_DQ_52)
M_B_DQ<53>: CN4125.216(DQ_48) U4555.BA29(DDR1_DQ_53/DDR1_DQ_53)
M_B_DQ<54>: CN4125.224(DQ_54) U4555.BD29(DDR1_DQ_54/DDR1_DQ_54)
M_B_DQ<55>: CN4125.228(DQ_50) U4555.BD30(DDR1_DQ_55/DDR1_DQ_55)
M_B_DQ<56>: CN4125.236(DQ_57) U4555.BG31(DDR1_DQ_56/DDR1_DQ_56)
M_B_DQ<57>: CN4125.237(DQ_56) U4555.BG32(DDR1_DQ_57/DDR1_DQ_57)
M_B_DQ<58>: CN4125.250(DQ_59) U4555.BK32(DDR1_DQ_58/DDR1_DQ_58)
M_B_DQ<59>: CN4125.246(DQ_63) U4555.BK31(DDR1_DQ_59/DDR1_DQ_59)
M_B_DQ<60>: CN4125.233(DQ_61) U4555.BG29(DDR1_DQ_60/DDR1_DQ_60)
M_B_DQ<61>: CN4125.232(DQ_60) U4555.BG30(DDR1_DQ_61/DDR1_DQ_61)
M_B_DQ<62>: CN4125.245(DQ_62) U4555.BK30(DDR1_DQ_62/DDR1_DQ_62)
M_B_DQ<63>: CN4125.249(DQ_58) U4555.BK29(DDR1_DQ_63/DDR1_DQ_63)
M_B_DQS0_DN: CN4125.11(DQS0_C) U4555.AP35(DDR0_DQSN_4/DDR1_DQSN_0)
M_B_DQS0_DP: CN4125.13(DQS0_T) U4555.AP34(DDR0_DQSP_4/DDR1_DQSP_0)
M_B_DQS1_DN: CN4125.32(DQS1_C) U4555.AV34(DDR0_DQSN_5/DDR1_DQSN_1)
M_B_DQS1_DP: CN4125.34(DQS1_T) U4555.AV35(DDR0_DQSP_5/DDR1_DQSP_1)
M_B_DQS2_DN: CN4125.177(DQS4_C) U4555.AL31(DDR1_DQSN_4/DDR1_DQSN_2)
M_B_DQS2_DP: CN4125.179(DQS4_T) U4555.AL30(DDR1_DQSP_4/DDR1_DQSP_2)
M_B_DQS3_DN: CN4125.198(DQS5_C) U4555.AU31(DDR1_DQSN_5/DDR1_DQSN_3)
M_B_DQS3_DP: CN4125.200(DQS5_T) U4555.AU30(DDR1_DQSP_5/DDR1_DQSP_3)
M_B_DQS4_DN: CN4125.53(DQS2_C) U4555.BB35(DDR0_DQSN_6/DDR1_DQSN_4)
M_B_DQS4_DP: CN4125.55(DQS2_T) U4555.BB34(DDR0_DQSP_6/DDR1_DQSP_4)
M_B_DQS5_DN: CN4125.74(DQS3_C) U4555.BF34(DDR0_DQSN_7/DDR1_DQSN_5)
M_B_DQS5_DP: CN4125.76(DQS3_T) U4555.BF35(DDR0_DQSP_7/DDR1_DQSP_5)
M_B_DQS6_DN: CN4125.219(DQS6_C) U4555.BC31(DDR1_DQSN_6/DDR1_DQSN_6)
M_B_DQS6_DP: CN4125.221(DQS6_T) U4555.BC30(DDR1_DQSP_6/DDR1_DQSP_6)
M_B_DQS7_DN: CN4125.240(DQS7_C) U4555.BH31(DDR1_DQSN_7/DDR1_DQSN_7)
M_B_DQS7_DP: CN4125.242(DQS7_T) U4555.BH30(DDR1_DQSP_7/DDR1_DQSP_7)
M_B_PAR: CN4125.143(PARITY) U4555.AE34(NC/DDR1_PAR)
M_CKE0: CN4100.109(CKE0) U4555.U36(DDR0_CKE_0/DDR0_CKE_0)
M_CKE1: CN4100.110(CKE1) U4555.U37(DDR0_CKE_1/DDR0_CKE_1)
M_CKE2: CN4125.109(CKE0) U4555.T28(DDR1_CKE_0/DDR1_CKE_0)
M_CKE3: CN4125.110(CKE1) U4555.T29(DDR1_CKE_1/DDR1_CKE_1)
M_CLK_DDR0_DN: CN4100.139(CK0_C) U4555.V32(DDR0_CKN_0/DDR0_CKN_0)
M_CLK_DDR0_DP: CN4100.137(CK0_T) U4555.V31(DDR0_CKP_0/DDR0_CKP_0)
M_CLK_DDR1_DN: CN4100.140(CK1_C) U4555.T32(DDR0_CKN_1/DDR0_CKN_1)
M_CLK_DDR1_DP: CN4100.138(CK1_T) U4555.T31(DDR0_CKP_1/DDR0_CKP_1)
M_CLK_DDR2_DN: CN4125.139(CK0_C) U4555.AF28(DDR1_CKN_0/DDR1_CKN_0)
M_CLK_DDR2_DP: CN4125.137(CK0_T) U4555.AF29(DDR1_CKP_0/DDR1_CKP_0)
M_CLK_DDR3_DN: CN4125.140(CK1_C) U4555.AE28(DDR1_CKN_1/DDR1_CKN_1)
M_CLK_DDR3_DP: CN4125.138(CK1_T) U4555.AE29(DDR1_CKP_1/DDR1_CKP_1)
M_CS#0: CN4100.149(CS0#) U4555.AE32(DDR0_CS#_0/DDR0_CS#_0)
M_CS#1: CN4100.157(CS1#) U4555.AF32(DDR0_CS#_1/DDR0_CS#_1)
M_CS#2: CN4125.149(CS0#) U4555.AL37(DDR1_CS#_0/DDR1_CS#_0)
M_CS#3: CN4125.157(CS1#) U4555.AL35(DDR1_CS#_1/DDR1_CS#_1)
M_ODT0: CN4100.155(ODT0) U4555.AE31(DDR0_ODT_0/DDR0_ODT_0)
M_ODT1: CN4100.161(ODT1) U4555.AF31(NC/DDR0_ODT_1)
M_ODT2: CN4125.155(ODT0) U4555.AL36(DDR1_ODT_0/DDR1_ODT_0)
M_ODT3: CN4125.161(ODT1) U4555.AL34(NC/DDR1_ODT_1)
MAIN_BAT_DET#: R374.1(A) R406.1(A) R6052.1(A) R60012.1(A)
MAIN_BAT_DET#_BAT: C7503.2(B) CN6050.6 D7500.2 R6052.2(B) TP6054.1
MAIN_BAT_DET#_EC: R374.2(B) U300.E11
ME_UNLOCK#: Q4755.1(G) R317.1(A) U300.G4(GPIO64)
MIC_PRIVA_EN: U300.K10(GPIOB2/I2C7_SDA0/DSR#) U3002.6 U3003.6
MSATA_DET: Q1951.D R1952.1(A) U4555.CM10(GPP_E1/SATAXPCIE1/SATAGP1)
NFC_3V3: CN4350.2 CN4350.3 CN4350.15 R4350.2(B) R4352.2(B)
NFC_3V3_R: CN4350.10 R4350.1(A)
NFC_CLICK_3S_SMCLK: CN303.7 CN4350.8 R4355.1(A) U4555.CN11(GPP_C17/I2C0_SCL)
NFC_CLICK_3S_SMDATA: CN303.6 CN4350.9 R4354.1(A) U4555.CM11(GPP_C16/I2C0_SDA)
NFC_DETECT#: CN4350.1 R4353.1(A) U4555.CN26(GPP_H22)
NFC_DWL_REQ_PCH: CN4350.5 R4769.2(B) R4774.2(B) U4555.CC27(GPP_B15/GSPI0_CS0#)
NFC_INT: CN4350.11 R4724.2(B) U4555.CM8(GPP_E6/DEVSLP2)
NFC_RST#: CN4350.6 R4619.2(B) U4555.CC30(GPP_B21/GSPI1_MISO)
NGATE: U60000.3
NMI_SMI_DBG#: CN375.5 Q302.S R4765.2(B) U4555.CC29(GPP_B20/GSPI1_CLK)
NUM_LOCK_LED#: CN375.15 R320.1(A) U300.D7(KSO15/GPIO83)
OCP_CHG#: R68055.1(A) U60000.23
OCP_ID_ADC2: R300.1(A) R68004.1(A) R68009.2(B)
OCP_ID_SEL: Q68098.G R68099.1(A) U300.K9(GPIO91/I2C2_SDA0)
