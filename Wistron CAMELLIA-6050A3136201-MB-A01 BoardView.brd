# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDDQ_PG: length 176.4
  L5 w0.102: v1(220.75,42.33) 221.15,41.92 221.15,33.59 221.15,33.59 221.15,33.42 226.01,28.56 230.45,28.56 230.96,28.05 233.31,28.05 238.89,22.47 238.89,22.21 242.8,18.3 242.8,17.46 242.8,14.02 242.62,13.84 242.62,11.01 240.05,8.45 240.05,5.71 239.47,5.12 239.47,4.61 v1(239.42,4.56)
  L6 w0.102: v1(220.75,42.33) 220.19,42.89 220.19,46.77 220.19,47.17 216.94,50.42 216.94,51.24 215.52,52.66 215.52,54.95 214.89,55.57 214.89,58.49 215.19,58.79 215.19,66 215.19,66.33 211.33,70.19 209.43,70.19 208.85,69.61 208.16,69.61 207.92,69.85 207.92,71.03 v1(207.87,71.08) ; v2(159.55,3.89) 159.66,3.78 160.08,3.78 160.5,3.36 168.08,3.36 171.06,6.34 175.7,6.34 177.07,7.71 202.83,7.71 205.85,4.69 215.11,4.69 215.84,3.97 219.06,3.97 220.16,5.08 227.22,5.08 227.29,5.15 229.6,5.15 230.06,4.69 235.56,4.69 235.74,4.51 237.39,4.51 237.8,4.93 238.14,4.93 238.5,4.56 v1(239.42,4.56)
  BOTTOM w0.102: R7416.1 207.97,71.18 v1(207.87,71.08) ; v2(159.55,3.89) 159.44,3.78 159.25,3.78 159.01,4.01 U60300.12
VSSSENSE: length 92.8
  TOP w0.13: v1(155.83,74.67) 155.83,74.95 154.96,75.82 R4598.1 ; v2(98.83,106.62) 98.83,106.55 98.41,106.13 98.41,105.91 R66831.2
  L3 w0.076: 148.06,75.25 148.06,72.61 148.33,72.33 155.02,72.33 155.33,72.63 155.33,74.17 v1(155.83,74.67)
  L3 w0.097: v2(98.83,106.62) 99.23,106.21 99.23,95.57 100.28,94.52 100.28,93 100.66,92.62 103.95,92.62 105.68,90.89 109.35,90.89 109.86,91.4 121.1,91.4 123.09,89.4 140.74,89.4 140.88,89.55 142.38,89.55 142.71,89.87 144.53,89.87 147.67,86.73 147.67,86.41 147.67,76.48 147.98,76.17 147.98,75.32 148.06,75.25
  BOTTOM w0.13: U4555.AN5 155.6,74.57 v1(155.83,74.67)
1ALS_HUB_INT#_DB: length 6.4
  TOP w0.102: CN9302.4 79.36,79.03 v1(79.68,79.35) ; v1(76.63,80.1) 76.63,80.16 76.4,80.39 76.4,80.67 75.87,81.2 U9302.3
  L3 w0.102: v1(76.63,80.1) 78.93,80.1 v1(79.68,79.35)
1ALS_HUB_SMCLK_DB: length 7.6
  TOP w0.13: U9302.5 v1(74.14,80.6) ; CN9302.3 78.86,79.06 79.02,79.22 v1(79.02,79.35)
  L3 w0.097: v1(79.02,79.35) 78.62,78.94 76.61,78.94 74.95,80.6 v1(74.14,80.6)
1ALS_HUB_SMDATA_DB: length 4.9
  TOP w0.13: v1(76.63,79.49) 76.21,79.91 76.21,80.28 75.89,80.6 U9302.2 ; v1(78.36,79.35) CN9302.2
  L3 w0.097: v1(76.63,79.49) 76.89,79.75 77.96,79.75 v1(78.36,79.35)
8051_RX_CAPS_LED#: length 125.1
  TOP w0.076: 241.17,50.36 241.27,50.25 241.27,49.87 241.41,49.73 241.41,49.3 241.67,49.04 R324.1 241.94,48.83 241.94,48.11 241.53,47.69 v1(241.53,46.65) ; v1(238.23,43.24) U300.J7
  TOP w0.102: v1(243.94,10.4) 244.09,10.25 249.56,10.25 v1(250.16,10.86) ; v1(237.61,56.35) 237,55.74 237,53.72 238.22,52.5 238.22,51.76 238.46,51.53 239.6,51.53 239.8,51.32 240.2,51.32 241.17,50.36
  L3 w0.076: 238.83,47.31 238.6,47.08 238.6,46.81 238.02,46.23 238.02,45.84 238.62,45.25 238.62,43.63 v1(238.23,43.24)
  L3 w0.102: v1(241.53,46.65) 240.09,46.65 239.36,47.38 238.9,47.38 238.83,47.31
  L5 w0.102: v1(250.16,10.86) 249.54,11.48 249.54,13.37 249.54,13.56 250.3,14.33 252.7,14.33 253.77,15.4 253.77,19.09 257.93,23.25 257.93,29.1 255.38,31.65 251.72,31.65 251.13,32.25 251.13,32.75 251.38,33 251.48,33.11 253.42,33.11 256.12,35.8 257.39,35.8 257.76,36.17 v1(257.76,36.49)
  L6 w0.076: v1(238.23,43.24) 238.58,43.59 239.02,43.59 239.23,43.39 239.23,42.44 238.58,41.79 238.58,41.14 235.61,38.17
  L6 w0.102: v1(243.94,10.4) 244,10.47 244,10.55 244.34,10.9 244.34,11.23 244,11.57 244,19.55 244.95,20.5 244.95,20.67 244.95,23.7 244.28,24.38 244.11,24.38 240.36,24.38 239.26,25.47 239.26,28.34 239.47,28.54 239.47,29.81 238.71,30.58 238.71,32.18 237.9,32.98 236.62,32.98 235.22,34.38 232.85,34.38 232.1,35.13 232.1,35.3 232.1,35.8 232.91,36.62 234.55,36.62 235.4,37.46 235.4,37.96 235.61,38.17
  BOTTOM w0.102: v3(256.79,33.54) 256.97,33.72 256.97,34.98 256.8,35.15 CN375.14 256.8,36.06 257.23,36.49 v1(257.76,36.49) ; v1(237.61,56.35) 239.8,54.16 R360.2 239.8,53.34 U302.3
8051_TX_LED_PWRSTBY#: length 128.3
  TOP w0.076: U300.H8 237.9,42.27 237.58,42.59 v1(237.58,42.59)
  TOP w0.102: v1(243.94,11.06) 244.34,11.47 v3(247.57,11.47) 250.21,11.47 v1(250.82,10.86)
  L5 w0.102: v1(250.82,10.86) 249.74,11.94 249.74,13.48 250.38,14.12 252.78,14.12 253.97,15.31 253.97,19 258.14,23.17 258.14,29.18 255.46,31.85 251.81,31.85 251.33,32.33 251.33,32.67 251.57,32.91 253.51,32.91 256.2,35.6 257.48,35.6 v1(258.37,36.49)
  L6 w0.102: 235.91,41.57 235.91,38.83 235.2,38.12 235.2,37.55 234.47,36.82 233,36.82 233,36.82 232.83,36.82 231.9,35.89 231.9,35.38 231.9,35.05 232.77,34.18 235.14,34.18 236.56,32.75 237.12,32.75 237.89,31.98 237.89,31.1 239.26,29.73 239.26,28.62 239.06,28.42 239.06,25.56 239.06,25.39 240.28,24.17 244.19,24.17 244.75,23.61 244.75,20.58 243.8,19.63 243.8,11.2 v1(243.94,11.06) ; 235.91,41.57 235.91,43.39 236.77,44.26 239.14,44.26 240.15,45.27 240.15,46.94 238.12,48.98 238.12,48.98 237.88,49.21 237.88,49.22 235.93,51.17 235.93,53.65 237,54.73 237,56.32 237.45,56.76 237.78,56.76 238.63,55.91 v1(238.63,51.93) ; 235.91,41.57 235.91,41.57 236.56,41.57 v1(237.58,42.59)
  BOTTOM w0.102: v1(258.37,36.49) 257.96,36.9 257.14,36.9 256.3,36.06 CN375.13 ; R361.2 240.75,50.84 240.18,50.84 240.07,50.73 240.07,50.68 R322.1 239.46,50.51 238.63,51.34 v1(238.63,51.93) 239.04,52.34 239.38,52.34 239.57,52.15 239.91,51.81 U302.1
A_LINEINL: length 11.6
  TOP w0.254: TP506.1 11.5,45.36 11.18,45.04 v1(11.19,45.04) ; U500.36 19.81,43.35 v1(19.33,43.83)
  L5 w0.254: v1(11.19,45.04) 11.85,45.71 14.7,45.71 15.05,45.37 15.05,44.59 15.8,43.83 v1(19.33,43.83)
A_LINEINR: length 2.7
  TOP w0.254: U500.35 20.25,43.85 20.23,43.87 20.23,43.87 20.09,44.01 20.09,44.01 19.81,44.29 19.81,45.09 TP505.1
A_SD#: length 236.7
  TOP w0.076: U300.L8 238.23,44.55 238.23,45.01 238.38,45.15 v1(238.38,45.99) 238.38,46.8 236.97,48.21 236.97,49.08 R396.1
  TOP w0.102: v1(47.75,27.01) 47.75,27.06 47.19,27.62 43.9,27.62 41.08,30.44 34.27,30.44 28.9,35.81 R502.1
  L3 w0.102: v2(96.97,32.87) 96.37,32.87 82.69,19.19 80.37,19.19 80.18,19 76.13,19 76.13,19 75.9,19 75.63,19 73.52,19 69.06,23.46 54.29,23.46 54.11,23.64 52.98,23.64 51.82,24.8 49.24,24.8 47.75,26.3 v1(47.75,27.01)
  BOTTOM w0.076: 232.51,45.07 232.97,45.07 233.66,44.39 235.05,44.39 235.65,44.99 237.77,44.99 238.38,45.59 v1(238.38,45.99)
  BOTTOM w0.102: v2(96.97,32.87) 97.82,33.72 103.56,33.72 105.66,31.62 156.18,31.62 157.73,33.16 185.57,33.16 190.58,38.17 209.21,38.17 209.79,38.76 210.03,38.76 214.79,43.52 223.6,43.52 223.86,43.78 224.8,43.78 224.88,43.7 229.46,43.7 230.83,45.07 232.51,45.07
ABMON: length 113.1
  TOP w0.102: R60011.2 193.4,98.4 C60027.1 193.96,97.04 v3(194.97,97.04) 195,97.04 195.12,96.92 196.61,96.92 197.15,97.46 197.15,97.88 v1(196.75,98.29) ; v1(243.94,33.9) 244.92,33.9 245.43,34.4 R444.1
  L3 w0.102: v1(196.75,98.29) 196.75,98.69 196.92,98.87 199.73,98.87 200.7,99.84 204.35,99.84 205.16,100.65 212.11,100.65 212.38,100.39 213.61,100.39 214.46,99.53 214.46,98.27 215.63,97.11 216.62,97.11 220.5,93.22 v1(222.91,93.22)
  L5 w0.102: v1(222.91,93.22) 223.52,92.62 223.52,91.69 226.92,88.29 226.92,83.5 229.69,80.74 229.69,78.76 231.09,77.37 231.09,73.17 231.91,72.34 231.91,65.95 231.77,65.81 231.77,61.05 231.92,60.89 231.92,60.71 233.24,59.4 237.66,59.4 245.69,51.37 245.69,47.75 245.87,47.57 245.87,46.08 245.52,45.73 245.48,45.73 244.34,44.59 244.34,41.44 242.88,39.98 242.88,38.75 243.56,38.07 243.56,38.05 244.34,37.27 244.34,35.43 243.94,35.03 v1(243.94,33.9)
ADDRP: length 7.9
  TOP w0.102: v3(95.77,89.09) 95.77,90.62 95.67,90.73 R66112.1 95.45,90.86 R66111.2 95.45,92.04 95.73,92.32 95.73,92.37 96.22,92.85 96.22,93.97 96.82,94.58 97.39,95.15 U66000.25
ADP_DET: length 135.4
  TOP w0.076: U300.M5 239.85,45.28 240.2,45.63 240.2,46.35 240,46.55 240,47.22 239.66,47.55 239.66,47.98 239.51,48.14 239.51,49.12 239.39,49.23 239.39,50.25 239.41,50.27 239.41,50.36
  TOP w0.102: R60021.2 189.34,104.84 v1(189.66,105.16) 189.72,105.16 190.23,105.66 U60000.24 ; R60002.1 178.04,110.64 178.84,109.83 D60097.1 178.97,109.06 v3(179.27,108.75) 179.37,108.75 180.26,107.86 180.26,107.16 181.52,105.91 182.28,105.91 183.12,105.07 183.99,105.07 v1(184.1,105.17) ; 239.41,50.36 239.41,50.65 238.95,51.12 238.29,51.12 237.82,51.6 237.82,52.33 236.6,53.55 236.6,54.93 235.17,56.36 v1(234.68,56.36)
  L5 w0.102: v1(234.68,56.36) 234.18,56.86 229.81,56.86 228.93,57.74 228.93,58.6 228.62,58.92 226.21,58.92 221.71,63.41 221.71,65.02 220.34,66.39 220.34,66.73 220.58,66.97 220.96,66.97 221.54,67.55 221.73,67.55 222.53,68.35 222.53,69.19 221.21,70.51 221.21,75.65 223.82,78.27 223.82,78.84 224.28,79.3 224.48,79.5 224.48,82.11 224.28,82.31 224.28,85.36 224,85.64 223.15,85.64 219.71,89.08 219.71,94.89 221.18,96.37 221.18,97.75 220.82,98.11 220.11,98.11 219.5,98.72 217.34,100.88 217.34,102.73 217.73,103.11 217.73,105.9 217.8,105.97 217.8,108.91 216.61,110.1 214.48,110.1 214.17,110.41 v1(214.17,110.99)
  L6 w0.102: v1(184.1,105.17) 184.1,105.64 184.49,106.03 187.12,106.03 188,105.16 189.66,105.16 v1(189.66,105.16) 189.66,105.16 194.06,105.16 194.86,105.96 196.32,105.96 199.37,109.01 204.52,109.01 206.64,111.13 213.45,111.13 213.59,110.99 v1(214.17,110.99)
ADP_PRES_OUT: length 126.7
  TOP w0.076: v1(241.48,42.59) U300.H3
  TOP w0.102: v1(233.24,24.65) 233.01,24.42 220.95,24.42 218.59,26.78 218.59,33 212.57,39.02 190.21,39.02 189.84,39.39 179.1,39.39 176.6,41.88 v3(176.6,42.15) 176.68,42.23 R4743.2 176.63,42.87 176.35,43.14 176.35,43.59 176.7,43.94 176.7,45.79 v1(177.06,46.15)
  L6 w0.076: 241.83,42.24 v1(241.48,42.59)
  L6 w0.102: 241.83,42.24 241.85,42.22 241.85,38.95 240.87,37.97 237.68,37.97 235.91,36.21 233.08,36.21 232.51,35.63 232.51,35.3 233.02,34.79 235.39,34.79 236.79,33.39 238.94,33.39 240.08,32.26 240.08,31.16 239.72,30.81 239.72,27.12 240.52,26.31 v1(240.52,25.6)
  BOTTOM w0.076: v1(177.06,46.15) 177.67,46.75 177.67,48.29 177.57,48.39 176.41,48.39 175.34,49.46 175.11,49.46 174.24,50.33 173.47,50.33 171.85,51.95 171.14,51.95 169.92,53.17 169.92,53.54 169.89,53.99 169.64,54.33 169.64,54.68 169.72,54.83 169.74,55.01 169.81,55.57 169.81,55.58 U4555.BU35
  BOTTOM w0.102: v1(240.52,25.6) 240.12,26.01 239.54,26.01 238.18,24.65 v1(233.24,24.65)
ALS_DETECT#: length 81.9
  L3 w0.102: v1(199.01,76.75) 197.39,78.36 196.82,78.36 196.61,78.58 186.44,78.58 183.29,75.42 v1(181.58,75.42)
  L5 w0.102: v1(198.47,105.78) 199.26,104.99 199.26,100.99 199.89,100.35 199.89,99.07 199.39,98.56 199.39,84.73 199.01,84.35 v1(199.01,76.75)
  BOTTOM w0.076: CN3001.20 223.67,107.25 ; v1(181.58,75.42) 181.2,75.81 180.81,75.81 180.7,75.7 180.21,75.7 179.76,75.25 U4555.CP4
  BOTTOM w0.102: v1(199.01,76.75) 199.42,76.34 R4782.2 ; v1(198.47,105.78) 202.59,105.78 205.26,103.12 205.67,103.12 209.89,103.12 211.99,105.21 218.77,105.21 220.8,107.25 223.67,107.25
ALS_HUB_INT#_DB: length 11.3
  TOP w0.102: v1(79.63,108.94) 79.8,108.77 U9300.3 ; v1(78.48,101.66) 77.65,100.84 77.65,100.28 77.39,100.02 CN9300.4
  L3 w0.102: v1(79.63,108.94) 79,108.3 79,106.15 78.31,105.46 78.31,104.6 78.44,104.47 78.44,101.7 v1(78.48,101.66)
ALS_HUB_SMCLK_DB: length 11.8
  TOP w0.13: v1(78.72,109.32) 78.95,109.32 79.2,109.57 U9300.5 ; v1(78.01,103.86) 77.3,103.86 76.33,102.89 76.33,100.76 76.57,100.52 CN9300.3
  L3 w0.097: v1(78.01,103.86) 78.01,105.59 78.72,106.3 v1(78.72,109.32)
ALS_HUB_SMDATA_DB: length 8.9
  TOP w0.13: v1(77.75,101.67) 77.75,101.34 77.43,101.02 CN9300.2 ; v1(78.19,107.14) 78.92,107.14 79.2,107.42 U9300.2
  L3 w0.097: v1(78.19,107.14) 78.19,106.12 77.58,105.51 77.58,102.89 77.75,102.72 v1(77.75,101.67)
ALS_LOW_LIGHT_EC: length 70.9
  TOP w0.076: U300.D3 241.48,39.33 241.48,38.87 241.67,38.68 241.93,38.68 242.13,38.48 242.13,38.23 242.34,38.03 242.58,38.03 242.86,37.76 242.86,36.63 243.28,36.21 v1(243.94,36.21)
  TOP w0.102: v2(202.61,46.84) 202.2,46.43 201.78,46.43 201.52,46.7 201.52,48.42 201.41,48.52 R4622.2
  L3 w0.076: 243.38,35.32 243.38,35.65 243.53,35.8 v1(243.94,36.21)
  L3 w0.102: v1(239.91,25.6) 239.91,27.84 240.46,28.39 241.73,28.39 242.85,29.52 242.85,34.79 243.38,35.32 ; v1(235.38,23.68) 233.16,23.68 232.59,24.25 231.09,25.75 231.09,27 228.37,29.73 228.37,30.29 225.84,32.81 225.84,33.24 224.93,34.15 224.44,34.15 221.61,36.98 220.38,36.98 213.45,43.91 213.34,43.91 212.78,44.46 212.35,44.46 211.69,45.12 211.35,45.12 209.63,46.84 v2(202.61,46.84)
  BOTTOM w0.102: v1(235.38,23.68) 237.99,23.68 v1(239.91,25.6)
ALS_LOW_LIGHT_PCH: length 37.3
  TOP w0.102: v2(200.96,46.84) 201.06,46.95 R4622.1 200.7,47.67 200.43,47.94 R4603.1
  L3 w0.076: 172.01,53.9 171.92,53.99 v1(171.78,53.99)
  L3 w0.102: v2(200.96,46.84) 200.55,47.25 197.03,47.25 195.13,45.35 179.92,45.35 178.5,46.77 178.5,47.59 178.01,48.08 177.81,48.08 172.27,53.62 172.27,53.63 172.01,53.9
  BOTTOM w0.076: U4555.BW36 171.64,54.64 171.64,54.13 v1(171.78,53.99)
ALS_PL_INT#_DB: length 15.1
  TOP w0.102: CN9301.4 v1(78.36,94.34) ; U9301.3 79.8,104.73 v1(79.62,104.91)
  L6 w0.102: v1(78.36,94.34) 78.36,96.78 77.21,97.93 77.21,101.7 77.81,102.31 79.07,102.31 79.71,102.94 79.71,104.82 v1(79.62,104.91)
ALS_PL_SMCLK_DB: length 15.3
  TOP w0.13: v1(78.82,105.33) 79.2,105.71 U9301.5 ; CN9301.5 v1(77.84,93.84)
  L6 w0.127: v1(77.84,93.84) 77.34,94.34 77.34,95.01 77.68,95.35 77.68,96.72 76.71,97.69 76.71,103.83 78.21,105.33 v1(78.82,105.33)
ALS_PL_SMDATA_DB: length 11.8
  TOP w0.13: U9301.2 79.2,103.48 v1(78.85,103.13) ; CN9301.3 v1(77.76,94.84)
  L6 w0.127: v1(78.85,103.13) 78.28,102.56 77.73,102.56 76.97,101.8 76.97,97.79 77.93,96.83 77.93,96.62 77.93,95.25 77.76,95.07 v1(77.76,94.84)
AMD_PD#_DB: length 42.5
  TOP w0.102: v1(46.75,73.09) 46.75,72.84 TP9205.1 ; U9203.5 46.18,81.33 46.32,81.2 47.46,81.2 R9205.2 48.69,80.26 v1(48.69,79.69) ; TP9202.1 v1(42.34,95.19) ; U9201.5 v1(41.76,100) 41.9,100.14 R9204.2
  L3 w0.102: v1(46.75,73.09) 46.75,76.49 48.69,78.42 v1(48.69,79.69) 48.69,81.45 46.97,83.16 46.67,83.16 44.75,85.08 43.51,85.08 42.87,85.71 42.87,87.14 43.63,87.9 43.63,89.03 43.63,89.03 43.63,92.44 42.34,93.73 v1(42.34,95.19) 42.34,99.42 v1(41.76,100)
  BOTTOM w0.102: CN9202.29 v1(46.75,73.09)
AUDIO_AVDD: length 8.5
  TOP w0.254: v1(13.48,41.34) v1(14.09,41.34) 14.11,41.32 C519.1 C518.1 ; C512.1 17.54,37.21 ; U500.41 17.82,41.05
  TOP w0.279: U500.46 18.63,39.05 18.42,38.84 18.42,38.83
  TOP w0.356: C512.1 16.43,37.21 v1(16.41,37.18) 16.41,36.49 C513.1 ; 18.42,38.83 18.27,38.68 18.27,37.56 ; v1(15.8,37.18) v1(15.19,37.18)
  vias: v1(16.53,41.34) v3(15.47,37.84)
AUDIO_AVDD1: length 16.5
  TOP w0.279: v1(20.93,44.64) 20.93,44.33 21.05,44.21 U500.33 ; U500.40 18.33,41.45
  TOP w0.305: 18.33,41.45 17.83,41.94 C516.2 16.86,41.94 C517.2 16.61,42.02 15.77,42.86 v3(15.77,42.89) 15.46,43.2 R520.2 15.58,44 v1(15.58,44.81) 15.12,45.27 C526.2 14.19,45.56 14.12,45.49 13.5,45.49 R518.2
  L5 w0.305: v1(20.93,44.64) 19.11,44.64 19.02,44.55 17.24,44.55 16.36,45.43 15.94,45.43 15.64,45.13 15.64,44.87 v1(15.58,44.81)
AUDIO_AVDD1_R: length 2.2
  TOP w0.254: C514.2 13.23,44.37 R518.1 13.24,43.7 Q500.D
AUDIO_CBN: length 3.8
  TOP w0.254: U500.24 24.95,43.08 25.7,43.83 25.7,45.22 C509.2
AUDIO_CBP: length 3.3
  TOP w0.254: C509.1 26.13,44.45 26.13,43.58 25.73,43.17 25.73,42.52 25.46,42.25 U500.23
AUDIO_CPVEE: length 1.8
  TOP w0.254: U500.25 24.6,43.35 25.04,43.79 C500.2
AUDIO_DMIC_CLK: length 5
  TOP w0.13: R7600.1 24.45,34.63 23.78,35.3 TP513.1 22.55,35.3 21.56,36.29 21.56,36.78 21.45,36.89 U500.5
AUDIO_I2C_SCL: length 5.6
  TOP w0.13: U500.7 22.25,37.12 23.57,35.81 24.01,35.81 25.6,34.21 TP515.1
AUDIO_I2S_DIN: length 5.6
  TOP w0.13: TP504.1 25.89,34.28 23.93,36.24 23.54,36.24 22.65,37.13 U500.8
AUDIO_I2S_DOUT: length 8.4
  TOP w0.13: U500.9 23.05,37.13 23.68,36.5 24.04,36.5 25.74,34.8 26.89,34.8 27.26,34.43 27.26,33.39 28.07,32.58 TP503.1
AUDIO_I2S_MCLK: length 6.1
  TOP w0.13: U500.11 23.85,37.12 24.03,36.95 24.32,36.95 25.95,35.31 27.11,35.31 27.71,34.71 TP501.1
AUDIO_I2S_SCLK: length 6.6
  TOP w0.13: TP502.1 27.76,34.3 27.61,34.45 27.6,34.45 27,35.06 25.84,35.06 24.18,36.72 23.86,36.72 23.45,37.13 U500.10
AUDIO_LDO1_CAP: length 3.8
  TOP w0.254: C507.2 R506.2 18,43.27 18,42.31 18.46,41.85 U500.39
AUDIO_LDO2_CAP: length 3.4
  TOP w0.254: U500.21 26.07,41.45 26.36,41.74 26.36,43.27 C508.1
AUDIO_LDO3_CAP: length 1.8
  TOP w0.254: U500.19 26.69,40.65 C510.1
AUDIO_MIC_CAP: length 2
  TOP w0.254: U500.32 21.45,43.85 21.44,43.86 21.44,44.3 21.39,44.36 21.39,45.1 C506.2
AUDIO_PDB: length 1.4
  TOP w0.102: U500.2 20.25,37.02 20.15,36.92 19.97,36.92 19.64,36.59 R515.2
AUDIO_VREF: length 3.3
  TOP w0.254: U500.38 18.61,42.25 18.36,42.5 18.36,43.65 19.19,44.48 C501.2
BARREL_ADP_DET: length 84.4
  TOP w0.102: R424.2 230.86,57.98 v1(230.96,58.08)
  L5 w0.102: v1(230.96,58.08) 230.96,58.41 228.83,60.54 225.69,60.54 224.05,62.18 224.05,62.47 222.93,63.59 222.93,69.03 222.93,69.36 221.61,70.68 221.61,75.48 225.09,78.96 225.09,79.54 225.28,79.72 225.28,82.01 224.91,82.37 224.91,82.71 225.07,82.86 225.07,85.14 224.16,86.04 223.32,86.04 220.11,89.25 220.11,94.73 222.2,96.81 222.2,97.48 222.2,97.48 222.2,97.65 221.33,98.52 220.28,98.52 219.91,98.88 217.75,101.05 217.75,102.56 218.13,102.94 218.13,105.73 218.21,105.81 218.21,109.08 215.82,111.47 v2(213.69,111.47)
  BOTTOM w0.102: v2(213.69,111.47) 213.69,111.26 213.02,110.6 212.17,110.6 212.13,110.63 209.94,110.63 209.41,111.16 208.8,111.16 208.25,111.72 R68121.1 207.88,112.16 Q68121.3 205.82,111.46 205.82,111.42 205.71,111.32 204.67,111.32 204.57,111.42 204.57,112.82 R68120.2
BARREL_ADP_DET_EC: length 31.4
  TOP w0.076: U300.H5 v1(240.18,41.94)
  TOP w0.102: C327.1 R424.1 231.72,57.91 v1(231.54,58.08)
  L5 w0.076: 240.99,45.71 239.52,44.24 239.38,44.24 239.17,44.04 239.17,43.68 239.4,43.45 239.4,42.72 v1(240.18,41.94)
  L5 w0.102: 240.99,45.71 241,45.72 241.12,45.72 241.98,46.59 244.09,46.59 244.31,46.8 244.31,48.46 244.34,48.5 244.34,50.99 237.16,58.18 232.6,58.18 232.3,58.49 231.95,58.49 v1(231.54,58.08)
BARREL_ADP_EN: length 141.5
  TOP w0.076: v1(240.83,41.29) U300.F4
  TOP w0.102: Q60032.S 257.11,99.59 v1(256.32,99.59)
  TOP w0.254: Q60032.S 257.21,99.69 R60053.1
  L5 w0.102: v1(240.83,41.29) 241.84,42.31 241.84,46.18 242.06,46.39 244.01,46.39 244.01,46.39 244.17,46.39 244.51,46.73 244.51,48.37 244.55,48.41 244.55,51.08 237.24,58.38 232.68,58.38 232.38,58.69 230.97,58.69 228.91,60.75 225.77,60.75 224.25,62.27 224.25,62.55 223.14,63.67 223.14,68.94 223.14,69.45 221.81,70.77 221.81,75.4 225.29,78.88 225.29,79.45 226.13,80.29 226.13,81.33 225.73,81.74 225.73,82.71 225.27,83.16 225.27,85.23 224.25,86.25 223.4,86.25 221.23,88.42 221.23,95.56 222.4,96.72 222.4,97.4 222.4,97.73 221.42,98.72 220.36,98.72 220.11,98.97 217.95,101.13 217.95,102.47 218.34,102.86 218.34,105.65 219.05,106.36 219.05,107.33 220,108.28 220,109.09 220.67,109.77 231.37,109.77 232.66,108.48 232.66,101.13 234.03,99.76 241.87,99.76 242.71,98.92 254.18,98.92 254.85,99.59 v1(256.32,99.59)
BAT_AMBERLED#: length 156.9
  TOP w0.076: v1(237.55,45.51) 237.55,45.44 237.58,45.41 237.58,44.55 U300.L9
  TOP w0.102: D300.4 v1(285.5,113.03)
  L3 w0.102: v2(254.58,24.55) 254.58,24.63 259.49,29.54 259.88,29.54 260.73,30.39 260.73,31.84 261.01,32.11 261.01,33.25 261.91,34.15 263.72,34.15 v1(266.06,36.49)
  L5 w0.076: 235.73,43.97 237.27,45.51 v1(237.55,45.51)
  L5 w0.102: 235.73,43.97 235.72,43.97 235.31,43.57 235.31,39.07 234.56,38.32 234.54,38.32 234.47,38.25 233.27,38.25 232.13,37.11 232.13,34.42 232.13,34.42 232.13,34.16 233.53,32.76 234.7,32.76 234.78,32.83 235.62,32.83 235.85,32.6 236.14,32.31 236.22,32.24 236.22,31.68 236.75,31.14 236.75,26.33 239.34,23.74 240.76,23.74 241.34,23.16 244.31,23.16 244.54,22.93 254.42,22.93 254.99,23.49 254.99,24.14 v2(254.58,24.55)
  L6 w0.102: v1(266.06,36.49) 266.46,36.89 268.48,36.89 270.13,38.55 270.13,38.71 270.13,38.71 270.13,49.29 268.83,50.59 268.83,51.19 269.7,52.06 269.74,52.06 269.74,69.83 269.44,70.14 269.44,74.31 270.37,75.24 270.37,77.64 269.25,78.75 269.25,96.07 269.12,96.2 269.12,99.79 277.46,108.13 278.29,108.13 278.29,108.13 280.61,108.13 v1(285.5,113.03)
BAT_AMBERLED#_R: length 25.6
  TOP w0.102: R435.1 v1(268.5,101.91) ; D300.2 287.12,113.03 287.02,112.92 287.02,110.86 v1(286.55,110.4)
  L3 w0.102: v1(268.5,101.91) 268.91,102.32 271.35,102.32 277.84,108.8 284.96,108.8 v1(286.55,110.4)
BAT_WHITELED#: length 155.8
  TOP w0.076: v1(238.23,41.29) U300.F7
  TOP w0.102: D300.3 v1(285.5,112.18)
  L3 w0.102: v2(266.72,36.49) 264.18,33.95 262,33.95 261.21,33.16 261.21,32.03 260.94,31.75 260.94,30.31 259.97,29.34 259.74,29.34 259.57,29.34 254.99,24.75 254.99,24.07 v1(254.58,23.66)
  L5 w0.076: 235.92,38.17 235.92,43.39 236.78,44.24 238.37,44.24 239.23,43.39 239.23,42.29 v1(238.23,41.29)
  L5 w0.102: v1(254.58,23.66) 254.05,23.13 245.24,23.13 244.15,24.22 241.76,24.22 241.63,24.35 239.6,24.35 237.89,26.06 237.89,31.98 236.51,33.36 236.44,33.44 234.53,33.44 234.45,33.36 233.79,33.36 233.55,33.6 233.55,33.94 233.79,34.18 234.19,34.18 235.92,35.91 235.92,38.17
  L6 w0.102: v2(266.72,36.49) 268.36,36.49 270.34,38.46 270.34,38.8 270.34,50.56 269.95,50.95 269.95,69.92 269.64,70.22 269.64,74.22 270.57,75.16 270.57,77.72 269.46,78.84 269.46,95.73 269.93,96.2 269.93,96.54 269.46,97.02 269.46,99.84 277.54,107.93 281.25,107.93 v1(285.5,112.18)
BAT_WHITELED#_R: length 24.3
  TOP w0.102: v1(287.37,110.37) 287.72,110.73 D300.1 ; R413.1 v2(269.39,101.91)
  L3 w0.102: v2(269.39,101.91) 271.23,101.91 277.92,108.6 285.6,108.6 v1(287.37,110.37)
BATLOW#: length 197
  TOP w0.076: 233.42,35.32 v1(233.52,35.42) 233.6,35.42 233.83,35.65 233.95,35.65 234.44,36.15 235.72,36.15 237.1,37.53 237.1,37.56 U300.A9
  TOP w0.102: R2704.1 252.4,74.46 252.4,74.89 251.93,75.36 250.85,75.36 250.48,75.73 249.88,75.73 249.4,76.22 249.4,76.92 248.3,78.02 247.39,78.02 246.2,78.02 245.93,77.76 243.28,77.76 242.46,76.93 242.46,76.52 241.85,75.91 241.85,73.91 241.57,73.64 241.57,72 241.15,71.58 234.09,71.58 232.93,71.58 232.93,71.58 223.33,71.58 v1(223.06,71.85) ; v1(211.86,44.29) 211.86,44.86 211.31,45.41 209.6,45.41 208.82,46.19 205.26,46.19 203.8,44.73 196.17,44.73 195.49,45.4 194.59,45.4 193.82,46.18 192.18,46.18 189.89,48.47 180.98,48.47 180.03,47.51 180.03,46.82 179.82,46.62 179.82,46.54 179.62,46.34 v1(179.57,46.28) 179.57,45.99 179.73,45.83 179.73,43.5 R4744.2 ; 233.42,35.32 232.43,34.33 230.44,34.33 229.63,35.14 225.62,35.14 225.27,35.5 225.27,36.9 Q302.D
  L3 w0.102: v1(211.86,44.29) 211.88,44.26 212.7,44.26 213.26,43.7 213.37,43.7 220.3,36.77 221.53,36.77 224.35,33.95 224.85,33.95 225.64,33.16 225.64,32.66 226.56,31.74 v1(226.56,31.28)
  L6 w0.102: v1(223.06,71.85) 223.06,64.25 224.63,62.68 224.63,57.78 225.05,57.37 238.08,57.37 242.13,53.32 242.13,51.68 241.27,50.82 241.27,46.92 241.16,46.8 241.16,46.15 242.25,45.06 242.25,38.82 240.88,37.44 238.33,37.44 236.89,36.01 234.11,36.01 v1(233.52,35.42)
  BOTTOM w0.076: 232.51,35.32 232.51,35.56 232.77,35.82 233.06,35.82 233.09,35.79 233.23,35.79 233.52,35.5 v1(233.52,35.42) ; v1(179.57,46.28) 179.29,46.56 179.28,46.56 179.06,46.78 178.94,46.91 178.94,48.59 178.24,49.29 176.45,49.29 175.62,50.12 175.39,50.12 174.51,50.99 173.74,50.99 172.12,52.61 171.41,52.61 170.72,53.3 U4555.BV36
  BOTTOM w0.102: v1(226.56,31.28) 226.64,31.36 228.8,31.36 232.51,35.06 232.51,35.32
BATLOW#_N: length 6.7
  TOP w0.076: U2700.U2 255.73,68.8 255.73,69.32 254.36,70.7 253.61,70.7 252.99,71.31 252.99,71.31 252.78,71.53 252.78,72.02
  TOP w0.102: 252.78,72.02 252.78,73.32 R2704.2
BKLT_EN: length 26.7
  TOP w0.102: R3002.2 v1(25.35,10.54) ; v1(25.35,10.54) 24.85,10.05 D3001.1 ; v1(25.35,10.54) 26.12,10.54 v3(26.13,10.53) ; v1(21.99,24.96) 21.99,24.49 R3009.2
  L3 w0.102: v1(25.35,10.54) 25.35,11.86 22.41,14.8 20.32,14.8 20.22,14.9 20.22,21.91 21.99,23.69 v1(21.99,24.96)
  BOTTOM w0.102: v1(21.99,24.96) 21.99,25.64 21.08,26.56 20.39,26.56 20.2,26.75 CN3000.19
BOOT_SPI#: length 1.8
  TOP w0.076: R4837.2 172.73,59.03 v1(173.19,58.57)
  BOTTOM w0.089: v1(173.19,58.57) 173.19,58.58 U4555.CA30
BRD_ID1: length 8.2
  BOTTOM w0.076: U4555.CR28 180.56,60.27 181.55,60.27 181.86,59.96 184.61,59.96 v3(184.63,59.98) 184.66,60.02 187.43,60.02 R4571.2 188,60.31
  BOTTOM w0.102: R4572.2 188,60.31
BRD_ID2: length 10.5
  BOTTOM w0.076: U4555.CP28 179.86,60.15 180.35,59.89 180.68,59.89 180.9,60.1 181.49,60.1 181.79,59.79 184.12,59.79 184.42,59.49 187.55,59.49 187.92,59.85 188,59.85
  BOTTOM w0.102: R4573.2 R4574.2 188.49,59.85 188,59.85
BRD_ID3: length 13.5
  BOTTOM w0.076: U4555.CN28 179.51,59.89 179.99,59.89 180.3,59.72 180.77,59.72 180.99,59.94 181.42,59.94 181.72,59.63 184.05,59.63 184.36,59.32 187.68,59.32 188,59.65
  BOTTOM w0.102: v3(191.51,60.77) 191.26,60.52 191.09,60.52 190.88,60.31 R4576.2 R4575.2 189.5,59.65 188,59.65
BRD_ID4: length 9.2
  BOTTOM w0.076: U4555.CM28 178.67,60.24 178.98,60.55 179.32,60.55 179.43,60.43 181.62,60.43 181.93,60.12 183.84,60.12 184.26,60.54 v3(185.77,60.54) 186.01,60.31 R4578.2 R4577.2
BT_OFF: length 302.8
  TOP w0.102: R4562.2 182.79,45.19 182.79,45.58 182.39,45.98 182.39,46.32 182.79,46.73 v1(182.79,46.79) ; v1(55.57,15.79) 57.17,17.39 57.17,29.48 v2(56.44,30.22)
  L5 w0.102: v1(55.57,15.79) 55.78,15.58 59.83,15.58 60.72,16.47 60.89,16.47 61.45,17.03 68.25,17.03 68.94,16.34 75.82,16.34 81.5,10.66 88.67,10.66 89.03,10.3 125.31,10.3 126.28,9.34 131.73,9.34 131.88,9.49 143.44,9.49 143.92,9.01 150.12,9.01 150.98,9.87 161.56,9.87 162.19,9.23 164.12,9.23 165.49,10.6 167.42,10.6 168.04,11.22 182.67,11.22 185.08,8.8 199.26,8.8 200.63,10.17 213.91,10.17 214.19,10.45 235.89,10.45 236.22,10.45 240.71,14.94 240.71,17.03 236.66,21.09 236.25,21.09 234.16,23.17 234.16,23.74 233.85,24.04 232.37,24.04 230.23,26.18 229.63,26.18 229.43,26.38 219.26,26.38 219.05,26.18 215.36,26.18 197.58,43.96 182.49,43.96 182.39,44.06 182.39,46.32 182.79,46.73 v1(182.79,46.79)
  BOTTOM w0.076: U4555.CC35 173.64,55.32 173.63,55.27 173.63,55.1 173.67,54.97 173.67,54.74 173.6,54.55 173.6,53.55 174.51,52.64 175.2,52.64 176.07,51.77 178.64,51.77 182.32,48.08
  BOTTOM w0.102: v1(182.79,46.79) 182.32,47.26 182.32,48.08 ; R1308.1 56.81,29.52 56.44,29.9 v2(56.44,30.22)
BT_OFF#: length 7.1
  BOTTOM w0.102: CN1300.54 62.13,30 R1306.2 60.9,28.77 v3(60.4,28.77) 59.64,28.01 58.34,28.01 58.21,27.88 Q1302.D
BT_OFF_R: length 6
  BOTTOM w0.102: v3(53.16,26.56) 54.52,27.91 54.52,28.2 55.44,29.12 R1308.2 55.96,28.84 55.68,28.56 55.68,27.88 Q1302.G
BUF_PLT_RST#: length 529
  TOP w0.102: R4502.1 113.28,65.59 112.87,65.18 112.87,64.04 115.67,61.24 115.67,52.36 109.97,46.66 101.7,46.66 99.25,44.22 98.83,44.22 95.32,40.71 95.32,27.11 91.03,22.82 89.66,21.45 89.66,14.36 91.84,12.18 v1(93.62,12.18) ; U2701.1 243.93,73.54 243.59,73.19 243.59,70.66 236.88,63.95 232.9,63.95 231.12,65.73 218.06,65.73 v1(217.01,64.68) ; v1(243.94,22.75) 245.83,20.86 245.83,20.62 245.96,20.49 245.96,15.07 248.24,12.79 254.82,12.79 255.06,13.02 255.06,16.25 256.63,17.82 258.45,17.82 v1(258.74,17.53) ; Q2620.5 218.21,54.33 217.96,54.08 216.59,54.08 v1(216.53,54.14) ; Q302.G 224.49,38.07 224.24,38.32 224.24,38.94 224.24,39.08 v1(224.31,39.16) ; v1(50.01,12.13) 50.72,12.13 51.2,12.62 51.2,14.32 53.99,17.11 v1(53.99,21.68) ; Q3800.5 v1(195.76,73.33)
  L5 w0.102: v1(214.49,78.32) 215.41,77.4 215.41,70.03 215.9,69.54 215.9,65.8 v1(217.01,64.68)
  L6 w0.102: v1(93.62,12.18) 93.29,12.18 93,12.47 88.24,12.47 87.5,13.21 83.15,17.57 68.05,17.57 66.29,19.32 56.18,19.32 53.99,21.51 v1(53.99,21.68) ; v1(195.76,73.33) 199.94,73.33 201.83,75.22 206,75.22 v1(206.6,75.82) 207.25,75.17 212.27,75.17 212.51,75.41 212.51,76.33 v1(214.49,78.32) ; v1(50.01,12.13) 50.72,12.13 52.71,14.12 55.7,14.12 55.9,13.92 69.13,13.92 70.42,12.63 86.43,12.63 87.73,11.33 89.16,11.33 91.15,9.34 120.05,9.34 120.25,9.54 128.76,9.54 132.95,5.35 143.75,5.35 144.26,5.86 164.49,5.86 164.66,5.86 167.92,9.12 212.27,9.12 212.29,9.13 227.34,9.13 228.89,7.58 238.14,7.58 238.34,7.79 239.19,7.79 239.6,7.79 241.51,9.69 241.83,9.69 243.15,11.01 243.15,19.56 244.34,20.75 244.34,22.55 244.14,22.75 v1(243.94,22.75) 242.95,23.74 240.01,23.74 238.25,25.5 238.25,30.46 237.08,31.63 237.08,31.95 236.36,32.67 235.79,33.24 233.68,33.24 233.35,33.57 232.79,33.57 232.51,33.57 232.31,33.77 231.91,33.77 231.91,33.77 230.33,33.77 228.76,35.35 228.42,35.35 227.7,35.35 226.55,36.49 226.19,36.49 225.07,37.62 225.07,38.31 224.31,39.07 v1(224.31,39.16) 223.93,38.77 223.25,38.77 222.32,39.7 222.32,39.91 221.51,40.72 221.51,42.75 220.39,43.87 220.39,46.86 220.39,47.25 217.14,50.5 217.14,53.53 v1(216.53,54.14) 216.46,54.22 216.46,64.12 v1(217.01,64.68)
  BOTTOM w0.102: U1401.1 214.44,63.28 215.21,64.05 215.21,64.07 215.66,64.51 216.52,64.51 216.69,64.68 v1(217.01,64.68) ; CN1951.50 260.4,18.43 259.5,17.53 v1(258.74,17.53) ; U1300.1 53.3,23.42 52.78,22.9 R1347.1 52.78,22.1 53.2,21.68 v1(53.99,21.68) ; v1(206.6,75.82) 206.55,75.78 206.55,70.52 206.45,70.42 206,70.42 205.76,70.18 205.76,69.85 205.52,69.61 205.28,69.61 204.87,69.2 R4713.1 204.87,68.6 U4700.4
CAMERA_ON: length 116
  TOP w0.102: R4565.2 199,50.87 200.24,52.1 201.81,52.1 v1(201.86,52.15) ; R3033.1 223.79,101.28 v3(223.45,100.91) v1(223.45,100.25)
  L3 w0.102: v1(215.67,49.39) 215.67,49.26 215.12,48.71 211.17,48.71 207.61,52.28 206.81,52.28 202.85,52.28 202.72,52.15 v1(201.86,52.15)
  L5 w0.102: v1(215.67,49.39) 215.67,50.36 214.89,51.13 214.89,59.77 217.83,62.7 217.83,63.67 218.78,64.62 218.78,65.45 218.38,65.85 218.38,66.83 216.86,68.35 216.86,69.44 216.07,70.23 216.07,80.3 218.23,82.46 218.23,87.24 218,87.48 218,97.92 v1(218.28,98.21)
  L6 w0.076: 181.6,53.41 176.22,53.41 173.37,56.26 173.37,57.29 173.19,57.47 v1(173.19,57.95)
  L6 w0.102: 181.6,53.41 186.5,53.41 188.7,55.62 192.74,55.62 196.2,52.15 v1(201.86,52.15) ; v1(218.28,98.21) 219,98.92 222.12,98.92 v1(223.45,100.25)
  BOTTOM w0.076: 223.67,100.03 223.95,99.75 CN3001.5
  BOTTOM w0.089: U4555.CA31 172.8,58.14 v1(173.19,57.95)
  BOTTOM w0.102: 223.67,100.03 v1(223.45,100.25)
CAMERA_WP#: length 4.6
  TOP w0.102: R3034.2 R3007.1 v3(224.76,103.82) 224.94,104 R3001.2 224.36,105.05 v1(224.06,104.75)
  BOTTOM w0.076: CN3001.15 v1(224.06,104.75)
CAMERA_WP#_EC: length 95.3
  TOP w0.076: v1(237.58,40.64) U300.E8
  TOP w0.102: R3001.1 v3(224.94,106.72) 224.61,107.05 221.18,107.05 v1(220.95,106.82)
  L5 w0.076: 245.44,46.27 242.37,43.2 242.37,42.09 242.36,42.09 242.36,40.37 241.62,39.63 241.33,39.63 240.03,40.93 239.38,40.93 239.32,40.99 238.73,40.99 238.37,40.64 v1(237.58,40.64)
  L5 w0.102: 245.44,46.27 245.46,46.29 245.46,47.4 245.28,47.58 245.28,51.2 237.49,58.99 233.07,58.99 231.37,60.7 231.37,65.98 231.51,66.12 231.51,71.55 230.15,72.91 230.15,77.73 229.28,78.6 229.28,78.76 229.28,78.76 229.28,78.93 229.28,80.05 226.51,82.82 226.51,85.99 225.65,86.86 223.66,86.86 222.58,87.94 222.58,91.36 222.4,91.53 222.3,91.64 222.3,95.76 223.01,96.47 223.01,97.14 223.01,97.99 221.67,99.33 220.62,99.33 219.72,100.22 219.72,105.31 220.95,106.53 v1(220.95,106.82)
CAPS_LED#: length 287
  L5 w0.102: v1(239.21,51.93) 239.24,51.27 237.36,49.39 237.36,49.04 237.17,48.85 237.17,47.94 237.16,47.92 237.16,46.53 236.99,46.36 236.99,45.64 236.99,45.48 236.55,45.04 236.52,45.04 236.5,45.03 236.49,45.03 235.11,43.65 235.11,43.1 233.09,41.08 229.68,41.08 227.99,39.39 227.99,36.78 230.36,34.41 231.6,34.41 233.45,32.55 234.79,32.55 234.86,32.63 235.54,32.63 235.71,32.46 236.01,32.15 236.01,30.66 235.88,30.53 235.81,30.46 234.97,29.62 234.97,27.25 239.93,22.3 241.56,22.3 241.8,22.06 241.8,20.45 243.63,18.62 243.63,13.71 243.44,13.52 243.44,10.69 240.86,8.11 240.86,5.37 240.43,4.94 240.43,4.14 239.84,3.55 236.62,3.55 235.89,4.28 228.16,4.28 227.81,3.93 227.47,3.93 227.12,4.28 221.21,4.28 217.98,7.51 215.41,7.51 213.97,8.96 201.14,8.96 199.77,7.58 185.08,7.58 184.58,7.58 183,9.16 165.77,9.16 163.21,6.59 150.61,6.59 149.73,7.47 143.69,7.47 142.71,6.49 141.35,6.49 141.27,6.42 138.68,6.42 136.62,8.47 132.31,8.47 132.15,8.32 125.86,8.32 124.89,9.29 99.61,9.29 98.82,8.5 82.8,8.5 78.15,13.15 59.94,13.15 59.56,13.53 52.37,13.53 50.34,11.5 49.15,11.5 48.64,12 43.58,12 v2(42.21,13.37)
  BOTTOM w0.102: U302.4 241.71,52.89 241.55,52.89 241.45,52.79 241.45,51.71 240.78,51.04 239.34,51.04 239.24,51.14 v1(239.21,51.93) ; U302.4 242.75,53.11 R341.1 ; U302.4 241.13,53.91 R360.1 ; R392.1 43.66,16.06 43.04,15.44 42.82,15.44 42.61,15.23 42.47,15.23 42.19,14.95 42.19,13.4 v2(42.21,13.37)
CAPS_LED#_R: length 5
  BOTTOM w0.102: R392.2 44.06,15.61 43.53,15.61 v3(42.67,14.75) 42.62,14.7 42.62,13.21 42.29,12.87 CN300.12
CATERR#: length 10.6
  BOTTOM w0.076: U4555.AA4 147.72,75.43 147.98,75.7 147.98,76.01 148.16,76.42 148.16,76.6 148.09,76.8 148.09,76.89 148.15,77.05 148.15,77.46 147.9,77.71 147.9,80.49 147.45,80.95
  BOTTOM w0.102: 147.45,80.95 147.12,81.27 147.12,82.81 146.62,83.3 v3(146.62,84.16) 146.45,84.34 R4604.2
CCG5_A_CC1: length 50
  TOP w0.076: 264.03,28.58 263.32,28.58 U2403.K2
  TOP w0.254: v1(266.47,30.29) 266.27,30.29 265.36,29.37 264.82,29.37 264.03,28.58
  TOP w0.33: v1(279.2,63.11) 279.25,63.16 280.31,63.16 280.4,63.07 CN2900.A5
  TOP w0.381: C2422.1 267.04,30.31 267.02,30.29 v1(266.47,30.29)
  L5 w0.381: v1(266.47,30.29) 266.47,30.62 268.96,33.11 268.96,33.69 276.04,40.78 276.45,40.78 277.92,42.26 277.92,52.34 275.16,55.1 275.16,59.41 278.66,62.91 279,62.91 v1(279.2,63.11)
  BOTTOM w0.254: v1(279.2,63.11) 280.18,63.11 280.8,62.49 D2619.1
CCG5_A_CC2: length 61.7
  TOP w0.076: 264.31,28.09 263.67,28.09 263.67,28.08 263.32,28.08 U2403.H2
  TOP w0.254: v1(284.7,64.17) 284.56,64.31 CN2900.B5 ; v1(265.4,28.32) 265.16,28.09 264.31,28.09
  L5 w0.381: v1(284.7,64.17) 284.92,64.39 284.92,65.15 284.55,65.51 283.45,65.51 282.96,66 278.85,66 278.18,65.33 278.18,64.25 278.46,63.96 278.46,63.39 274.68,59.61 274.68,54.9 277.44,52.14 277.44,42.46 276.25,41.26 275.66,41.26 272.3,37.91 272.05,37.91 268.61,34.46 266.48,34.46 265.5,33.49 265.5,28.43 v1(265.4,28.32)
  BOTTOM w0.102: v1(265.4,28.32) 265.67,28.05 C2419.1
  BOTTOM w0.254: D2603.1 285.44,64.14 285.41,64.17 v1(284.7,64.17)
CCG5_B_CC1: length 74.6
  TOP w0.076: U2403.K9 259.32,29.08 259.32,29.43 259.03,29.73 259.03,30.15
  TOP w0.102: 259.03,30.15 259.03,30.35 v1(258.98,30.39) 258.69,30.39 258.05,31.04 256.52,31.04 255.97,31.59 255.57,31.59 254.84,32.32 254.3,32.32 253.99,32.01 C2421.1
  TOP w0.33: CN2800.A5 279.45,78.71 v1(279.42,78.68)
  L5 w0.381: v1(258.98,30.39) 259.16,30.57 262.39,30.57 262.8,30.98 262.8,32.29 266.11,35.6 266.95,35.6 270.23,38.87 271.9,38.87 275.49,42.46 276.01,42.46 276.48,42.92 276.48,51.54 273.72,54.3 273.72,62.05 274.62,62.96 274.62,64.6 276.46,66.44 276.46,72.7 278.22,74.47 278.22,76.23 279.19,77.2 279.19,78.45 v1(279.42,78.68)
  BOTTOM w0.33: D2806.1 280.56,78.11 280.08,78.59 280.07,78.59 279.96,78.7 279.45,78.7 v1(279.42,78.68)
CCG5_B_CC2: length 82.8
  TOP w0.076: U2403.K10 259.05,28.83 258.82,29.06 258.82,29.43 258.42,29.83 v1(258.37,29.83) 258.1,30.1 258.1,30.15
  TOP w0.102: 258.1,30.15 257.73,30.52 254.05,30.52 C2420.1
  TOP w0.254: CN2800.B5 284.79,79.95 285.35,80.51 v1(285.35,80.63)
  L5 w0.381: v1(285.35,80.63) 285.35,77.81 284.88,77.34 280.04,77.34 278.71,76.01 278.71,74.25 276.96,72.51 276.96,66.26 275.1,64.4 275.1,62.76 274.2,61.85 274.2,54.5 276.96,51.74 276.96,42.72 276.21,41.98 275.69,41.98 272.1,38.39 270.43,38.39 267.15,35.12 266.34,35.12 264.44,33.22 264.44,30.98 262.86,29.4 258.8,29.4 v1(258.37,29.83)
  BOTTOM w0.254: v1(285.35,80.63) 285.07,80.35 285.07,79.99 D2807.1
CCG5_BOT_A_L_DN: length 66.6
  TOP w0.076: 266.06,24.01 266.04,24.01 266.01,23.98 265.21,23.98 264.1,25.09 263.81,25.09 U2403.C1
  TOP w0.119: v1(277.11,64.36) 277.08,64.36 276.85,64.58 276.51,64.58 276.37,64.44 D2614.1 D2614.10 274.13,64.44 273.99,64.58 273.46,64.58 v1(273.2,64.32) ; v1(267.59,24.37) 267.55,24.37 267.19,24.01 266.06,24.01 ; CN2900.B7 283.18,63.31 283.3,63.43 283.92,63.43 v1(284.16,63.19)
  L6 w0.127: v1(273.2,64.32) 273.2,64.48 273.52,64.8 273.82,64.8 274.11,64.51 274.11,63.17 273.01,62.07 273.01,53.17 274.11,52.07 274.11,37.51 270.24,33.64 270.24,33.06 267.83,30.65 267.83,27.83 268.32,27.34 268.32,24.3 268.04,24.02 267.92,24.02 267.59,24.35 v1(267.59,24.37)
  BOTTOM w0.119: v1(277.11,64.36) 277.32,64.58 277.66,64.58 278.33,63.91 278.33,62.97 279.56,61.73 281.93,61.73 283.6,63.4 283.95,63.4 v1(284.16,63.19)
CCG5_BOT_A_L_DP: length 66.7
  TOP w0.076: 266.06,23.79 266.04,23.79 266.01,23.82 265.14,23.82 264.03,24.92 263.66,24.92 U2403.B1
  TOP w0.119: 266.06,23.79 v1(267.56,23.79) ; v2(277.11,65.02) 276.9,64.8 276.51,64.8 276.37,64.94 D2614.2 D2614.9 274.13,64.94 273.99,64.8 273.46,64.8 v1(273.2,65.07) ; CN2900.B6 283.18,63.82 283.35,63.65 283.98,63.65 v1(284.16,63.83)
  L6 w0.127: v1(267.56,23.79) 268.14,23.79 268.55,24.2 268.55,27.43 268.06,27.93 268.06,30.55 270.47,32.96 270.47,33.54 274.34,37.41 274.34,52.16 273.24,53.27 273.24,61.98 274.34,63.08 274.34,64.6 273.92,65.03 273.24,65.03 v1(273.2,65.07)
  BOTTOM w0.119: v2(277.11,65.02) 277.32,64.8 277.75,64.8 278.55,64 278.55,63.06 279.65,61.95 281.84,61.95 283.51,63.62 283.95,63.62 v1(284.16,63.83)
CCG5_BOT_B_L_DN: length 69.9
  TOP w0.076: 265.13,30.15 265.11,30.14 265.11,30.1 264.85,29.83 264.59,29.83 263.92,29.16 263.74,29.16 U2403.L1
  TOP w0.119: 265.13,30.15 266.55,31.58 266.97,31.58 267.51,32.12 267.51,32.29 267.33,32.48 v1(267,32.48) ; CN2800.B7 283.18,78.95 283.3,79.07 284.02,79.07 v1(284.25,78.83) ; v1(274.6,77.67) 274.86,77.93 275.39,77.93 275.53,77.79 D2606.10 D2606.1 277.7,77.79 277.86,77.96 278.28,77.96 v1(278.55,77.75)
  L6 w0.127: v1(274.6,77.67) 274.6,77.82 274.35,78.07 274.04,78.07 273.91,77.94 273.91,72.67 273.11,71.87 273.11,69.48 271.92,68.29 271.92,52.4 273.02,51.3 273.02,42.68 272.61,42.28 272.61,37.74 268.61,33.74 268.61,33.15 267.93,32.46 267.02,32.46 v1(267,32.48)
  BOTTOM w0.119: v1(278.55,77.75) 278.75,77.95 278.86,77.95 279.63,77.18 281.87,77.18 283.8,79.11 283.98,79.11 v1(284.25,78.83)
CCG5_BOT_B_L_DP: length 69.9
  TOP w0.076: 265.28,30 265.27,29.98 265.23,29.98 264.92,29.67 264.66,29.67 263.99,29 263.74,29 U2403.K1
  TOP w0.119: 265.28,30 266.64,31.36 267.06,31.36 267.73,32.03 267.73,32.39 267.48,32.63 v1(267.48,32.96) ; v1(274.6,78.42) 274.86,78.15 275.39,78.15 275.53,78.29 D2606.9 D2606.2 277.78,78.29 277.89,78.18 278.28,78.18 v2(278.55,78.44) ; v1(284.27,79.47) 284.1,79.29 283.35,79.29 283.18,79.46 CN2800.B6
  L6 w0.127: v1(274.6,78.42) 274.48,78.3 273.94,78.3 273.68,78.04 273.68,72.76 272.88,71.96 272.88,69.57 271.69,68.38 271.69,52.31 272.79,51.21 272.79,42.78 272.38,42.37 272.38,37.83 268.39,33.83 268.39,33.24 267.83,32.69 267.65,32.69 267.48,32.86 v1(267.48,32.96)
  BOTTOM w0.119: v2(278.55,78.44) 278.55,78.44 278.82,78.17 278.96,78.17 279.73,77.4 281.78,77.4 283.71,79.33 284.14,79.33 v1(284.27,79.47)
CCG5_I2C_EC_INT#: length 99.5
  TOP w0.076: 232.51,37.76 233.31,37.76 v1(233.47,37.6) 233.97,37.1 235.5,37.1 235.95,37.55 U300.A11
  TOP w0.102: 232.51,37.76 R397.1 ; R2626.1 259.69,35.55 259.16,36.08 256.18,36.08 253.98,33.89 250.79,33.89 249.46,35.22 248.11,35.22 246.78,33.89 246.78,33.17 246.48,32.86 245.79,32.86 243.91,30.98 v1(243.86,30.98) 243.81,30.98 242.84,31.95 242.41,31.95 242.05,32.3 241,32.3 240.92,32.38 240.57,32.38 239.83,33.12 239.2,33.12 238.9,33.42 234.98,33.42 234.08,32.52 v1(234.08,31.74)
  L3 w0.076: 232.51,35.32 232.51,36.63 v1(233.47,37.6)
  L3 w0.102: 232.51,35.32 232.51,33.31 v1(234.08,31.74)
  L5 w0.102: v1(243.86,30.98) 244.23,30.98 245.38,32.13 245.38,36.83 248.85,40.3 249.47,40.3 250.19,41.02 250.19,45.17 249.27,46.08 249.27,57.49 249.68,57.9 249.68,69.78 248.48,70.98 246.5,70.98 246.05,71.43 246.05,72.56 247.57,74.08 249.82,74.08 250.14,74.4 250.14,76.16 v2(250.09,76.21)
  BOTTOM w0.102: v2(250.09,76.21) 250.15,76.15 CN2701.12
CCG5_I2C_EC_R_INT#: length 6.1
  TOP w0.076: U2403.L5 261.31,29.59 261.31,30.15
  TOP w0.102: R2626.2 259.76,34.49 v3(259.76,33.76) 259.64,33.63 259.64,32.33 261.31,30.65 261.31,30.15
CCG5_I2C_EC_R_SCL: length 7.5
  TOP w0.13: R2660.2 258.87,35.11 v3(258.52,34.76) 258.52,34.17 259.01,33.67 259.01,32.74 259.27,32.48 259.27,32.35 261.07,30.55 U2403.L6
CCG5_I2C_EC_R_SDA: length 7.5
  TOP w0.076: U2403.K6 260.82,29.08 260.82,30.04 260.81,30.05 260.81,30.15
  TOP w0.13: R2684.2 257.54,34.17 257.95,34.17 258.06,34.06 258.06,33.92 v3(258.52,33.47) 258.52,32.87 259.01,32.38 259.01,32.24 260.81,30.44 260.81,30.15 260.81,30.15
CCG5_I2C_EC_SCL: length 92.3
  TOP w0.076: v1(237.58,41.29) U300.F8
  TOP w0.13: R2660.1 257.8,35.84 256.28,35.84 254.08,33.64 250.69,33.64 249.43,34.91 248.37,34.91 v1(248.28,34.82) 247.46,33.99 247.46,31.77 246.25,30.56 243.68,30.56 242.54,31.7 242.31,31.7 241.95,32.06 240.9,32.06 240.82,32.13 240.47,32.13 239.73,32.87 239.1,32.87 238.8,33.17 235.31,33.17 234.52,32.38 234.52,31.27 v1(234.59,31.21) 234.59,30.86 235.41,30.04 R375.1
  L3 w0.097: v1(234.59,31.21) 234.57,31.22 234.57,33.7 235.23,34.36 235.23,40.47 236.01,41.25 236.28,41.25 236.75,41.72 237.14,41.72 v1(237.58,41.29)
  BOTTOM w0.13: CN2701.14 248.59,75.15 246.44,73.01 246.44,50.65 v3(246.73,50.36) 246.73,49.97 248.35,48.35 248.35,47.01 248.1,46.76 247.86,46.76 246.88,45.78 246.88,42.54 248.62,40.79 248.62,35.65 248.28,35.31 v1(248.28,34.82)
CCG5_I2C_EC_SDA: length 88.2
  TOP w0.076: v1(236.93,41.29) U300.F9
  TOP w0.13: R2684.1 256.17,35.37 254.19,33.39 250.59,33.39 249.32,34.65 248.73,34.65 v1(248.28,34.21) 247.71,33.64 247.71,31.66 246.36,30.31 243.58,30.31 242.43,31.45 242.2,31.45 241.85,31.8 240.79,31.8 240.71,31.88 240.36,31.88 239.62,32.62 237.55,32.62 v3(237.51,32.65) 237.25,32.92 235.66,32.92 234.78,32.03 234.78,31.63 v1(235.2,31.21) 235.35,31.05 R356.1
  L3 w0.097: v1(235.2,31.21) 234.8,31.61 234.8,33.52 235.46,34.18 235.46,40.43 236.09,41.06 236.7,41.06 v1(236.93,41.29)
  BOTTOM w0.13: v1(248.28,34.21) 247.86,34.63 247.86,35.26 248.36,35.76 248.36,40.68 246.62,42.43 246.62,47.99 246.19,48.42 246.19,73.11 248.49,75.41 249.23,75.41 249.47,75.65 CN2701.13
CCG5_MOD_ID1: length 7.9
  TOP w0.13: U2403.A8 258.86,23.12 258.86,20.48 R2465.2 257.59,19.22 v3(256.79,19.22) 256.2,19.81 R2466.1
CCG5_MOD_ID2: length 6.8
  TOP w0.13: U2403.A9 259.57,24.15 258.47,23.06 258.47,22.6 258.25,22.38 R2464.2 258.22,20.78 257.5,21.5 v3(256.82,21.5) 256.2,20.89 R2463.1
CCG5_PD_ADP_DIS1#: length 7.3
  TOP w0.102: Q2607.6 255.93,49.14 256.18,49.39 256.4,49.39 256.93,49.93 258.37,49.93 258.59,49.7 258.59,47.74 R2621.1 258.04,47.18 257.3,47.18 Q2607.3
CCG5_PD_ADP_DIS1#_R: length 2.2
  TOP w0.102: R2621.2 259.08,47.3 R2619.1 259.08,45.69 Q2601.1
CCG5_PD_ADP_DIS2#: length 2.9
  TOP w0.102: R2612.1 262.75,96.07 Q2605.3 262.93,97.13 263.18,97.38 263.18,97.39 263.77,97.98 263.95,97.98 Q2605.6
CCG5_PD_ADP_DIS2#_R: length 4.7
  TOP w0.102: v3(263.39,91.71) 263.1,92 Q2603.1 263.64,94.6 R2611.1 263.64,95.11 R2612.2
CCG5_PVCC_PD: length 45
  TOP w0.13: v2(263.09,20.6) 262.76,20.27 R2421.2 ; v1(250.8,23.71) 250.47,23.39 R2458.2 250.44,22.82 C2425.1 248.37,22.82 C2423.1 247.67,22.63 C2424.1 ; R2466.2 R2463.2 255.3,20.78 v1(254.68,20.78) ; U2403.C10 259.59,25.38 259.59,25.38 v1(259.6,25.38) U2403.D10
  L3 w0.097: v1(254.68,20.78) 255.09,20.38 262.87,20.38 v2(263.09,20.6) 262.64,21.05 260.77,21.05 259.6,22.22 v1(259.6,25.38) 259.99,25.77 259.99,26.8 259.58,27.21 259.58,28.56 259.8,28.78 260.2,28.78 261.49,30.08 261.49,31.52 261.77,31.8 261.77,32.76 v1(262.25,33.24)
  BOTTOM w0.13: v1(250.8,23.71) 251.24,24.16 252.47,24.16 253.69,25.38 v1(259.6,25.38) ; v1(262.25,33.24) 262.25,33.34 262.55,33.64 R2441.1 262.91,33.64 262.92,33.64 R2422.2
CCG5_SBU1_A_DP: length 60.3
  TOP w0.076: 262.63,22.86 262.63,22.87 262.6,22.9 262.6,23.78 262.4,23.98 262.4,24.16 U2403.A3
  TOP w0.119: CN2900.A8 280.16,64.57 279.93,64.34 v1(279.91,64.34) ; 262.63,22.86 262.63,22.6 264.24,20.99 266.89,20.99 266.97,21.06 267.77,21.06 v1(268.04,21.34)
  L6 w0.127: v1(279.91,64.34) 281.33,62.93 281.33,62.62 279.32,60.61 279.32,42.64 274.77,38.09 274.77,36.65 269.19,31.07 269.19,21.76 268.54,21.11 268.28,21.11 v1(268.04,21.34)
  BOTTOM w0.119: D2615.1 280.71,63.54 v1(279.91,64.34)
CCG5_SBU1_B_DP: length 74.4
  TOP w0.076: U2403.E1 263.74,26.5 263.92,26.5 264.11,26.68 264.51,26.68 264.78,26.42 v1(264.78,26.42)
  TOP w0.119: CN2800.A8 280.16,80.21 279.93,79.98 v1(279.91,79.98)
  L6 w0.127: v1(279.91,79.98) 281.48,79.98 281.73,79.73 281.73,79.55 281.68,79.49 276.85,79.49 275.48,80.86 273.94,80.86 272.36,79.28 272.36,73.46 271.55,72.65 271.55,70.32 270.37,69.13 270.37,51.55 270.76,51.16 270.76,38.97 270.76,38.97 270.76,38.29 264.98,32.51 264.98,28.98 264.13,28.13 264.13,27.09 264.78,26.44 v1(264.78,26.42)
  BOTTOM w0.119: v1(279.91,79.98) 279.91,79.5 280.58,78.83 D2605.1
CCG5_SBU2_A_DN: length 63
  TOP w0.076: 262.4,22.86 262.4,22.88 262.43,22.91 262.43,23.72 262.24,23.91 262.24,24.16 U2403.A4
  TOP w0.119: CN2900.B8 283.7,62.82 284.32,62.19 v1(284.62,62.19) ; 262.4,22.86 262.4,22.51 264.15,20.77 266.98,20.77 267.06,20.84 267.79,20.84 v2(268.04,20.59)
  L6 w0.127: v1(284.62,62.19) 284.04,62.78 281.81,62.78 279.55,60.52 279.55,42.54 275,37.99 275,36.56 269.41,30.98 269.41,21.66 268.63,20.88 268.33,20.88 v2(268.04,20.59)
  BOTTOM w0.119: v1(284.62,62.19) 285.06,62.63 D2618.1
CCG5_SBU2_B_DN: length 74
  TOP w0.076: v1(264.78,27.12) 264.51,26.85 264.04,26.85 263.85,26.66 263.74,26.66 U2403.F1
  TOP w0.119: v1(284.08,78.02) 284.16,78.02 283.73,78.46 CN2800.B8
  L6 w0.127: v1(264.78,27.12) 264.69,27.03 264.51,27.03 264.36,27.18 264.36,28.03 265.21,28.88 265.21,32.42 270.98,38.19 270.98,39.07 270.98,51.25 270.6,51.64 270.6,69.04 271.78,70.22 271.78,72.56 272.59,73.37 272.59,79.19 274.04,80.63 275.38,80.63 276.76,79.26 282.97,79.26 v1(284.08,78.02)
  BOTTOM w0.119: v1(284.08,78.02) 284.94,78.02 D2604.1
CCG5_SWD_CLK: length 25.8
  TOP w0.076: U2403.C2 v1(262.54,25.39)
  TOP w0.13: R2457.2 251.32,22.85 R2458.1 251.32,23.45 v1(251.53,23.66)
  L6 w0.127: v1(262.54,25.39) 260.89,27.04 260.89,28.48 261.37,28.96 261.37,30.99 261.83,31.44 261.83,34.06 v1(262.38,34.61)
  BOTTOM w0.13: v1(262.38,34.61) 262.8,35.03 CN375.26 ; v1(251.53,23.66) 251.64,23.77 252.63,23.77 253.84,24.98 254.73,24.98 254.78,24.93 260.16,24.93 260.17,24.93 261.52,24.93 261.52,24.93 262.08,24.93 v1(262.54,25.39)
CCG5_SWD_IO: length 20.8
  TOP w0.076: 263.78,24.57 263.77,24.58 263.37,24.58 263.11,24.83 U2403.B2
  TOP w0.13: 263.78,24.57 v1(264.08,24.27) 265.07,23.28 265.11,23.28 265.23,23.17 R2449.1 R2418.1 265.93,21.72 v3(265.93,21.48)
  L6 w0.127: v1(264.08,24.27) 263.38,24.97 262.36,24.97 259.89,27.44 259.89,28.47 260.99,29.57 260.99,31.14 261.45,31.6 261.45,34.36 v1(261.72,34.62)
  BOTTOM w0.13: v1(261.72,34.62) 261.8,34.62 262.2,35.03 262.21,35.03 262.3,35.12 CN375.25
CCG5_SWD_XRES: length 11.5
  TOP w0.13: C2432.1 261.75,33.13 v1(262.25,32.63) ; U2403.H6 v1(261.31,28.31)
  BOTTOM w0.13: v1(262.25,32.63) 261.83,33.05 261.83,33.51 262.51,34.19 262.55,34.19 263.3,34.94 CN375.27 ; v1(262.25,32.63) 262.7,32.18 v3(262.7,30.37) 262.7,29.69 v1(261.31,28.31) ; v1(262.25,32.63) 262.41,32.79 R2441.2
CCG5_TOP_A_L_DN: length 61.4
  TOP w0.076: v1(263.72,22.87) 263.94,23.09 263.94,23.31 263.25,24 263.25,24.15 U2403.A2
  TOP w0.119: CN2900.A7 280.44,64.07 280.3,63.93 279.53,63.93 277.15,66.31 276.76,66.31 276.76,66.31 276.43,66.31 D2614.5 D2614.6 274.13,66.45 273.99,66.31 273.46,66.31 v2(273.2,66.57)
  L6 w0.127: v1(263.72,22.87) 263.88,23.03 263.88,23.48 264.75,24.35 265.99,24.35 266.67,25.02 267.38,25.02 267.66,25.3 267.66,27.07 267.17,27.56 267.17,30.92 269.58,33.33 269.58,33.91 273.45,37.78 273.45,51.63 272.35,52.73 272.35,66.26 272.61,66.52 273.15,66.52 v2(273.2,66.57)
CCG5_TOP_A_L_DP: length 61.3
  TOP w0.076: v1(264.33,22.87) 264.11,23.1 264.11,23.38 263.42,24.07 263.42,24.18 U2403.A1
  TOP w0.119: v1(273.2,65.82) 273.46,66.08 273.99,66.08 274.13,65.95 D2614.7 D2614.4 276.43,66.08 276.76,66.08 276.76,66.08 277.06,66.08 279.44,63.7 280.3,63.7 280.44,63.57 CN2900.A6
  L6 w0.127: v1(273.2,65.82) 273.2,65.98 272.88,66.29 272.7,66.29 272.58,66.16 272.58,52.83 273.68,51.73 273.68,37.69 269.81,33.82 269.81,33.24 267.4,30.82 267.4,27.66 267.89,27.16 267.89,25.21 267.47,24.79 266.76,24.79 266.09,24.12 264.84,24.12 264.11,23.38 264.11,23.1 v1(264.33,22.87)
CCG5_TOP_B_L_DN: length 72.7
  TOP w0.076: 266.06,27.4 266.05,27.4 266.02,27.37 265.81,27.37 265.34,27.83 U2403.H1
  TOP w0.119: v1(274.6,79.92) 274.86,79.65 275.39,79.65 275.53,79.79 D2606.6 D2606.5 277.75,79.79 277.87,79.67 278.2,79.67 278.31,79.57 280.61,79.57 280.75,79.71 CN2800.A7 ; v2(266.54,25.6) 266.81,25.86 267.44,25.86 267.82,26.23 267.82,26.76 267.18,27.4 266.06,27.4
  L6 w0.127: v1(274.6,79.92) 273.93,79.92 273.02,79.01 273.02,73.04 272.22,72.24 272.22,69.85 271.03,68.65 271.03,51.9 271.42,51.51 271.42,45.1 271.42,38.01 265.82,32.42 265.82,26.26 265.82,25.98 266.08,25.72 266.42,25.72 v2(266.54,25.6)
CCG5_TOP_B_L_DP: length 72.7
  TOP w0.076: U2403.G1 263.57,27.48 263.76,27.67 263.93,27.67 264.05,27.55 264.19,27.55 264.31,27.67 264.44,27.67 264.55,27.55 264.7,27.55 264.82,27.67 265.28,27.67 265.74,27.2 266.01,27.2 266.04,27.17 266.06,27.17
  TOP w0.119: v1(266.57,26.6) 266.57,26.2 266.69,26.08 267.35,26.08 267.59,26.33 267.59,26.67 267.09,27.17 266.06,27.17 ; CN2800.A6 280.72,79.21 280.58,79.34 278.21,79.34 278.11,79.45 277.91,79.45 277.75,79.29 D2606.4 D2606.7 275.53,79.29 275.39,79.43 274.86,79.43 v1(274.6,79.17)
  L6 w0.127: v1(266.57,26.6) 266.57,26.22 266.3,25.95 266.18,25.95 266.05,26.08 266.05,26.17 266.05,32.32 271.65,37.92 271.65,45.2 271.64,51.61 271.26,52 271.26,68.56 272.45,69.75 272.45,72.14 273.25,72.94 273.25,78.91 274.03,79.69 274.21,79.69 274.6,79.3 v1(274.6,79.17)
CCG5_TR_RST#: length 71.6
  TOP w0.076: v1(261.84,67.55) U2700.E5
  TOP w0.102: R2449.2 267.81,22.67 v1(268.04,22.67) ; R2749.1 R2742.1 270.4,76.7 270.41,76.7 v1(270.98,76.7)
  L3 w0.102: v1(262.56,26.05) 262.13,25.62 262.13,25.02 261.67,24.56 261.51,24.56 260.75,23.8 260.75,23.47 261.75,22.47 267.84,22.47 v1(268.04,22.67)
  L5 w0.102: v1(261.84,67.55) 270.91,76.62 270.91,76.65 v1(270.98,76.7)
  L6 w0.102: v1(261.84,67.55) 262.88,66.51 262.88,60.49 260.98,58.59 260.98,57.98 260.66,57.67 260.66,56.5 260.66,56.5 260.66,51.71 262.66,49.71 262.66,41.84 262.79,41.71 262.79,34.44 262.66,34.32 262.66,30.89 261.74,29.97 261.74,26.87 v1(262.56,26.05)
CCG5_VBUS_C_CTRL_P1: length 25.9
  TOP w0.076: U2403.K4 262.04,28.83 261.82,29.06 261.82,29.51 261.75,29.58 261.75,30.15
  TOP w0.102: v1(257.3,48.2) 257.27,48.2 257.16,48.09 256.78,48.09 256.44,47.74 Q2607.2 256.44,47.31 256.63,47.12 R2602.1 256.4,46.65 255.25,46.65 R2606.2 ; 261.75,30.15 261.75,30.9 v2(260.12,32.53)
  L6 w0.102: v2(260.12,32.53) 260.32,32.73 260.32,41.85 259.2,42.97 259.2,43.3 259.2,45.18 257.3,47.08 v1(257.3,48.2)
