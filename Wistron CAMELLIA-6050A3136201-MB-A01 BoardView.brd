# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Nets (continued)
XDP_PRSNT#: CN4920.60(GND17) D4920.3(A1) R4924.1(A) R4934.2(B) TP4517.1
XDP_PRSNT#_D: D4920.1(A2) R4929.1(A)
XDP_PRSNT#_R: Q4921.G R4924.2(B)
XDP_TRST#: CN4920.54(TRSTN) R4613.2(B)
XTAL24_IN: C4828.1(A) L4555.2(IND) R4547.2 R4898.2(B) X4751.3
XTAL24_IN_PCH: L4555.1(INC) R4547.1 U4555.CK3(XTAL_IN)
XTAL24_OUT: C4826.1(A) L4555.3(INB) R4548.2 R4898.1(A) X4751.1
XTAL24_OUT_PCH: L4555.4(INA) R4548.1 U4555.CK2(XTAL_OUT)
XTAL_SELECT: R4550.2(B) U4555.CF25(GPP_H21/XTAL_FREQ_SELECT)

Pads without a net: CN200 7 8; CN301 4 5; CN375 2 23; CN1300 8 12 20 44 46 48 66 68 70; CN1400 22 29 31 35 37 38 40 60 62 64 65; CN1951 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 75; CN2500 2; CN2701 11; CN3000 4 6; CN3150 13 14; CN4100 87 88 91 92 95 97 100 101 104 105 162 165 166; CN4125 87 88 91 92 95 97 100 101 104 105 162 165 166; CN4350 4 13; CN4941 16 17 18; CN9301 2; CN9354 1 2 7 8 9 10 11 12; D1300 2; D1302 2; D1410 2; D4920 2; D7002 2; D9201 4 5 6 7; D9202 4 5 6 7; FIX1 1; FIX2 1; FIX3 1; FIX4 1; FIX5 1; FIX6 1; FIX7 1; FIX8 1; FIX9200 1; FIX9201 1; FIX9202 1; FIX9203 1; FIX9204 1; FIX9205 1; FIX9206 1; FIX9207 1; FIX9350 1; FIX9351 1; U500 12; U1000 5 11; U1400 B2; U2403 B6 B7 B8 B9 F10 G8 G10 H4 H5 H8 H11 J10 J11 K5 L4; U2500 3; U2501 13; U2700 AB3 AB5 AB15 AB17 AB19 AB21 AB23 AC3 AC5 AC15 AC17 AC19 AC21 B23 D19 D20 E19 E20 H5 J9 J11 N4 N5 V8; U2702 1 5; U3150 3; U3500 3 4 5 10 11 12 13 15 25 26 27 28 29 30 31; U3800 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U4555 A34 A35 AA24 AA26 AB25 AC24 AC25 AC26 AD24 AD26 AG6 AG7 AH26 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BA1 BA2 BB9 BB24 BC3 BC24 BC28 BD3 BG5 BG6 BJ34 BJ36 BK5 BK6 BK34 BK35 BK36 BL3 BL4 BL34 BL36 BL37 BM3 BM4 BP8 BP9 BP34 BP35 BR18 BT8 BT9 BV24 BV25 BV28 BV30 BV34 BW1 BW2 BW5 BW6 BY3 BY4 BY6 BY7 C34 CA32 CB8 CB9 CE27 CG1 CG2 CH35 CH36 CJ27 CK34 CK36 CL35 CL36 CM22 CM35 CN12 CN35 CN36 CP3 CP8 CP26 CP36 CR3 CR4 CR26 CR35 D34 D35 D37 E1 F34 F37 G1 G2 G3 G4 H3 H4 K12 K14 K15 K17 K18 K20 L5 L25 M24 M26 N5 P24 P26 R24 R25 R26 T25 U3 U4 U34 U35 V24 V25 V28 V29 W3 W25 Y3 Y24 Y25; U4700 1; U7000 1; U60000 26; U60100 4; U60250 10; U60600 8; U60900 8; U61400 7; U66000 2 40

## Via types
v1: diameter 0.457, hole 0.254, TOP to BOTTOM, 4561 vias
v2: diameter 0.61, hole 0.254, TOP to BOTTOM, 422 vias
v3: diameter 0.61, hole 0.305, TOP to BOTTOM, 641 vias
v4: diameter 0.762, hole 0.381, TOP to BOTTOM, 36 vias
v5: diameter 0.61, hole 0.406, TOP to BOTTOM, 550 vias
v6: diameter 0.864, hole 0.432, TOP to BOTTOM, 7 vias
v7: diameter 0.584, hole 0.292, TOP to BOTTOM, 2 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V05A_PG: length 96.9
  L3 w0.102: v1(212.39,97.3) 212.39,96.27 216.37,92.29 216.37,91.56 220.93,87 220.93,84.99 219.95,84.01 215.13,84.01 v1(214.73,83.61)
  L5 w0.102: v1(213.92,106.77) 214,106.69 214,98.17 213.13,97.3 v1(212.39,97.3)
  L6 w0.102: v1(213.92,106.77) 213.34,106.77 212.53,107.58 211.18,107.58 208.85,109.91 207.15,109.91 205.03,107.79 203.4,107.79 200.71,105.09 199.4,105.09 197.78,103.47 194.26,103.47 194.09,103.47 193.2,102.58 188.03,102.58 187.76,102.31 184.9,102.31 181.76,105.45 172.44,105.45 169.8,102.81 v2(166.9,102.81)
  BOTTOM w0.102: R7420.1 216.3,76.23 215.72,76.81 215.72,78.17 214.36,79.53 214.36,83.24 v1(214.73,83.61) ; U60900.7 166.49,102.4 v2(166.9,102.81)
3V3DS_PG: length 27.5
  L6 w0.102: v2(216.03,94.24) 220.66,94.24 227.58,87.31 v1(229.05,87.31)
  BOTTOM w0.102: v1(229.05,87.31) 229.05,87.26 229.64,86.68 229.64,85.57 230.03,85.18 232.06,85.18 232.33,84.91 232.33,83.25 231.22,82.14 231.22,81.14 231.11,81.03 230.07,81.03 230.01,81.1 U60100.3 ; R7000.2 v2(216.03,94.24)
3V3DS_PG_R: length 6.7
  BOTTOM w0.102: 214.53,95.86 U7000.2 214.53,93.8 C7001.1 ; 214.53,95.86 215.53,95.86 R7017.2 R7000.1 ; 214.53,95.86 v3(212.77,95.86)
3V_LP#: length 1.5
  TOP w0.102: TP60102.1 225.57,81.32 v1(225.68,81.21)
  BOTTOM w0.102: U60100.12 225.79,81.1 v1(225.68,81.21)
5V_PG: length 66.3
  L3 w0.102: v1(212.39,97.91) 212.39,97.87 212.56,97.7 212.8,97.46 212.8,96.15 216.57,92.37 216.57,91.64 221.13,87.08 221.13,84.91 219.83,83.61 v1(215.34,83.61)
  L5 w0.102: v1(213.59,103.44) 213.59,98.05 213.45,97.91 v1(212.39,97.91)
  L6 w0.102: v1(191.12,100.42) 191.7,101 193.54,101 193.93,100.62 200.1,100.62 203.3,103.82 203.3,104.63 204.76,106.08 205.38,106.08 205.61,105.86 205.97,105.5 205.97,105.5 208.03,103.44 v1(213.59,103.44)
  BOTTOM w0.102: U60250.9 190.72,100.19 190.95,100.42 v1(191.12,100.42) ; R7429.1 215.92,76.9 215.92,78.26 214.6,79.58 214.6,82.64 v3(214.88,82.92) 214.88,83.15 v1(215.34,83.61)
AGND_AUDIO: length 62.8
  TOP w0.254: C502.2 v1(27.89,41.44) ; v1(25.86,41.95) 25.76,41.85 U500.22 ; R507.2 18.03,45.66 v1(18.28,45.4) ; C517.1 17.3,42.87 v1(17.5,43.07) 17.54,43.02 C516.1 ; C501.1 18.34,44.65 v1(18.79,45.1) ; U500.37 v1(19.15,43.15) ; v1(22.27,44.2) 22.27,44.03 22.25,44.01 U500.30
  TOP w0.381: C515.2 16.52,45.44 16.4,45.56 C526.1 15.97,45.19 16.13,45.03 16.13,44.95 v1(16.15,44.92) ; C507.1 R506.1 16.72,42.94 C517.1 ; C503.2 28.09,42.57 v1(28.09,42.84) ; v1(9.08,46.74) 8.79,46.45 8.79,46.44 R509.2 R510.2 ; C525.2 4.98,44.34 v1(5.42,44.79) 5.51,44.79 6.39,45.67 R510.2 ; R510.2 v3(7.18,46.62) ; v1(28.06,43.52) 27.48,43.52 C508.2 ; v1(21.91,46.13) 21.89,46.11 C506.1 ; v1(27.68,44.21) 27.96,44.49 C524.2
  L3 w0.203: v1(19.15,43.15) 19.15,43.32 17.54,44.93 16.16,44.93 v1(16.15,44.92) 16.15,44.92 15.52,45.56 10.44,45.56 10.24,45.35 5.99,45.35 v1(5.42,44.79) ; v1(2.87,45.26) 4.35,46.74 v1(5.76,46.74) v1(9.08,46.74) 9.22,46.88 21.16,46.88 v1(21.91,46.13) 23.58,46.13 v1(24.1,45.61)
  BOTTOM w0.356: v1(2.87,45.26) 2.75,45.14 CN2500.28 ; CN2500.23 5.25,44.62 v1(5.42,44.79)
  BOTTOM w0.381: v1(5.42,44.79) 5.42,46.39 v1(5.76,46.74) ; v1(2.87,45.26) 2.87,45.96 v1(3.63,46.73)
  vias: v1(25.04,45.85)
AGND_KBC: length 15.2
  TOP w0.152: C318.1 249.01,38.37 249.01,35.87 248.74,35.6 247.98,35.6 C304.2
  TOP w0.254: C313.1 249.25,39.44 ; C309.2 v1(249.3,40.71) ; C301.2 249.22,40.07 ; 249.3,39 248.95,38.65 C318.1 ; v1(246.2,40.43) 246.12,40.5 244.25,40.5 244.14,40.39 242.53,40.39 U300.E1 ; C320.2 247.72,35.57 C304.2
  L3 w0.381: v1(249.3,40.71) 248.12,39.52 247.52,39.52 246.62,40.43 v1(246.2,40.43)
AGND_USB: length 5.1
  TOP w0.254: C9226.2 27.28,73.7 v1(27.28,73.32) ; C9228.2 v1(30.62,74.13) ; C9227.2 29.81,68.7 v1(29.69,68.7)
  BOTTOM w0.254: CN9202.8 v1(36.25,72.79) ; v1(35.11,73.62) 34.31,73.62 33.75,73.06 CN9202.3
  vias: v1(24.08,73.32) v1(36.22,74.36)
DGND: length 2409.5
  TOP w0.076: 202.15,76.25 202.46,76.56 202.93,76.56 203.16,76.78 U3800.N2 ; 20.19,36.57 C520.2
  TOP w0.152: U2700.L22 U2700.L23 ; v1(263.98,67.61) 263.86,67.65 U2700.A4 U2700.B4 ; U2700.B16 U2700.A16 263.88,62.13 v1(263.98,62.14) ; U2700.B2 U2700.A2 U2700.A1 ; U2700.B2 U2700.D4 ; U2700.B2 U2700.B1 U2700.A1 ; U2700.AC2 U2700.AB2 ; v1(263.98,64.89) U2700.A10 U2700.B10 ; v1(261.59,58.34) 261.48,58.45 U2700.E23 261.48,59.22 261.49,59.23 261.49,59.37 U2700.E22 ; v1(263.78,68.83) 263.57,69.03 U2700.A1 ; U2700.A22 U2700.B22 262.56,59.68 262.56,59.99 U2700.B20 U2700.A20 263.87,60.29 v1(263.98,60.19) ; v1(263.98,61.21) 263.86,61.21 U2700.A18 U2700.B18 262.64,61.44 262.23,61.44 U2700.D18 ; v1(263.98,63.97) U2700.A12 U2700.B12 ; U2700.U22 U2700.U23 255.96,58.91 255.96,58.39 255.92,58.35 v1(255.92,58.33) ; U2700.AB6 U2700.AC6 253.16,66.77 252.47,66.77 v1(252.45,66.79) ; v1(252.47,63.99) 252.56,63.97 252.9,63.97 252.92,63.94 253.06,63.94 253.09,63.97 U2700.AC12 U2700.AB12 ; v1(263.98,65.81) U2700.A8 U2700.B8 ; v1(260.56,58.34) 260.56,58.37 260.56,58.38 U2700.G23 U2700.G22 ; U2700.R23 v1(256.88,58.34) ; 259.24,64.3 259.24,64.95 U2700.L9 ; 202.15,76.25 v1(202.15,75.82) ; v1(259.64,58.33) 259.64,58.34 U2700.J23 U2700.J22 ; v1(252.47,61.21) U2700.AC18 U2700.AB18 ; C7625.2 26.24,37.28 26.46,37.5 27.93,37.5 28.3,37.87 v1(28.3,37.93) ; v1(252.42,67.65) U2700.AC4 U2700.AB4 ; U2700.M2 U2700.M1 v1(258.26,69.56) ; v1(255,58.34) 255,58.32 255.04,58.37 U2700.W23 U2700.W22 ; v1(257.8,58.34) U2700.N23 U2700.N22 ; U2700.J1 v1(259.64,69.56) ; U2700.J1 U2700.J2 ; U2700.J1 U2700.H1 ; v1(252.47,62.13) U2700.AC16 253.25,62.17 253.62,62.17 U2700.AB16 ; U2700.AB8 U2700.AC8 253.18,65.84 252.71,65.84 252.67,65.89 252.5,65.89 252.48,65.86 v1(252.47,65.86) ; U2700.AB14 U2700.AC14 v1(252.47,63.05) ; U2700.AB10 U2700.AC10 252.54,64.89 v1(252.47,64.96) ; v1(257.94,61.7) v1(257.94,62.35) ; v1(253.84,58.34) 253.84,58.44 254.12,58.72 U2700.AA23 U2700.AA22 U2700.AB22 U2700.AC22 v1(252.47,59.07) U2700.AC23 ; U2700.C22 U2700.C23 262.4,58.54 v1(262.61,58.38) ; v1(263.98,63.06) 263.98,63.05 U2700.A14 U2700.B14 ; U2700.A23 v1(263.7,58.54)
  TOP w0.178: U2700.Y5 254.16,67.43 254.03,67.43 254.03,68.21 U2700.AB2 ; U2700.E4 261.66,68.02 261.78,68.02 262.02,68.02 U2700.D4 ; U2700.F1 U2700.F2 ; U2700.R12 v1(257.29,64.3) ; v1(263.03,70.02) 262.64,70.02 261.94,69.33 U2700.D1 U2700.D2 ; 259.24,64.3 U2700.J12
  TOP w0.203: U2700.F5 U2700.F6 v1(261.19,66.25) U2700.F8 ; 261.19,64.3 261.51,64.62 U2700.E11 ; 261.19,64.3 U2700.F11 ; 261.19,64.3 U2700.F12 261.19,63.65 261.51,63.33 U2700.E13 ; v1(242.5,37.23) 242.45,37.28 U300.A1 ; v1(255.98,61.69) 255.66,62 U2700.V16 ; v1(255.98,61.69) U2700.V18 ; v1(255.98,61.69) U2700.T18 v1(256.65,61.69) U2700.R18 v1(257.28,61.04) ; U2700.D9 261.84,64.95 ; U2700.D9 U2700.D8 ; U2700.D9 U2700.B10 U2700.D11 ; 261.84,64.95 U2700.D11 ; 261.84,64.95 U2700.E11 ; 261.84,64.95 U2700.E9 ; 259.93,59.72 U2700.J22 ; 259.93,59.72 U2700.H20 ; 259.93,59.72 U2700.J20 ; v1(256.64,63) U2700.R15 257.18,62.88 257.4,62.88 U2700.N15 v1(257.94,62.35) U2700.M15 U2700.L15 v1(259.24,62.35) ; U2700.E13 261.19,63 U2700.F15 261.19,62.35 ; U2700.E13 v1(261.84,63) ; U2700.E13 v1(261.84,63.65) ; v1(262.47,62.35) 262.16,62.04 U2700.D16 U2700.D18 U2700.E18 v1(261.19,61.7) ; v1(262.47,62.35) U2700.B16 ; v1(262.47,62.35) U2700.D15 v1(261.84,63) ; U2700.W8 U2700.Y9 ; U2700.Y9 253.82,65.81 U2700.AB8 ; U2700.Y9 U2700.W11 ; 255.34,63.65 U2700.V12 v1(255.34,64.3) ; 255.34,63.65 U2700.V13 255.34,63 ; 255.34,63.65 U2700.W13 ; U2700.AB6 U2700.Y5 ; U2700.N9 257.5,65.39 257.08,65.39 U2700.R9 ; U2700.E9 261.19,64.95 ; U2700.E9 U2700.D8 ; 261.19,64.95 U2700.E11 ; 261.19,64.95 260.86,65.27 U2700.F9 ; U2700.R23 U2700.R22 256.96,59.45 U2700.R20 ; U2700.D13 v1(261.84,63.65) ; U2700.D13 v1(261.84,63) ; U2700.D13 262.43,63.05 U2700.B14 ; v1(261.84,63.65) U2700.D12 v1(261.84,64.3) ; 261.19,62.35 U2700.E15 ; 261.19,62.35 U2700.F16 ; U2700.C22 262.4,59.4 262.09,59.71 261.8,59.71 261.48,59.4 U2700.E22 ; U2700.D2 U2700.D4 ; U2700.D4 U2700.B4 ; U2700.D4 262.28,67.76 262.28,67.33 U2700.D5 262.32,67.06 262.32,66.73 ; 255.96,59.92 256.16,59.92 U2700.T20 ; 255.96,59.92 255.82,59.92 255.66,60.07 U2700.V20 ; 255.96,59.92 255.96,59.41 ; v1(237.48,46.09) 237.13,45.74 237.13,45.23 237.25,45.11 U300.M9 ; U2700.E11 v1(261.84,64.3) ; v1(261.84,64.3) U2700.D11 ; v1(261.84,63) U2700.E15 ; v1(256.64,66.25) 256.64,66.25 256.32,66.57 U2700.T6 ; 255.34,63 U2700.W15 v1(254.69,63) ; 255.34,63 U2700.W13 ; 255.34,63 U2700.V15 ; 262.32,66.73 U2700.D6 v1(261.84,66.25) U2700.D8 ; 262.32,66.73 U2700.B6 U2700.A6 ; U2700.M6 U2700.L8 258.91,65.92 258.59,65.6 ; U2700.M2 258.26,68.56 257.94,68.24 257.33,68.24 U2700.R4 ; v1(257.94,65.6) U2700.M9 258.26,65.27 258.59,65.6 ; 258.59,65.6 U2700.L9 ; U2700.E15 U2700.F13 U2700.E12 ; U2700.AA22 254.12,59.84 253.67,60.29 U2700.AB20 U2700.AC20 v1(252.47,60.29) ; U2700.N18 v1(257.94,61.7) ; U2700.B8 U2700.D8 ; U2700.AB10 254.09,64.89 U2700.Y11 254.37,64.62 v1(254.69,64.31) ; 259.24,64.3 U2700.L12 v1(258.59,64.3) ; v1(162.76,70.74) 163.46,70.74 163.68,70.96 163.68,71.83 R4524.2 ; v1(254.69,63) U2700.W13 ; v1(254.69,63) U2700.Y15 254.2,62.67 253.99,62.46 253.99,62.45 253.8,62.26 253.79,62.26 U2700.AB16 ; v1(255.34,64.3) U2700.W11 ; v1(255.34,64.3) U2700.V11 ; U2700.W11 v1(254.69,64.31) ; U2700.W11 255.34,64.95 255.66,65.27 U2700.V9 ; U2700.M20 U2700.N19 257.59,60.72 v1(257.28,61.04) ; U2700.M20 U2700.N20 257.29,60.4 256.96,60.72 U2700.R19 ; U2700.M20 257.8,59.61 U2700.N22 ; U2700.Y8 U2700.W9 ; U2700.F2 U2700.F4 ; v1(254.69,64.31) 255.01,63.98 U2700.W12 ; v1(252.79,68.87) 252.85,68.87 252.88,68.89 252.88,68.9 253.01,69.03 U2700.AC1 U2700.AB1 ; U2700.R19 256.64,60.39 v1(256.64,60.39) ; U2700.R19 v1(257.28,61.04) ; U2700.N12 U2700.M12 ; U2700.AB4 254.03,67.43 ; U2700.L22 258.72,59.88 U2700.L20 U2700.J19 ; v1(256.64,64.3) U2700.R12
  TOP w0.229: U3800.A6 206.47,84.11 207.01,84.11 v1(207.92,85.03) ; U2700.U22 255.96,59.41
  TOP w0.254: C66806.2 106.78,103.9 v1(106.83,103.95) 107.33,103.95 R66198.2 ; v1(221.31,58.61) 221.44,58.48 R1019.1 221.89,58.88 222.41,59.39 U3500.9 ; v1(264.18,41.65) 264.2,41.87 R2617.1 ; R4562.1 183.59,44.89 v1(183.59,44.57) ; v1(168.9,63.8) 168.9,63.74 168.5,63.34 C4531.1 ; v1(143.18,8.6) 143.18,8.67 142.14,9.71 C1001.2 ; Q2613.S 266.57,40.4 266.01,40.4 265.38,41.04 v1(264.97,41.04) ; Q7006.S 216.49,91.53 215.66,91.53 215.17,92.01 v1(214.69,92.01) ; C1453.2 v1(268.59,42.93) ; C4588.2 158.62,72.67 158.62,72.74 v1(158.6,72.76) ; v1(265.76,98.68) 265.76,97.61 265.5,97.35 R2615.1 ; v1(273.92,65.44) D2614.8 D2614.3 ; v1(257.01,85.73) 257.6,85.73 R68108.2 ; v1(144.29,56.21) 144.29,55.75 C4506.2 ; R2706.2 246.66,71.39 v1(246.88,71.62) ; v1(104.76,6.66) 104.5,6.92 C7610.2 ; C3315.2 236.05,95.62 v1(235.49,95.62) 234.88,96.22 C3369.2 R3300.2 ; U3500.23 226.46,55.22 226.46,53.18 226.13,52.85 v1(226.13,52.75) ; C7537.2 217.32,22.25 v1(217.27,22.3) ; CN4920.37 124.52,68.65 v1(124.62,68.54) ; C4152.2 205.64,20.6 v1(204.51,19.47) ; 191.11,98.27 191.3,98.45 191.3,98.78 191.73,99.22 v1(191.73,100.42) ; 191.11,98.27 191.34,98.04 C60020.2 ; 191.11,98.27 190.93,98.45 C60033.2 ; U2403.G5 U2403.G6 ; U2403.G5 U2403.G4 ; U2403.G5 U2403.F5 ; U2403.G6 U2403.F6 ; U2403.G6 U2403.G7 ; C4140.2 178.71,22.45 v1(178.73,22.47) ; C66107.2 94.6,95.7 v1(94.18,95.7) 94.18,95.28 R66107.2 ; U2700.H20 260.26,60.07 260.56,59.77 ; R4621.1 184.23,59.89 v1(182.95,58.6) ; v1(98.83,91.25) 98.83,90.66 C66100.2 ; v1(165.46,77.76) 165.91,77.3 C4624.1 166.1,77.3 C4626.1 166.1,75.48 C4516.1 165.66,75.47 v1(165.46,75.68) ; C4115.2 129.13,20.72 C4117.2 130.12,19.73 v1(130.12,19.09) ; CN2800.A1 281.8,76.71 282.05,76.46 CN2800.B12 282.59,76.48 283.25,76.48 283.46,76.7 v1(283.61,76.7) ; v1(201.86,51.19) 200.65,49.98 198.03,49.98 197.53,49.47 R4582.2 196.99,49.47 196.61,49.09 R4859.2 ; R4589.2 145.84,75.77 v1(145.93,75.68) ; v1(236.24,22.82) 236.1,22.82 235.74,22.45 C4129.2 235.44,21.99 C4130.2 ; v1(26.18,32.84) 26.18,32.81 26.11,32.73 C2505.2 ; v1(202.15,75.82) 202.99,74.98 205.44,74.98 205.57,75.11 205.57,75.89 U3800.P6 U3800.N5 U3800.P4 ; C7548.2 154.33,56.17 v1(154.36,56.21) ; v1(275.54,61.63) 275.54,61.79 275.33,62 D2900.2 ; C7542.2 146.5,18.36 v1(146.58,18.28) ; v1(178.71,45.15) 178.6,45.15 178.23,44.77 178.23,44.37 178.24,44.36 178.24,44.35 178.37,44.22 R4860.2 R4864.2 ; v1(21,24.25) 20.8,24.45 R3028.1 20.26,24.12 C3001.2 ; v1(226.78,22.24) 226.19,21.65 C7553.2 ; C7512.2 148.73,6.56 v1(148.84,6.67) ; v1(245.11,70.51) 244.26,71.36 U2701.3 ; v1(103.73,41.7) 103.7,41.72 C4920.2 103.06,40.49 U4920.2 ; C3316.2 v1(247,94.76) R3314.2 ; v1(174.19,14.06) 174.31,13.94 C4149.2 ; U3300.43 243.04,95.38 v1(243.07,95.42) ; R4519.1 148.38,75.67 v1(148.37,75.68) ; R345.2 CN366.4 U366.4 v1(226.01,29.43) ; v1(2.69,37.18) 2.7,37.19 C640.2 ; C2600.1 268.59,95.44 268.42,95.44 U2600.D3 U2600.C3 U2600.B3 ; C2600.1 270.6,96.37 271.06,96.83 v1(271.06,97.51) ; C2600.1 269.53,96.55 269.36,96.72 C2601.2 ; R2603.1 265.2,96.61 R2615.1 ; R4603.2 200.3,46.85 v1(200.3,46.84) ; C4547.2 170.59,78.63 v1(171.04,78.83) ; v1(149.33,56.21) 149.37,56.16 C4505.2 ; R4527.2 153.44,75.86 v1(153.26,75.68) ; Q68054.S 180.32,109.68 178.51,111.49 R60002.2 177.57,112.63 177.82,112.88 v5(179.09,112.88) ; R4566.2 139.18,77.81 138.74,77.36 C4605.2 C4604.2 138.32,76.59 v1(138.22,76.49) ; C7620.2 25.68,21.78 v1(25.68,21.78) 24.79,21.78 24.51,22.06 Q3003.S ; C7624.2 24.21,33.01 23.6,32.41 C521.2 22.85,32.41 v1(22.51,32.75) ; v1(166.33,62.4) 166.36,61.68 166.88,61.17 C4520.2 167.64,61.17 v1(167.71,61.24) ; v1(266.37,98.81) 266.37,98.97 266.99,99.6 Q2602.S ; v1(113.56,14.34) 113.56,14.34 C4112.2 ; U2403.E7 U2403.D7 ; U2403.E7 U2403.E8 ; U2403.E7 U2403.F7 ; U2403.E7 U2403.E6 ; U2403.D7 v1(260.34,25.35) 260.34,25.36 U2403.D8 ; U2403.D7 U2403.D6 ; U2403.D7 U2403.D8 ; C4538.1 v1(174.06,68.84) ; R4543.1 189.96,60.51 R4970.1 190.01,61.17 v1(190.11,61.27) 190.17,61.33 191.34,61.33 191.74,60.93 191.74,59.84 R4819.2 ; C7622.2 238.78,28.71 v1(238.86,28.79) 239.27,28.79 R357.2 ; R3801.1 v1(197.53,72.57) ; U3500.2 226.49,61.02 C3503.2 226.18,61.03 v1(225.98,61.23) ; v1(172.15,63.8) 172.3,63.65 172.65,63.65 R4588.1 ; C504.2 v1(28.1,39.17) ; v1(246.1,36.97) 245.44,36.97 R906.2 ; TP4751.1 209.34,8.18 v1(208.73,7.58) ; v1(273.03,41.42) 273.86,40.59 CN1451.G1 ; v1(190.27,97.83) 190.21,97.83 189.92,98.12 189.92,98.71 C7514.2 ; R349.2 244.31,48.09 243.94,47.72 v1(243.94,47.56) ; v1(94.17,96.99) 94.17,97.56 R66407.1 ; R4101.2 159.82,18.98 v1(159.63,18.79) ; v1(167.71,61.24) 167.97,60.97 R4587.1 ; v1(167.71,61.24) 168.05,61.58 C4534.1 ; v1(231.07,17.81) 231.11,17.85 C7546.2 ; v1(205.96,78.91) 206.16,78.71 U3800.K8 ; TP2522.1 8.17,42.66 v1(7.75,43.08) 7.93,43.08 8.72,43.87 R509.1 ; v1(198.12,112.46) 198.12,112.53 197.71,112.94 197.21,112.94 196.72,113.44 195.53,113.44 195.19,113.78 C60030.2 ; v1(170.18,63) 170.18,62.98 169.72,62.52 C4524.1 C4549.1 ; C7552.2 111.64,22.16 v1(111.61,22.19) ; v1(131.59,21.27) 131.98,21.66 C4137.2 ; C7612.2 215.45,52.9 215.92,53.38 v1(215.92,53.53) ; v1(149.38,11.03) 149.37,11.03 C7547.2 ; 166.68,66.01 C4521.2 166.68,67.01 v1(166.92,67.26) ; U4921.2 99.59,40.79 99.89,41.09 C4921.2 99.89,41.78 99.42,42.25 98.71,42.25 98.56,42.1 98.56,41.89 98.08,41.42 v1(97.94,41.42) ; v1(249.78,21.38) 249.63,21.53 C2425.2 250.44,21.97 R2457.1 ; CN4920.25 v1(121.48,65.65) 121.48,64.4 121.74,64.14 CN4920.19 ; v1(268.59,46.75) 268.76,46.71 C1405.2 269.83,46.71 D1404.2 ; C7539.2 141.76,56.19 v1(141.78,56.21) ; v1(168.24,53.46) 168.69,53.01 168.69,51.18 169.24,50.63 169.24,42.71 C7029.2 ; C7603.2 273.07,33.07 273.07,33.06 v1(273.07,32.68) 272.27,32.68 C7600.2 ; R3021.2 v1(22.63,22.77) ; v1(170.2,67.16) 170.16,67.12 C4536.1 ; v1(218.64,4.51) 219.4,5.27 C4350.2 ; C7529.2 152.72,61.58 ; v1(219.4,22.43) 219.35,22.38 C7540.2 ; C7605.2 269.24,81.02 C7607.2 268.2,80.3 v1(268.09,80.2) ; R4531.2 168.93,55.67 v1(169.46,56.21) ; v1(275.27,78.79) D2606.8 D2606.3 v1(277.97,78.79) ; CN4920.31 v1(121.55,67.15) ; C511.2 27.57,36.28 27.57,35.46 v1(27.76,35.27) ; v1(197.05,22.47) 197.29,22.24 C4133.2 ; C505.2 v1(27.71,40.04) 27.71,40.54 27.71,40.55 C510.2 ; C366.2 228.93,57.78 228.93,55.54 229.02,55.44 C3504.2 229.43,54.83 v1(230.32,53.94) ; v1(261.59,58.34) 261.52,58.26 261.52,56.97 261.78,56.71 262.57,56.71 263.09,57.23 263.09,57.61 262.61,58.09 v1(262.61,58.38) ; v1(229.09,13.73) 228.79,13.44 C4147.2 ; v1(175.56,22.39) 175.54,22.37 C7541.2 ; v1(56.54,24.48) 56.49,24.48 C7621.2 ; v1(63.24,11.95) 62.91,11.62 C7517.2 ; C2200.2 234.86,5.18 234.75,5.29 234.06,5.29 233.85,5.5 231.72,5.5 v1(230.8,6.42) ; C7531.2 152.88,60.97 ; v1(155.88,72.84) 155.9,72.82 155.9,72.68 156.18,72.4 C4559.2 ; C4539.1 175.2,67.37 v1(175.41,67.62) ; v1(25.09,24.96) 25.18,25.04 R2501.2 ; C325.1 238.29,48.84 238.29,48.84 v1(238.29,49.38) ; v1(270.05,74.06) 270.26,73.8 C2749.2 ; C307.2 248.25,42.25 247.95,41.95 247.55,41.95 247.37,42.13 246.71,42.13 v1(246.2,41.62) 246,41.82 245.19,41.82 C317.2 ; v1(214.32,22.17) 214.33,22.17 C4135.2 ; C7538.2 163.45,27.88 v1(163.62,28.06) ; C4523.1 173.42,66.27 v1(173.42,65.51) 173.55,65.37 C4546.1 ; v1(201.94,115.95) 201.37,115.38 C7616.2 ; v1(239.84,37.04) 239.85,37.04 U300.A5 ; C324.2 231.61,43.73 231.6,43.73 v1(231.09,43.73) ; C4551.2 160.92,61.81 C4558.2 160.91,62.35 v1(160.87,62.39) 160.86,62.4 C4555.2 ; Q60035.S 184.55,112.17 v1(185.04,112.17) ; C1956.2 246.46,21.4 v1(246.24,21.4) ; v1(224.06,100.25) 224.18,100.37 R3033.2 ; v1(161.37,72.76) 161.42,72.81 C4560.2 C4563.2 ; v1(130.46,2.44) 130.42,2.36 C7513.2 ; v1(232.32,55.44) 232.64,55.12 R4606.1 ; C7550.2 193.82,22.34 v1(193.81,22.36) ; U2403.E6 U2403.E5 ; U2403.E6 U2403.D6 ; U2403.E6 U2403.F6 ; U2403.E5 U2403.E4 ; U2403.E5 U2403.F5 ; U2403.E5 U2403.D5 ; C7518.2 156.1,1.68 v1(156.11,1.67) ; R321.2 241.96,47.3 242.11,47.16 v1(242.11,46.95) ; 125.58,90.55 C7523.2 ; R2614.1 260.35,96.84 260.35,96.87 260.17,97.05 260.17,98.74 260.01,98.9 v1(260.01,99.59) ; C4550.2 162.89,72.41 v1(163.21,72.73) ; C7406.2 225.93,35.88 v1(225.79,35.74) ; v1(230.45,39.16) 230.23,39.38 C322.2 230.9,39.9 231.2,40.19 231.24,40.19 231.28,40.23 C303.2 C310.2 232.52,40.23 232.55,40.2 233.27,40.2 v1(233.3,40.17) ; v1(268.59,47.36) 268.77,47.41 D1402.2 ; R2610.2 v1(267.89,86.8) 267.86,86.77 C7618.2 ; U366.9 223.54,29.02 220.59,29.02 C316.2 ; U2403.F6 U2403.F5 ; U2403.F6 U2403.F7 ; v1(172.26,59.85) 172.43,60.02 172.65,60.02 R4837.1 ; C4532.1 167.82,73.46 v1(167.84,73.44) ; v1(187.45,106.42) 187.45,106.5 187.19,106.77 186.26,106.77 186.01,106.51 R60014.1 185.61,106.24 R60017.1 ; v1(21.79,15.35) 21.69,15.45 21.69,16.58 Q3001.1 21.7,16.88 21.91,17.09 22.2,17.09 22.7,17.59 Q3001.4 ; v1(116.46,13.86) 116.38,13.78 C4114.2 ; C2601.2 269.81,97.46 v1(269.86,97.41) ; C2601.2 269.68,97.14 ; v1(256.82,20.78) R2464.1 R2465.1 ; R2609.1 275.91,62.12 v1(275.9,62.11) ; R431.2 243.84,34.81 244.01,34.99 C315.2 244.33,34.39 C131.2 ; R431.2 243.65,35.26 243.65,35.26 243.36,35.55 v1(243,35.55) ; R431.2 243.65,34.38 243.65,34.38 C305.1 243.32,33.59 C306.1 ; C4603.2 C4606.2 140.91,77.3 C4602.2 140.91,75.82 v1(141.05,75.68) ; U2403.D5 v1(261.34,25.35) 261.34,25.36 U2403.D6 ; U2403.D5 U2403.D6 ; R68099.2 212.07,108.62 v1(213.31,107.38) ; v1(270.05,70.4) 270.26,70.61 C2748.2 ; v1(138.68,5.81) 138.71,5.84 U1000.7 ; C3302.2 236.84,84.94 237.3,84.47 R3308.2 R3356.2 237.38,83.22 v1(237.89,83.22) ; v1(21.82,20.64) 21.74,20.72 R3008.2 ; C60027.2 195.91,97.6 v1(196.14,97.83) 196.14,97.91 195.71,98.34 194.44,98.34 R60022.2 ; v1(235.66,28.72) 235.61,28.67 C1000.2 ; D2815.2 v1(275.85,82.07) ; R3505.2 221.22,54.95 220.54,54.95 v1(220.52,54.93) 220.01,55.44 220.01,55.62 219.68,55.95 C3540.2 218.8,55.95 Q2620.1 218.71,55.57 218.49,55.35 218.24,55.35 217.71,54.81 Q2620.4 ; v1(185.53,68.45) 185.6,68.52 189.15,68.52 R4555.1 ; R2623.1 v1(277.91,63.74) ; R1007.2 215.41,47.6 215.05,47.25 Q1001.4 215.76,46.19 215.76,46.19 v1(216.33,46.18) ; v1(261.19,61.7) U2700.F16 ; R4533.1 184.68,44.49 v1(184.6,44.57) ; v1(256.82,41.47) 256.61,41.65 R68105.2 256.16,40.87 R2600.2 ; CN2900.A12 280.33,66.57 v1(280.15,66.75) ; v1(189.17,18.12) 189.57,18.51 C4138.2 ; v1(257.29,64.3) U2700.N12 ; v1(118.89,71.69) 118.85,71.65 CN4920.50 ; v1(97.83,22.58) 97.81,22.6 C7545.2 97.65,23.18 97.23,23.6 C4121.2 ; v1(142.31,5.88) 141.4,6.8 R1004.2 ; 152.25,61.69 C4526.2 ; R2736.1 v1(254.89,72.79) R2735.1 ; 20.19,36.57 20.19,34.76 v1(20.7,34.25) ; R68103.2 R68102.2 ; R68102.2 244.17,25.72 v1(243.94,25.5) 243.81,25.5 R68104.2 243.27,23.67 PAD300.1 ; R68102.2 244.83,26.08 245.09,25.83 R68094.2 245.09,24.93 C68098.2 ; R2642.1 275.98,67.12 v1(275.23,67.12) 274.42,67.12 D2903.2 ; 260.56,59.77 U2700.G22 ; 260.56,59.77 U2700.F20 ; v1(183.35,22.42) 183.41,22.48 C7543.2 ; v1(157.86,95.44) 157.86,94.82 C4639.2 ; C4101.2 163.32,8.7 163.95,9.34 v1(163.95,9.64) ; v1(244.56,99.32) 244.62,99.25 R60032.2 ; R387.2 225.07,38.55 v1(225.47,38.14) ; R60349.2 156.36,11.01 v1(156.38,11.03) ; C7525.2 127.45,90.55 ; R510.1 7.18,43.56 v1(6.32,42.69) ; v1(154.57,77.04) 154.21,76.68 C4590.2 154.21,76.14 R4598.2 ; R4131.1 214.14,13.43 v1(214.59,13.87) 215.03,13.43 C4145.2 ; C4116.2 119.53,19.3 v1(119.84,18.99) ; v1(264.07,38.52) 264.94,38.52 v5(264.97,38.5) 265.05,38.57 C2613.2 ; R3006.1 25.2,17.71 v1(25.45,17.46) ; v1(197.23,100.22) 197.25,100.19 198.55,100.19 198.77,99.97 C60018.2 199.03,99.71 198.24,98.92 C60031.2 ; CN1451.G3 279.96,37.89 v1(279.96,37.15) ; v1(268.62,30.42) 268.62,29.98 268.1,29.46 C2422.2 ; R2749.2 269.47,77.23 v1(269.47,77.97) ; v1(163.95,11.01) 163.95,10.61 163.47,10.12 163.12,10.12 162.92,9.92 C4100.2 ; v1(223.72,22.22) 223.54,22.04 C4139.2 ; v1(264.15,80.67) 264.22,80.67 264.63,80.26 R68109.2 ; v1(141.42,11.01) 141.42,11.08 C4110.2 139.8,12.34 C4111.2 139.21,12.34 R4122.1 ; C60029.2 188.45,110.94 v1(188.16,110.66) 187.19,109.68 184.52,109.68 C60008.1 ; v1(242.19,97.64) R3323.2 R3339.2 ; U3001.2 v1(23.26,20.39) ; CN1451.C5 268.59,48.72 v1(268.59,48.72) ; 135.91,90.22 C7527.2 ; CN2700.4 U2703.4 243.71,60.36 U2703.9 243.73,59.62 244.93,59.62 C2747.2 ; CN1451.G4 278.67,54.01 v1(278.67,54.01) ; Q2605.4 264.47,97.13 264.7,97.35 R2615.1 ; C512.2 17.21,36.16 16.65,35.6 C513.2 16.45,35.42 v1(15.64,34.61) ; v1(277.64,77.01) 277.67,77.01 277.67,77.01 R2630.1 ; v1(182.8,68.05) 183.45,67.4 185.67,67.4 186.1,66.97 R4805.2 185.99,66.4 185.49,65.91 R4812.2 184.87,65.91 184.87,65.91 R4803.2 ; U2403.G7 U2403.F7 ; U2403.G7 U2403.H7 v1(260.31,28.3) ; C4151.2 135.96,15.02 v1(136.25,15.31) ; v1(278.45,80.02) 278.15,80.32 R2631.1 ; R66113.2 94.42,90.58 94.42,90.58 v1(94.44,90.55) ; R66160.2 C66160.2 106.24,97.94 v1(106.96,97.22) ; R4509.2 142.9,76.81 142.9,76 143.22,75.68 v1(143.49,75.68) ; C4625.1 164.13,89.5 163.87,89.75 162.25,89.75 161.65,89.15 C4529.2 161.38,89.09 v1(160.6,89.87) ; U3800.J5 205.25,78.81 v1(205.36,78.91) 205.36,79.4 204.95,79.81 U3800.G5 ; U300.J12 235.25,42.97 234.26,42.97 v1(233.99,43.24) ; C7544.2 191.75,13.91 v1(192.08,14.24) ; C4510.2 164.8,55.84 v1(164.43,56.21) ; C4518.1 170.41,75.61 v1(170.34,75.68) ; R66115.2 C66115.2 105.39,91.76 v1(105.76,91.4) ; C4119.2 121.31,13.5 v1(120.96,13.85) ; v1(162.76,28.92) 162.99,29.15 C7536.2 ; v1(193.14,44.57) 193.64,44.06 194.16,44.06 194.69,43.54 R4842.2 ; C4109.2 132.07,13.02 v1(131.36,13.73) 130.95,13.33 C4146.2 ; R4804.2 204.6,64.76 204.77,64.94 v1(205.23,64.94) ; U3300.26 242.24,88.93 v1(241.83,89.35) ; U2403.F8 v1(259.56,26.65) 259.78,26.51 259.82,26.47 U2403.E8 ; U2403.F8 U2403.E8 ; U2403.F8 U2403.F7 ; R68107.2 v1(259.17,88.2) ; C642.2 C643.2 2.75,39.88 v1(2.71,39.85) ; v1(170.2,64.64) 170.07,64.77 C4535.1 ; v1(246.53,83.88) 246.46,83.88 R3324.1 245.7,84.7 244.84,85.56 C3375.2 ; v1(273.81,95.31) 273.81,94.31 C7606.2 274.14,94.34 C7604.2 ; v1(56.03,8.96) 55.58,9.4 C7615.2 ; C4132.2 v1(212.11,10.99) ; C641.2 3.78,36.7 v1(3.07,36.7) ; v1(94.21,96.38) 94.38,96.38 C66407.1 ; U2403.E8 U2403.D8 ; C7519.2 213,98.93 v1(213,98.92) ; C4561.2 160.53,73.95 v1(160.45,74.03) 160.53,74.11 C4562.2 ; v1(222.09,46.78) 222.09,47.64 R370.2 ; v1(119.38,13.73) 119.52,13.88 C4108.2 ; C66472.1 99.57,106.8 v1(99.57,107.41) 99.57,107.95 C66172.1 ; C4141.2 195.44,13.96 v1(195.31,14.09) ; C7613.2 220.41,101.03 v1(220.42,101.03) ; v1(234.12,99.04) 233.96,98.88 R3304.2 ; C327.2 230.86,55.52 v1(230.79,55.44) ; v1(266.77,80.2) 266.77,80.37 267.03,80.63 C7611.2 ; C7614.2 54.44,23.75 v1(54.44,23.98) ; C4351.2 C7508.2 229.38,8.28 v1(229.06,8.6) ; v1(104.42,99.99) 104.87,100.44 C66197.2 R66197.1 ; v1(118.89,68.44) 118.72,68.65 CN4920.38 ; C4543.1 174.05,73.4 v1(174.29,73.4) 174.32,73.4 174.66,73.74 R4504.2 ; v1(76.25,32.32) 76.85,32.32 C7619.2 ; U300.G1 243.13,41.61 v1(243.33,41.81) ; C3006.2 52.9,9.65 52.54,9.65 v1(52.38,9.5) 52.92,8.97 R3003.2 ; v1(163.34,11.01) 162.86,10.53 C4102.2 ; v1(250.06,78.08) 251.32,78.08 252.28,77.13 252.28,76.91 252.32,76.87 R2732.1 ; R2740.1 v1(249.6,72.81) ; v1(245.01,91.1) 244.83,90.92 U3300.35 ; U300.A8 237.9,37.46 237.58,37.14 237.45,37.14 v1(236.82,36.52) ; U3800.E7 206.31,80.16 v1(206.42,80.06) 206.33,80.14 U3800.H10 ; Q1951.S 260.57,13.17 v1(260.55,13.19) ; v1(15.05,42.79) 15.05,42.38 C519.2 15.67,42.17 C518.2 ; v1(138.1,65.99) 138.1,65.32 C4568.2 ; C4104.2 164.13,18.08 v1(164.13,17.59) 163.49,17.59 163.15,17.93 C4105.2 ; v1(277.62,82.23) 277.71,82.14 R2632.1 ; R342.2 248.46,46.98 248.26,47.18 v1(247.93,47.18) 247.93,46.93 247.17,46.17 R1018.2 ; R4619.1 C1414.2 203.34,56.47 v1(203.32,56.45) ; CN4920.8 119.35,61.15 v1(119.77,60.72) ; v1(168.25,64.64) 168.01,64.41 C4541.2 C4542.2 ; v1(175.5,78.69) 174.47,77.67 R4756.2 R4505.2 ; U2700.J15 259.56,62.67 v1(259.24,62.35) U2700.J16 ; v1(166.11,11.01) 166.44,10.69 R4100.2 ; PAD310.1 250.91,39.46 v1(250.91,39.03) ; v1(191.94,71.13) 191.94,71.06 191.44,70.55 R4727.1 ; v1(175,65.53) 174.86,65.67 C4545.1 ; C4552.2 163.08,61.86 v1(163.61,62.39) 164.01,61.98 C4527.2 164.11,61.44 C4554.2 ; C4113.2 152.14,10.26 v1(151.38,11.03) ; 152.78,63.59 C4525.2 ; C4123.2 124.88,22.12 v1(125.04,22.28) ; C4148.2 184.85,13.17 v1(185.59,13.91) ; v1(230.22,8.32) 230.41,8.13 D2202.2 D2201.2 ; v1(258.59,64.3) U2700.M12 ; v1(161.18,96.09) 161.31,95.95 C7609.2 ; R4774.1 202.85,56.32 v1(202.71,56.45) 202.29,56.03 C1407.2 201.65,56.03 C1415.2 ; C7554.2 141.37,18.43 v1(141.35,18.41) ; R4518.2 166.9,56.25 v1(166.95,56.21) ; v1(233.46,22.17) 233.44,22.16 C4142.2 ; v1(224.06,98.59) 224.06,98.75 224.05,98.76 C2250.2 ; v1(187.65,64.57) 187.63,64.55 C4530.1 C4504.1 ; C7532.2 152.45,60.36 ; CN4920.2 118.28,59.64 118.54,59.39 v1(118.54,59.07) ; R3502.2 222.86,61.66 C3506.2 222.65,61.55 222.38,61.55 v1(222.15,61.79) ; v1(268.59,44.46) 268.73,44.47 D1405.2 D1401.2 ; v1(13.48,42.74) 13.2,42.45 Q500.S ; R4823.1 124.97,58.95 124.92,58.99 v1(123.97,58.99) ; R329.2 C308.2 C319.2 235.7,49.62 v1(235.94,49.38) ; Q2605.1 262.75,98.45 v1(262.97,98.68) ; U2403.F5 U2403.F4 ; v1(249.84,89.93) 250.33,89.45 R3320.2 ; v1(29.45,27.94) 29.45,28.57 C2504.2 ; v5(144.12,113.22) 144.24,113.35 C7511.2 ; v1(139.09,18.28) 137.31,20.06 C4118.2 ; R2741.1 v1(251.23,72.81) R2738.1 ; U3500.32 v1(227.64,60.14) ; v1(94.43,89.96) 94.51,89.88 R66112.2 ; v1(213.51,44.92) 214.05,45.46 Q1001.1 ; v1(241.15,45.35) U300.M3 ; v1(163.02,75.68) 163.01,75.68 C4589.2 163.4,76.42 C4512.1 ; 126.51,90.22 C7524.2 ; R380.2 231.95,35.15 231.62,34.81 v1(231.54,34.81) ; Q3800.4 194.86,72.83 194.65,73.05 194.65,73.34 194.15,73.83 Q3800.1 193.44,74.19 C3801.2 193.72,74.64 194.18,75.11 v1(194.25,75.11) 194.32,75.11 194.94,74.49 R3813.1 ; C66111.2 96.23,89.78 v1(96.66,89.36) ; R2500.1 25.8,27.62 v1(25.8,28.12) ; C4107.2 158.61,19.54 v1(158.69,19.46) ; C4150.2 206.09,14.46 v1(206.08,14.46) ; v1(247.7,66.99) 247.96,67.25 R2737.1 R2739.1 ; R2200.2 234.94,8.42 v1(235.12,8.6) ; v1(9.36,43.05) 9.41,43.05 10.31,43.95 D500.1 ; v1(21.26,19.24) 21.55,18.95 R3026.2 ; v1(212.85,56.22) 213.1,56.22 213.39,55.94 R1412.2 ; R2733.1 C2746.2 248.97,73.59 v1(248.97,72.7) ; v1(199.92,113.72) C60021.2 C60024.2 ; C60049.2 188.19,102.66 187.95,102.42 C60006.1 188.66,102.17 C60007.1 190.34,102.07 v1(191.33,103.06) ; CN4920.59 v1(121.56,74.15) ; CN4920.26 v1(118.89,65.65) ; v1(22.45,27.62) 23.4,27.62 23.71,27.93 U2501.14 ; C4127.2 C4128.2 C4125.2 C4126.2 240.31,16.47 238.93,17.85 v1(238.05,17.85) ; C4515.1 166.86,55.21 R4541.2 166.6,55.67 166.95,56.01 v1(166.95,56.21) ; U2700.F4 U2700.E4 U2700.F5 ; v1(277.24,80.52) 277.17,80.6 D2816.2 ; CN4920.49 v1(121.55,71.65) ; C314.2 C302.2 236.34,34 236.37,33.97 236.95,33.97 v1(237,34.03) ; R3007.2 224.05,102.76 v1(224.06,102.75) ; v1(166.95,56.21) 167.42,56.21 R4540.2 ; v1(128.74,16.39) 128.93,16.2 C4131.2 ; v1(201.32,97.04) 201.24,97.04 200.26,98.03 C7608.2 ; v1(4.49,42.85) 4.71,42.85 C525.1 ; v5(180.62,112.88) 180.62,112.07 C60035.2 ; v1(115.31,83.96) 115.16,83.96 114.31,83.11 R4526.2 ; v1(283.57,61.04) 283.51,60.98 283.44,60.98 283.3,60.84 282.59,60.84 CN2900.B12 282.05,60.82 281.8,61.07 CN2900.A1 ; C4501.2 151.17,55.68 C4508.2 ; R3310.2 v1(248.36,92.1) ; C4136.2 204.29,14.55 v1(204.32,14.51) ; v1(274.77,52.31) 274.77,53.48 274.25,54.01 CN1451.G2 ; v1(94.27,92.71) 94.5,92.93 R66607.2 C66607.2 ; C7627.2 C7602.2 268.71,39.22 C7601.2 268.37,39.54 v1(268.65,39.82) ; R4945.2 170.2,43.89 170.71,43.38 170.71,41.81 171.35,41.17 172.11,41.17 172.53,41.59 R4858.2 R4851.2 R4863.2 172.53,44.44 173.37,45.29 v1(173.63,45.29) ; C312.2 C311.2 248.26,45.03 248.66,45.43 v1(248.66,45.51) ; R4111.1 129.88,41.87 R4136.1 130.66,42.32 131.26,42.93 131.26,43.41 130.35,44.33 v1(130.27,44.33) ; v1(283.58,81.8) 283.43,81.95 CN2800.B1 ; v1(240.84,30.39) 240.5,30.73 C100.2 ; U2700.B12 262.56,63.97 ; CN2800.A12 280.33,82.21 v1(280.15,82.39) ; C7515.2 213.77,79.32 v1(213.63,79.18) ; R2643.1 v1(275.53,68.79) ; C7617.2 31.62,45.29 v1(31.62,44.9) ; C2781.2 272.45,73.93 272.94,74.42 272.94,75.23 272.57,75.6 C2774.2 272.37,75.64 271.57,75.64 C2773.2 270.7,75.62 C2775.2 C2776.2 269.99,76.02 v1(269.8,76.21) ; v1(158.34,92.72) 157.72,93.34 C4642.2 ; v1(123.75,113.17) 123.57,113.35 C7516.2 ; v1(172.12,62.1) 171.65,61.63 R4806.2 ; v1(13.75,35.19) 14.47,35.19 C523.2 15.63,35.54 C522.2 ; CN4920.14 118.82,62.65 v1(119,62.82) ; C7551.2 187.6,22.42 v1(187.55,22.47) ; R2425.2 249.14,23.77 C2427.2 248.47,23.76 C2423.2 247.79,23.48 247.41,23.1 C2424.2 246.88,23.5 246.88,23.94 247.29,24.35 v1(247.37,24.35) 247.44,24.35 248.28,25.19 C68099.2 248.5,25.88 R2423.2 ; C4144.2 215.8,13.66 v1(215.7,13.75) ; 134.98,90.55 C7526.2 ; R2734.1 v1(254.86,75.69) ; 263.31,74.93 C2750.2 263.31,75.25 ; R68101.2 250.44,30.24 250.69,30.49 251.09,30.49 251.42,30.16 v1(251.68,30.16) 251.9,30.16 C2420.2 C2421.2 ; Q4921.S 108.37,42.5 v1(107.57,41.7) ; v1(29.31,44.49) C524.1 ; v1(275.9,63.74) 275.5,63.74 D2901.2 ; U300.E12 235.07,40.31 234.78,40.6 v1(234.68,40.6) ; R68100.2 253.34,48.5 R68106.2 254.05,47.79 R2606.1 255.07,47.79 255.31,47.55 Q2607.1 255.93,48.08 v1(256.1,48.25) 256.26,48.25 256.4,48.39 256.72,48.39 256.94,48.61 Q2607.4 257.41,48.9 257.65,48.66 R2627.1 ; 263.31,74.32 C2751.2 263.31,74.64 ; C4134.2 v1(203.1,11) ; C2411.2 260.53,20.34 260.53,21.14 260.53,21.15 C2410.2 260.53,21.25 260.53,21.25 v1(260.53,21.86) ; v1(273.2,95.31) 273.2,94.31 C7626.2 ; CN4920.7 v1(121.55,61.15) ; 255.34,64.95 U2700.W9 ; v1(277.54,75.35) 277.59,75.39 R2629.1 ; R2503.1 v1(28.52,31.61) ; R348.2 230.3,38.26 v1(229.69,38.88) ; C4937.2 v1(125.37,73.12) ; C1406.2 C1413.2 213.53,56.46 213.15,56.83 v1(212.87,56.83) 211.95,56.83 Q1401.S ; C4500.2 146.83,56.18 v1(146.81,56.21) ; v1(248.19,75.75) 248.04,75.6 U2702.3 247.89,74.96 R2701.1 ; v1(163.32,9.64) 162.99,9.31 C4103.2 ; C7530.2 227.99,35.88 228.25,36.14 229.78,36.14 v1(229.79,36.16) ; CN4920.32 v1(118.89,67.15) ; C60026.2 156.95,116.46 v1(157.38,116.88) ; v1(274.85,68.8) 274.36,68.8 D2902.2 ; C4519.1 174.49,71.46 174.89,71.06 v1(174.89,70.71) 174.89,70.22 C4548.2 ; v1(283.49,66.25) 283.42,66.31 CN2900.B1 ; v1(204.92,81.28) 204.68,81.29 U3800.C4 ; v1(159.98,70.93) 160.04,70.99 C4565.2 ; C7528.2 136.85,90.55 ; CN4920.13 v1(121.55,62.65) ; CN4920.20 v1(119.22,64.14) ; v1(10.8,42.79) R519.1 ; C4143.2 214.74,19.59 v1(215.2,19.13) ; C2432.2 261.52,32.28 261.78,32.02 v1(262.25,32.02) ; U2700.AB14 254.09,63.05 ; D2813.2 v1(276.39,74.94) ; C2611.2 270.24,99.15 v1(270.37,99.02) 270.37,98.82 C2617.2 ; v1(143.2,22.3) 143.28,22.22 C7549.2 ; C4564.2 161.06,77.9 v1(160.94,78.03) ; R3312.2 251.69,87.46 R3305.2 250.83,87.34 v1(250.42,86.93) ; D2814.2 v1(275.85,76.94) ; U2700.N9 v1(257.94,65.6) ; C66110.2 v1(105.31,95.57) ; C66101.2 v1(106.32,91.56) ; R3342.2 v1(237.25,99.04) 237.12,99.04 R3302.2 ; R4125.2 238.6,15.09 238.2,15.5 237.83,15.5 v1(237.33,15.99)
  TOP w0.305: v1(264.07,38.52) 263.75,38.85 U2602.D3 U2602.C3 U2602.B3
  TOP w0.381: v1(159.4,56.21) 159.39,56.2 C4503.2 ; C4508.2 151.51,55.87 v1(151.84,56.21) ; 263.05,76.94 C2752.2 263.45,77.39 ; 263.06,76.01 C2753.2 263.06,75.56 ; 266.35,46.63 C2606.2 ; 267.69,46.23 C2607.2 ; v1(156.88,56.23) 156.94,56.18 C4507.2 ; v1(162.01,56.3) 161.75,56.05 C4502.2 ; 263.06,77.84 C2755.2 263.45,77.39 ; 263.06,78.75 C2754.2 263.45,79.2
  L6 w0.229: v1(120.95,48.73) 120.6,48.1 119.03,45.96 98.98,25.91 98.33,25.91 95.95,23.52 95.85,22.79 95.85,22.78 95.45,19.58 v1(95.12,19.25)
  L6 w0.254: S32.1 121.69,49.47 v1(120.95,48.73) ; v1(235.4,13.76) 236.37,13.76 236.63,14.02 236.63,15.36 237.25,15.99 v1(237.33,15.99) 237.37,16.03 237.37,18.33 233.52,22.17 v1(233.46,22.17) 232.43,22.17 230.82,23.78 228.52,23.78 227.74,24.56 225.1,24.56 224.54,25.12 213.14,25.12 213.05,25.2 202.42,25.2 201.76,25.86 199.48,25.86 187.59,37.76 178.03,37.76 172.04,43.75 172.04,47.85 170.56,49.34 170.56,50.97 170.18,51.34 170.18,51.34 170.05,51.48 170.05,51.49 169.48,52.05 v1(169.48,53.87) ; 186.83,75.21 186.55,74.93 185.61,74.93 v1(185.47,75.07) 185.47,75.22 183.97,76.71 v1(181.18,76.71) 179.82,75.36 177.28,75.36 176.94,75.7 176.94,76.96 177.62,77.64 v1(178.25,77.64) 178.99,77.64 179.21,77.42 179.61,77.42 180.01,77.82 180.01,77.85 180.25,78.09 184.87,78.09 186.22,76.73 v1(186.35,76.73) 186.4,76.73 186.83,76.3 186.83,75.21
  BOTTOM w0.076: U4555.CP2 179.52,76.23 179.52,76.01 179.4,75.89 179.4,75.74 179.2,75.53 178.67,75.53 ; 178.54,75.75 179.02,76.23 U4555.CN2
  BOTTOM w0.102: 178.67,75.53 U4555.CM4 ; U4555.T36 v1(144.29,53.95) ; v1(134.42,60.79) 134.43,60.78 136.02,60.78 U4555.B27 ; v1(181.08,64.56) 181.05,64.59 U4555.CP21 ; U4555.B23 v1(134.4,63.31) ; v1(140.39,53.13) 140.52,53.26 U4555.J36 ; U4555.AT36 156.88,53.96 ; v1(163.17,53.14) U4555.BF36 ; v1(153.08,53.16) 153.1,53.17 153.1,54.83 U4555.AK36 ; v1(155.62,53.15) U4555.AP36 ; U4555.B25 v1(135.23,62.06) ; v1(181.1,72.15) U4555.CP9 ; U4555.B31 134.16,58.28 v1(133.53,57.66) ; v1(148.03,53.14) 148.03,53.18 148.07,53.22 U4555.AB36 ; 178.48,75.75 178.54,75.75 ; U4555.BD36 161.91,53.96 ; v1(145.34,53.19) 145.55,53.4 U4555.V36 ; v1(135.22,59.53) 135.24,59.53 135.25,59.54 U4555.B29 ; v1(158.14,53.07) U4555.AV36 ; v1(174.5,53.9) 174.5,54.69 U4555.CE36 ; v1(143.04,53.06) U4555.P36 ; v1(141.78,53.95) U4555.L36 ; U4555.BB36 v1(160.65,53.07) ; U4555.AF36 v1(150.59,53.19)
  BOTTOM w0.114: 138.1,57.88 U4555.E33 ; U4555.E29 138.1,58.68
  BOTTOM w0.127: U4555.CP19 181.77,65.85 181.79,65.83 v1(181.84,65.83) ; U4555.CP13 180.08,69.68 v1(181,69.68) ; U4555.CP11 182.02,70.89 182.14,70.76 182.14,70.75 v1(182.16,70.73) ; U4555.CP15 182.49,68.37 v1(182.8,68.05) ; v1(172.78,77.81) U4555.CB2 ; v1(175.5,78.69) 175.22,78.42 U4555.CF2 ; U4555.CM37 178.69,54.81 178.4,55.11 178.25,55.25 178.25,55.53 178.66,55.94 178.86,55.94 179.04,56.13 179.51,56.13 U4555.CP35 179.49,55.48 179.49,54.68 U4555.CN37
  BOTTOM w0.146: 138.1,57.88 U4555.E31 138.1,58.68
  BOTTOM w0.15: v1(178.4,58.19) 178.17,57.77 178.17,57.44 U4555.CM33
  BOTTOM w0.152: U4555.CL2 178.1,76.64 178.1,76.12 178.46,75.75 178.48,75.75 U4555.CM4 ; 211.35,51.29 211.91,50.73 X4750.2 ; 211.35,51.29 204.39,51.29 C4788.1 203.71,51.31 203.06,51.31 202.67,50.92 202.67,50.05 203.35,49.37 203.35,49.37 v1(203.55,49.37) ; 211.35,51.29 212.62,51.29 212.99,51.29 213.14,51.14 213.14,49.42 212.98,49.27 211.48,49.27 ; v1(204.57,49.37) 204.67,49.27 211.48,49.27 ; 261.84,57.93 263.06,57.93 ; 211.48,49.27 212.04,49.83 X4750.3
  BOTTOM w0.16: U4555.CR2 180.34,76.7 180.17,76.54 U4555.CP2
  BOTTOM w0.178: U4555.V33 145.51,56.85 144.34,56.85 U4555.T33 ; v1(168.24,53.46) 168.21,53.5 168.21,54.8 ; U4555.BT36 169.41,54.9 169.41,54.01 169.44,53.98 169.44,53.91 v1(169.48,53.87) ; U4555.BM36 166.91,54.92 166.91,54.06 166.87,54.02 v1(166.84,54.02)
  BOTTOM w0.18: v1(166.33,62.4) 166.34,62.38 U4555.BL25 ; v1(146.01,70.89) 146.13,71.01 U4555.W10 ; v1(161.37,72.76) U4555.BC8 ; v1(160.87,62.39) U4555.BC25 ; U4555.CF2 U4555.CF3 ; v1(158.6,74.03) 158.5,73.99 U4555.AV6 ; U4555.BE10 v1(162.76,70.74) ; v1(168.25,66.32) U4555.BP19 ; v1(163.61,62.39) U4555.BG25 ; v1(154.65,70.84) 154.6,70.84 154.44,70.99 U4555.AM10 ; v1(157.21,70.88) U4555.AU10 ; v1(148.99,70.93) 148.9,71.02 U4555.AC10 ; U4555.BK10 165.53,71.03 v1(165.41,70.91) ; v1(159.98,70.93) U4555.BA10 ; U4555.AV8 v1(158.6,72.76) ; U4555.AN25 v1(155.4,62.39) ; U4555.BK3 U4555.BK2 v1(165.46,77.76) ; U4555.B7 v1(135.62,73.41) ; U4555.AV25 v1(158.14,62.39) ; U4555.P10 v1(143.36,70.72) ; U4555.BA6 v1(160.45,74.03) ; U4555.CP27 181.78,60.8 v1(181.82,60.76) ; U4555.AG10 v1(151.67,70.98) ; U4555.CB2 U4555.CB3
  BOTTOM w0.2: v1(174.11,70.51) 174.11,70.42 U4555.CD12 ; U4555.AH30 v1(151.3,58.58) U4555.AH31 ; U4555.K3 v1(141.05,75.68) U4555.K4 ; U4555.G9 139.1,72.06 138.75,71.71 v1(138.75,71.64) ; U4555.K32 v1(140.36,57.95) U4555.K31 ; v1(168.9,63.8) U4555.BR22 ; v1(164.06,59.85) U4555.BH28 ; U4555.Y30 v1(146.74,58.55) ; U4555.P4 v1(143.49,75.68) U4555.P3 ; v1(170.2,64.64) 169.95,64.96 U4555.BU20 ; v1(165.07,73.4) U4555.BJ7 ; v1(167.9,75.68) U4555.BP3 ; U4555.AF4 v1(150.81,75.68) U4555.AF3 ; v1(154.95,59.22) U4555.AN29 ; v1(136.15,65.99) 136.34,66.27 U4555.B18 ; U4555.V30 144.97,58.61 v1(144.92,58.62) ; U4555.B25 U4555.C25 U4555.D25 ; U4555.BR19 v1(168.25,66.32) ; U4555.V4 v1(145.93,75.68) U4555.V3 ; U4555.CM29 v1(178.94,59.79) U4555.CN29 ; U4555.AB30 v1(147.66,58.58) ; v1(140.56,71.69) 140.86,72.04 U4555.K9 ; v1(177.36,68.7) U4555.CJ14 ; U4555.R28 v1(143.1,59.85) ; U4555.F4 U4555.F3 ; U4555.D6 U4555.D5 v1(137.27,74.63) U4555.C4 U4555.B5 ; U4555.BV3 v1(170.34,75.68) U4555.BV4 ; U4555.R31 v1(143.1,58.58) U4555.R30 ; U4555.T27 v1(144.01,60.48) ; U4555.B9 v1(136.15,71.64) ; v1(158.59,59.22) U4555.AW29 ; v1(150.39,58.58) 150.39,58.58 U4555.AF30 ; U4555.AP3 v1(155.7,75.68) U4555.AP4 ; U4555.CP13 U4555.CN13 ; v1(163.15,59.85) U4555.BG28 ; U4555.CM37 U4555.CN37 U4555.CP37 ; v1(154.9,74.67) U4555.AM5 ; U4555.AH28 v1(151.3,59.85) ; U4555.AH29 v1(151.3,59.22) ; v1(154.04,59.85) U4555.AM28 ; U4555.BW15 v1(171.5,68) U4555.BY15 U4555.CA15 ; U4555.BY18 U4555.BY19 v1(172.15,65.48) ; U4555.C9 v1(136.8,71.64) ; U4555.E33 v1(137.49,57.02) ; U4555.B12 v1(136.15,70.7) ; v1(165.88,57.95) U4555.BL31 ; U4555.CN25 v1(178.94,62.31) U4555.CM25 ; v1(178.4,58.19) U4555.CM31 ; v1(177.36,70.74) U4555.CJ11 ; U4555.BV31 v1(171.34,57.95) ; v1(172.26,59.85) U4555.BY28 ; v1(145.83,58.58) 146.21,58.78 U4555.W30 ; U4555.K28 v1(140.36,59.85) ; U4555.CF3 v1(175.22,75.68) U4555.CF4 ; v1(153.12,59.22) U4555.AL29 ; U4555.U7 v1(145.67,73.4) ; U4555.R29 v1(143.1,59.22) ; v1(175,65.53) 175.25,65.79 U4555.CF19 ; v1(176.82,60.45) 176.89,60.38 177.03,60.38 U4555.CJ28 ; v1(140.05,65.99) 140.24,66.27 U4555.J18 ; U4555.CB4 v1(172.78,75.68) U4555.CB3 ; v1(153.06,73.4) U4555.AJ7 ; v1(169.68,74.67) U4555.BT5 ; U4555.AB7 v1(148.44,73.4) ; U4555.B21 U4555.C21 ; U4555.CJ36 U4555.CJ35 177.01,56.18 v1(177.01,56.3) U4555.CJ33 ; U4555.AB4 v1(148.37,75.68) U4555.AB3 ; v1(158.59,59.85) U4555.AW28 ; v1(138.1,67.87) U4555.F15 ; U4555.Y27 v1(146.74,60.46) ; v1(174.12,57.91) 174.11,57.94 U4555.CC31 ; U4555.J15 v1(140.05,68.82) ; v1(159.5,59.85) U4555.BA28 ; v1(160.42,59.22) U4555.BC29 ; U4555.CL2 178.27,76.74 U4555.CM1 ; v1(145.83,60.46) U4555.W27 U4555.V26 ; U4555.CM13 v1(178.94,69.87) ; U4555.CP21 179.94,64.59 179.93,64.6 179.48,64.6 179.47,64.59 U4555.CN21 ; v1(174.12,59.83) U4555.CC28 ; v1(137.49,59.54) U4555.E29 ; U4555.CD25 174.1,62.12 ; 174.1,62.12 U4555.CC25 ; 174.1,62.12 U4555.CD24 ; U4555.AC27 v1(148.57,60.49) ; U4555.R27 v1(143.1,60.46) ; v1(162.24,59.85) U4555.BE28 ; U4555.AE30 v1(149.48,58.58) ; U4555.BL29 166.03,59.3 v1(165.88,59.22) ; U4555.AC30 v1(148.57,58.56) ; U4555.D8 U4555.D9 137.63,71.78 v1(137.46,71.62) 137.82,71.61 U4555.E9 ; U4555.CF11 174.89,70.86 v1(174.89,70.71) ; U4555.U26 U4555.V27 v1(144.92,60.46) ; U4555.AK4 v1(153.26,75.68) U4555.AK3 ; U4555.AL28 v1(153.12,59.85) U4555.AJ28 ; v1(163.02,75.68) U4555.BF3 ; U4555.T7 v1(144.74,73.4) ; v1(178.94,64.83) U4555.CM21 ; U4555.CA11 U4555.CB11 ; v1(138.1,65.99) 138.29,66.27 U4555.F18 ; U4555.B15 v1(136.15,68.82) ; U4555.T30 v1(144.01,58.56) ; U4555.BK7 v1(165.99,73.4) ; U4555.BY22 v1(172.15,63.8) U4555.CA22 ; v1(156.77,59.22) U4555.AU29 ; v1(164.06,59.22) U4555.BH29 ; v1(156.77,59.85) U4555.AU28 ; v1(174.1,67.16) U4555.CC16 ; U4555.CP9 U4555.CN9 ; U4555.CB18 173.45,66.32 U4555.CB19 ; U4555.J12 v1(140.05,70.7) ; v1(165.88,59.85) U4555.BL28 ; U4555.AB27 v1(147.66,60.49) ; v1(162.24,59.22) U4555.BE29 ; U4555.K30 v1(140.36,58.58) ; U4555.K29 v1(140.36,59.22) ; U4555.F12 v1(138.1,70.7) ; U4555.AF7 v1(151.21,73.4) ; U4555.CM9 178.52,72.15 v1(178.95,72.39) ; v1(175.9,59.85) U4555.CF28 ; v1(155.86,59.85) U4555.AR28 ; v1(161.33,59.85) U4555.BD28 ; v1(165.88,58.58) U4555.BL30 ; U4555.CJ19 177.36,65.58 v1(177.41,65.55) ; U4555.P7 v1(143.82,73.37) ; U4555.BU16 v1(170.2,67.16) ; U4555.BK3 v1(165.46,75.68) ; v1(140.61,62.21) U4555.J24 ; v1(154.95,59.85) U4555.AN28 ; v1(157.68,59.85) U4555.AV28
  BOTTOM w0.203: U4555.B36 U4555.B37 ; U4555.B37 U4555.C37 U4555.C36 ; U4555.B37 136.16,54.41 134.74,54.41 v1(134.7,54.44) ; U4555.BT33 v1(169.46,56.21) U4555.BT35 U4555.BT36 ; U4555.BT33 169.44,56.83 168.71,56.83 168.68,56.81 U4555.BP33 ; U4555.BT33 169.49,56.83 170.22,56.83 170.24,56.81 U4555.BV33 171.2,56.81 171.23,56.83 171.95,56.83 U4555.BY33 v1(171.98,56.19) U4555.BY35 U4555.BY36 ; U4555.Y33 146.85,56.85 148.03,56.85 U4555.AB33 148.11,56.85 149.28,56.85 U4555.AD33 v1(149.33,56.21) U4555.AD35 ; U4555.Y33 v1(146.81,56.21) 146.81,55.6 U4555.Y35 ; U4555.Y33 146.77,56.85 145.6,56.85 U4555.V33 ; U4555.AK33 v1(153.13,57.3) U4555.AL32 ; U4555.AK33 152.59,56.81 152.52,56.87 152.32,56.87 152.25,56.81 U4555.AH33 v1(151.84,56.21) U4555.AH35 ; U4555.AK33 153.52,56.81 153.56,56.84 153.96,56.84 153.99,56.81 U4555.AM33 v1(154.36,56.21) U4555.AM35 ; U4555.AT33 v1(156.77,57.31) U4555.AU32 ; U4555.AT33 v1(156.88,56.23) U4555.AT35 U4555.AT36 ; U4555.AT33 157.23,56.81 157.28,56.85 158.09,56.85 U4555.AV33 158.23,56.9 159.3,56.9 U4555.AY33 v1(159.4,56.21) U4555.AY35 ; U4555.CJ2 U4555.CJ3 U4555.CJ4 ; U4555.BP33 168.21,57.49 U4555.BP32 ; U4555.BP33 167.73,56.81 167.7,56.83 166.97,56.83 U4555.BM33 v1(166.95,56.21) U4555.BM35 U4555.BM36 ; U4555.L33 141.81,56.84 143,56.84 U4555.P33 143.09,56.87 144.23,56.87 U4555.T33 v1(144.29,56.21) U4555.T35 U4555.T36 ; U4555.L33 v1(141.78,56.21) U4555.L35 U4555.L36 ; U4555.L33 141.75,56.84 141.02,56.84 140.99,56.81 U4555.J33 ; v1(139.17,54.02) 139.17,54.86 U4555.G36 U4555.G35 ; v1(137.49,59.54) U4555.C29 U4555.B29 ; v1(141.97,74.03) U4555.L6 ; U4555.K32 140.79,57.53 140.52,57.26 U4555.J33 ; U4555.BP36 168.21,54.8 ; U4555.B21 136.07,64.75 v1(134.18,64.75) ; v1(142.89,74.03) U4555.N6 ; v1(141.05,74.03) U4555.J6 ; U4555.CE36 U4555.CE35 v1(174.5,56.21) U4555.CE33 174.46,56.84 173.73,56.84 173.69,56.81 U4555.CB33 ; U4555.BH33 164.47,56.85 165.2,56.85 165.24,56.81 U4555.BK33 ; U4555.BH33 v1(164.43,56.21) U4555.BH35 ; U4555.BH33 v1(164.06,57.28) U4555.BH32 ; U4555.J33 140.05,56.81 140.01,56.84 139.34,56.84 U4555.G33 U4555.F33 v1(138.35,56.28) U4555.E35 v1(137.7,55.91) ; U4555.BD36 U4555.BD35 161.91,56.21 v1(162.01,56.3) 161.91,56.4 U4555.BD33 161.87,56.85 160.98,56.85 160.94,56.81 U4555.BB33 v1(160.42,57.28) U4555.BC32 ; U4555.BN7 U4555.BL7 v1(165.99,73.4) ; v1(141.04,74.67) U4555.J5 ; U4555.CJ33 176.93,56.85 176.66,56.85 176.64,56.87 176.24,56.87 176.19,56.81 U4555.CG33 ; U4555.CH31 v1(176.86,57.88) ; U4555.BW24 U4555.BY25
  BOTTOM w0.229: v1(186.35,76.73) 187.29,77.67 v1(187.58,77.67) 187.89,77.35 192.09,77.35 192.24,77.2 v1(192.24,75.31)
  BOTTOM w0.254: v1(221.61,53.08) 221.84,53.3 C4764.2 222.48,53.3 C4766.2 ; v1(247.29,10.86) 247.29,12.56 CN1951.G1 ; v1(144.22,18.12) 144.7,18.6 144.7,19.14 145.13,19.56 CN4100.193 ; v1(207.24,3.88) 207.32,3.8 CN4750.G2 ; CN4125.192 220.59,12.37 220.59,13.73 v1(220.5,13.82) ; CN300.G2 v1(26.06,9) ; v1(149.73,100.65) 149.73,101.3 C66616.2 ; v1(231.12,16.49) 232.33,17.69 CN4125.239 ; U4555.CD14 v1(174.06,68.84) U4555.CC14 ; U4555.CD14 U4555.CF14 ; U4555.CD14 174.64,69.48 174.64,69.88 U4555.CD12 ; v1(69.11,16.75) 69.11,16.07 69.53,15.65 CN1300.G1 ; CN4125.90 193.09,12.37 193.09,13.58 193.3,13.79 193.78,13.79 v1(193.81,13.82) 194.09,13.54 194.09,12.37 CN4125.94 ; v1(123.97,58.99) v1(123.27,58.99) ; C7400.2 213.63,70.05 v1(214.02,69.86) ; U4555.BP7 168.07,73.4 v1(167.84,73.44) 167.61,73.4 U4555.BN7 ; CN375.24 v1(261.8,36.49) ; U1400.B1 U1400.A2 U1400.A3 ; U1400.B1 U1400.C1 210.43,63.1 210.26,62.93 v1(210.03,62.93) ; U1400.B1 210.83,63.76 210.86,63.76 210.93,63.84 C7507.2 ; v1(103.27,57.07) 103.27,57.09 103.46,57.28 R60523.2 ; D2818.2 v1(275.85,76.94) ; v1(225.38,18.18) 224.83,18.73 CN4125.209 ; CN3000.G5 21.5,38.74 v1(21.38,38.62) ; CN4125.31 178.33,22.07 v1(178.73,22.47) 179.33,21.87 CN4125.35 ; R4534.2 134.41,86.38 v1(134.43,86.4) 134.43,86.35 135.04,85.74 R4597.2 ; C6037.2 233.15,79.14 233.24,79.04 233.24,79.03 233.39,78.88 233.9,78.88 234.27,79.25 C6038.2 ; C6037.2 233.02,79.42 233.02,79.86 232.86,80.01 C7623.2 ; C6037.2 232.71,78.85 v1(232.71,78.35) ; R2708.1 257.67,60.65 v1(257.28,61.04) ; v1(211.86,86.27) 211.99,86.4 C7000.2 C7004.1 211.35,87.86 211.1,88.1 209.76,88.1 C7005.1 ; C60259.2 190.85,95.81 190.27,96.38 U60250.18 v1(190.27,97.83) ; v1(260.55,13.19) 260.65,13.09 CN1951.51 ; C2766.2 259.99,69.91 v1(259.64,69.56) 259.36,69.85 C2782.2 ; CN4100.82 115.38,14.31 116.32,15.22 116.41,15.22 v1(116.44,15.25) ; U4555.AJ28 152.67,60.14 152.47,60.35 ; v1(221.51,68.77) 221.51,71.02 R3023.2 ; v1(160.42,57.28) 160.01,56.88 159.84,56.88 159.77,56.81 U4555.AY33 ; CN6050.G2 73.25,19.14 73.94,19.83 v1(74.39,19.83) ; CN4941.G2 263.62,49.04 v1(264.61,48.05) ; U4555.BU16 169.69,67.76 169.41,67.76 169.23,67.58 U4555.BT16 ; U66020.19 120.39,104.32 v1(120.53,104.32) 120.61,104.32 C66027.2 ; v1(6.32,42.69) 6.25,42.76 CN2500.21 ; CN2501.G1 9.2,33.7 v1(9.2,33.69) ; C321.2 223.67,56.06 v1(224.18,56.58) ; v1(221.05,7) 221,7.05 CN4350.14 ; CN4125.73 188.83,19.63 188.6,19.41 188.6,17.26 ; R1332.2 v1(59.05,21.57) ; v1(214.69,92.01) C7013.1 214.44,91.5 C7012.2 213.45,91.82 R7029.1 ; CN4125.5 171.83,18.87 v1(171.65,18.69) ; v1(169.28,18.79) 169.28,19 169.69,19.42 170.15,19.42 170.83,20.09 CN4125.1 ; U4555.BM9 166.91,71.47 167.54,70.85 167.54,70.78 167.64,70.69 v1(167.58,70.53) 167.92,70.24 U4555.BP12 ; R2640.2 v1(275.9,63.74) ; CN1951.33 256.15,12.03 v1(256.15,13.19) ; v1(212.85,55.61) 212.16,55.61 211.25,54.71 CN1400.51 ; CN4125.230 230.09,12.37 v1(230.09,13.72) ; v1(160.77,87.33) 160.92,87.48 C7025.2 161.44,87.51 161.44,88.21 C7027.2 ; 222.81,36.82 223.11,36.51 224.01,36.51 225.47,37.98 v1(225.47,38.14) ; v1(161.92,53.94) 161.92,53.95 161.91,53.96 ; v1(236.33,52.65) 236.54,52.85 CN367.4 236.52,53.54 U367.4 ; v1(194.48,96.59) 194.09,96.19 C60280.2 ; CN375.G2 265.7,34.79 266.44,34.05 266.44,32.07 v1(266.52,31.99) ; U60900.14 166.49,99.01 166.68,98.81 168.18,98.81 168.57,98.42 C60909.2 ; CN1951.45 v1(259.15,13.19) ; v1(210.84,3.88) 210.92,3.8 CN4750.G1 ; C3003.2 52.73,7.6 U3000.2 52.73,9.15 v1(52.38,9.5) ; 199.49,65.93 199.87,65.93 200.48,65.32 R7003.2 ; 199.49,65.93 199.49,66.67 199.34,66.82 198,66.82 Q7300.4 ; 199.49,65.93 199.49,65.4 199.11,65.02 199.11,64.67 199.49,64.3 v1(199.49,64.23) 199.49,63.24 ; Q307.1 214.52,4.13 214.3,4.34 214.01,4.34 213.52,4.84 Q307.4 v1(213.52,5.79) ; v1(124.2,88.57) 124.2,87.19 123.95,86.93 U4411.5 ; CN4125.227 229.33,22 229.79,22.46 v1(230.23,22.46) 230.33,22.37 CN4125.231 ; U66010.19 147.88,103.31 v1(147.97,103.21) 148.03,103.15 C66017.2 ; CN4100.31 102.63,18.42 103.09,17.96 v1(103.27,17.96) ; CN4125.9 172.83,18.45 v1(172.95,18.32) ; CN4125.93 193.83,22.34 v1(193.81,22.36) ; 117.13,22.84 117.2,22.84 118.13,21.91 CN4100.93 ; D2603.2 286.04,64.17 v1(286.88,64.17) ; C2761.2 257.97,61.67 v1(257.94,61.7) ; CN2701.15 251.37,72.95 v1(251.23,72.81) ; v1(219.59,13.79) 219.59,12.37 CN4125.188 ; 115.26,88.51 C7561.2 114.7,88.41 ; v1(263.98,60.19) 263.75,59.96 C2779.2 R2721.1 ; U4555.BY25 v1(172.12,62.1) U4555.CA25 v1(172.81,62.1) ; 156.88,53.96 156.89,53.95 v1(156.89,53.94) ; v1(153.6,19.36) 153.6,19.4 153.63,19.42 CN4100.227 ; CN4125.252 235.58,13.55 235.4,13.72 v1(235.4,13.76) ; v1(213.49,93.87) 213.57,93.79 C7001.2 214.02,94.68 U7000.3 ; C61402.2 173.2,89.56 v1(173.2,88.76) ; v1(158.69,19.46) 158.63,19.52 CN4100.247 ; U4555.AL7 v1(153.96,73.4) ; U1400.D3 209.53,62.46 209.56,62.46 210.02,62.93 v1(210.03,62.93) ; U1400.D3 209.23,62.17 209.23,62.14 209.22,62.12 209.22,61.87 209.11,61.77 C7506.2 ; U1400.D3 209.51,62.33 209.73,62.11 C7505.2 ; CN6050.G1 88.95,15.97 v1(88.74,15.76) ; v1(217.52,73.53) 217.19,73.85 R7401.2 216.55,74.1 216.98,74.53 C7401.2 ; C66617.2 155.4,101.58 v1(155.34,101.64) 155.25,101.74 U66610.11 ; v1(141.35,14.8) 140.88,14.32 CN4100.176 ; C4767.1 204.52,49.32 v1(204.57,49.37) ; CN4125.251 235.33,19.53 v1(235.43,19.43) ; U4555.CE7 v1(174.29,73.4) U4555.CC7 U4555.CB7 ; v1(54.44,23.98) 54.44,24.46 54.18,24.72 U1300.3 ; CN4100.226 v1(153.38,11.03) ; CN1300.33 v1(69.79,24.75) ; v1(154.85,17.99) 155.63,18.76 CN4100.235 ; CN4125.61 185.83,22.03 185.48,22.37 v1(184.62,22.37) 184.83,22.16 CN4125.57 ; C7534.2 144.34,116.47 ; R2731.1 R2700.1 252.56,65.95 v1(252.47,65.86) ; v1(117.34,83.89) 117.25,83.98 C4411.2 ; R68122.2 208.29,113.79 v1(208.31,113.77) 208.31,113.07 R68121.2 209.05,113.01 C68052.2 ; v1(94.31,101.5) 94.35,101.54 C66672.1 ; U4555.CR6 v1(180.98,74.08) ; C2815.2 283.03,79.75 282.11,78.83 D2605.2 281.67,78.11 D2806.2 ; R60201.1 243.39,75.33 v1(243.42,75.3) 243.42,74.59 242.84,74 242.63,74 242.23,73.6 C60217.2 242.36,73.55 v1(242.77,73.14) 242.29,72.66 C60209.2 ; v1(169.68,72.76) U4555.BU7 v1(170.61,72.76) U4555.BW7 ; v1(212.66,53.53) 212.67,53.53 212.75,53.46 CN1400.57 ; v1(243,79.9) 243,80.17 C60048.2 ; v1(107.3,56.13) 107.3,56.47 106.99,56.78 R60529.1 ; v1(106.2,22.4) 104.88,22.4 104.63,22.15 CN4100.39 ; CN4100.26 v1(101.38,13.72) ; CN1400.3 199.25,51.25 199.43,51.07 199.79,51.07 199.97,51.25 199.97,51.26 ; v1(141.35,18.41) 141.35,18.43 142.13,19.21 CN4100.181 ; R4811.2 193.77,73.27 193.77,74.7 194.18,75.11 v1(194.25,75.11) ; CN1300.7 v1(69.7,18.25) ; v1(215.2,19.13) 215.33,19.26 CN4125.171 ; CN4100.223 152.63,19.6 v1(152.15,19.12) ; C2900.2 282.53,64.79 D2615.2 D2619.2 ; v1(164.97,59.85) U4555.BK28 ; v1(211.86,85.05) 211.6,84.79 C7007.2 C7002.1 ; v1(213.31,107.38) 213.31,107.76 211.94,109.12 Q68098.S ; TP6052.1 77.62,27.01 C2501.2 ; C66037.2 131.58,103.97 v1(131.19,103.97) 131.06,103.97 U66030.19 ; R4576.1 190.37,61.2 190.36,61.2 190.3,61.27 v1(190.11,61.27) ; v1(86.1,38.95) 86.61,38.95 87.21,38.35 CN4300.G1 ; Q7307.1 158.96,88.18 159.21,87.92 v1(159.48,87.92) 159.48,88.8 160.02,89.34 Q7307.4 160.31,89.58 v1(160.6,89.87) ; CN4941.10 258.62,47.8 258.33,48.08 v1(257.93,48.08) 257.62,47.76 CN4941.8 ; CN3000.G3 23.33,27.62 v1(22.45,27.62) ; CN4100.230 v1(154.38,13.72) ; CN2200.4 234.75,8.28 234.82,8.35 234.82,8.35 235.07,8.6 v1(235.12,8.6) ; v1(213.63,79.18) 213.55,79.1 211.39,79.1 Q7002.1 211.22,79.56 210.88,79.9 210.45,79.9 210.21,80.14 Q7002.4 ; C60016.2 v1(175.5,116.6) ; CN4125.234 231.09,12.37 v1(231.09,13.75) ; U4555.U24 U4555.U26 ; CN4750.2 v1(208.73,7.58) ; CN1951.27 254.65,12.03 v1(254.65,13.19) ; C2772.2 255.86,58.39 v1(255.92,58.33) ; R1333.1 v1(60.58,24.02) ; C7501.1 86.58,28.36 v1(86.53,28.31) 86.49,28.36 C7500.1 ; C7024.2 207.66,77.02 206.5,78.18 203.79,78.18 C3800.2 203.67,78.13 203.2,78.59 203.2,79.54 C3802.2 203.35,80.05 203.5,80.2 v1(204.16,80.2) ; v1(156.11,1.67) 156.11,1.67 R60346.1 R60302.1 ; C7556.2 183.16,103.19 ; v1(218.72,62.77) 219.42,63.47 C1404.1 C1403.1 ; v1(141.29,61.31) U4555.K27 ; v1(141.29,61.31) 141.02,61.58 U4555.K25 v1(141.31,62.23) 141.02,62.52 U4555.K24 v1(141.32,63.3) 141.02,63.61 U4555.K22 ; v1(141.29,61.31) U4555.L27 ; U4555.K27 v1(141.28,60.49) U4555.L27 ; U4555.K27 v1(140.36,60.49) U4555.H27 v1(139.45,60.49) U4555.G27 v1(138.54,60.49) U4555.E27 ; U60400.2 v1(196.67,5.27) ; C7023.2 158,97.33 158,95.58 v1(157.86,95.44) ; v1(248.97,72.7) 248.87,72.8 CN2701.G2 ; v1(191.25,17.82) 190.84,18.24 190.84,20.81 CN4125.81 ; CN375.G3 247.2,38.25 246.1,37.15 v1(246.1,36.97) ; v1(286.8,62.19) 286.36,62.63 D2618.2 ; CN2500.9 v1(12.25,42.74) ; C2768.2 260.62,58.27 v1(260.56,58.34) 260.12,58.78 C2769.2 ; CN4100.18 99.38,13.41 99.01,13.78 99.01,14.74 v1(99.53,15.26) ; C1301.2 C1305.2 46.94,26.18 v1(46.94,27.01) ; CN4125.G2 237.88,28.72 v1(235.66,28.72) ; v1(274.85,68.8) 274.36,68.8 D2902.2 ; C7402.1 R7412.1 211.26,75.07 Q7011.S 210.75,74.56 U7400.4 ; v1(131.72,102.3) 132.44,102.3 C66034.2 ; CN4125.176 216.58,13.94 217.09,14.46 v1(217.13,14.46) 217.59,13.99 217.59,12.37 CN4125.180 ; v1(256.64,66.25) 256.57,66.18 C2757.2 ; U4555.CC24 v1(173.45,62.1) ; v1(139.6,15.21) 139.62,15.21 140.08,14.74 140.08,14.34 139.88,14.14 CN4100.172 ; v1(224.09,13.72) 224.09,12.37 CN4125.206 ; CN4100.210 v1(149.38,11.03) ; CN4941.12 259.62,48.16 259.05,48.73 v1(259,48.73) ; 204.44,68.41 204.19,68.15 U4700.3 ; 204.44,68.41 204.81,68.04 204.81,67.84 204.96,67.7 205.67,67.7 206.27,68.29 R4564.2 ; 204.44,68.41 204.44,68.96 R4713.2 204.21,69.18 204.21,69.93 Q4751.1 204.17,70.27 203.97,70.47 203.51,70.47 203.17,70.81 Q4751.4 203.17,72.07 203.4,72.29 v1(203.4,72.37) 203.35,72.41 R4724.1 ; U4555.CK1 177.74,77.16 v1(178.25,77.64) 178.69,77.17 U4555.CM1 ; v1(221.59,97.4) 221.71,97.4 222.32,96.79 R3036.1 222.32,96.61 221.15,95.44 219.99,95.44 ; v1(183.83,14.45) 183.59,14.2 183.59,12.37 CN4125.52 ; CN4125.40 v1(180.58,13.86) ; v1(195.31,14.09) 195.09,13.86 195.09,12.37 CN4125.98 ; v1(155.88,73.45) U4555.AN7 ; CN4125.214 226.09,12.37 v1(226.09,13.81) ; v1(263.98,61.21) 263.95,61.18 C2780.2 R2723.1 ; v1(278.51,50.02) 279.45,49.07 ; 279.45,49.07 279.37,48.99 C1451.2 ; 279.45,49.07 C1452.2 ; CN4125.222 228.09,12.37 228.09,13.95 v1(227.64,14.4) 227.54,14.4 227.09,13.95 227.09,12.37 CN4125.218 ; CN3000.37 17.05,35.75 CN2501.G2 16.8,35.23 16.18,34.61 v1(15.64,34.61) ; v1(286.68,78.22) 286.64,78.26 286.19,78.26 286.19,78.26 285.6,78.26 D2604.2 ; D1451.2 279.84,50.4 279.59,50.65 v1(278.49,50.65) ; 47.16,21.29 46.78,21.29 R399.1 ; 47.16,21.29 47.16,20.01 Q303.1 46.81,19.95 46.59,19.73 46.59,19.16 46.38,18.95 Q303.4 ; 47.16,21.29 R402.1 47.67,21.29 v1(48.16,21.78) ; CN4125.226 229.09,12.37 v1(229.09,13.73) ; R4523.2 133.62,84.96 v1(133.62,86.4) ; 220.21,98.24 219.65,98.24 219.05,97.63 R4510.1 ; 220.21,98.24 220.97,98.24 R3035.1 221.74,98.93 222.47,99.65 C2251.2 222.84,99.94 v1(222.84,100.25) ; 220.21,98.24 U3002.2 ; v1(164.06,57.28) 163.59,56.81 U4555.BF33 162.75,56.81 162.58,56.98 162.08,56.98 U4555.BD33 ; U4555.BR16 U4555.BP15 v1(167.34,67.84) ; v1(49.16,9.39) 49.85,9.39 CN300.G1 ; v1(136.36,98.68) 136.55,98.87 C66036.2 ; 199.97,51.26 201.03,51.26 201.25,51.48 CN1400.11 ; 199.97,51.26 199.75,51.48 CN1400.5 199.75,53.44 v1(199.84,53.53) ; CN4100.197 146.13,18.71 146.52,18.32 146.54,18.32 v1(146.58,18.28) 146.59,18.28 147.13,18.82 CN4100.201 ; 261.84,57.93 261.49,57.57 261.49,54.98 263.34,53.13 v1(265.02,53.13) v1(268.22,53.13) 268.6,53.51 268.6,57.47 v1(268.22,57.47) v1(265.02,57.47) 263.52,57.47 263.06,57.93 ; C60116.2 231.37,74.69 v1(231.9,74.69) ; U4555.L27 v1(142.19,60.46) U4555.N27 ; U4555.BB3 v1(160.58,75.68) U4555.BB4 ; C3152.2 C3150.2 v1(273.2,95.31) ; v1(193,22.36) 192.83,22.19 CN4125.89 ; v1(277.54,75.35) 277.59,75.39 R2616.2 ; v1(175.56,22.39) 175.25,22.08 174.54,22.08 174.33,21.87 CN4125.15 ; C60616.2 110.02,92.32 v1(109.67,92.32) ; C61700.2 232.91,90.54 v1(233.07,90.37) ; C2767.2 259.1,62.49 v1(259.24,62.35) 259.28,62.3 C2759.2 ; C1002.2 261.67,1.67 v1(261.59,1.59) Q1004.S ; v1(215.7,13.75) 215.58,13.62 CN4125.172 ; v1(191.01,14.41) 191.09,14.33 191.09,12.37 CN4125.82 191.08,11.33 190.86,11.12 190.29,11.12 190.08,11.33 CN4125.78 ; U4555.CM17 v1(178.94,67.35) U4555.CN17 ; v1(154.95,59.22) 155.34,58.83 U4555.AN30 155.21,58.64 155.21,58.36 155.39,58.18 U4555.AN31 ; U60600.14 109.34,100.17 C60609.2 ; D4300.2 D4301.2 82.19,31.56 v1(83.21,32.58) 83.21,32.68 TP4301.1 82.37,33.51 CN4300.2 ; v1(172.59,88.76) 172.25,88.76 C60903.2 ; v1(173.59,14.78) 173.08,14.26 CN4125.10 ; v1(191.56,6.95) 191.56,7.36 192.32,8.11 R60401.2 ; U4555.CB11 173.45,70.52 U4555.CC11 v1(174.11,70.51) U4555.CD11 v1(174.89,70.71) ; CN4100.72 112.88,12.67 112.88,13.63 v1(113.56,14.34) ; Q68000.3 211.57,115.97 v1(211.84,115.7) 212.29,116.16 R68004.2 ; CN4100.209 149.18,20.78 149.18,17.65 v1(148.36,16.83) ; CN4125.47 182.33,22.17 182.58,22.42 v1(183.35,22.42) ; v1(105.05,107.84) 104.15,107.84 U4413.4 103.85,107.83 C4413.2 ; CN200.2 60.75,10.25 v1(60.98,10.48) ; v1(72.26,33.75) CN1300.69 ; CN1951.9 v1(250.15,13.19) ; v1(24.45,19.53) 24.38,19.53 CN3000.G2 ; CN4100.51 107.63,21.88 v1(106.71,22.8) ; C2785.2 258.55,65.72 C2756.2 258.07,65.73 v1(257.94,65.6) ; CN4125.43 181.33,18.97 v1(180.48,18.13) ; CN4100.185 143.13,22.23 v1(143.2,22.3) 143.76,22.3 144.13,21.93 CN4100.189 ; R60903.1 v1(169.69,105.27) ; v1(214.32,22.17) 214.34,22.16 214.34,20.83 CN4125.167 ; U1400.A3 U1400.B3 209.53,63.75 209.8,63.48 209.84,63.48 210.03,63.29 v1(210.03,62.93) ; U1400.A3 209.51,64.82 209.56,64.86 209.56,65.07 C1409.2 ; v1(186.59,13.73) 186.59,12.37 CN4125.64 ; C1410.2 216.42,65.17 216.89,65.17 v1(217.01,65.29) 216.46,65.85 R1417.1 ; C4514.2 R4514.2 v1(142.66,84.37) ; CN1300.51 72.01,29.25 72.57,29.81 v1(72.57,30.77) 72.55,30.75 CN1300.57 ; 115.67,88.1 C7563.2 115.59,87.57 ; v1(47.39,11.26) 47.29,11.37 CN300.2 ; CN4125.213 225.83,21.92 226.15,22.24 v1(226.78,22.24) ; CN4350.7 224.51,7.87 v1(224.51,6.8) ; U2500.2 79.02,31.69 79.52,31.18 79.52,28.61 C2502.2 ; U4555.AP4 155.86,75.17 155.9,75.21 U4555.AR4 ; v1(104.87,13.77) CN4100.40 ; 205.04,54.26 v1(204.96,54.26) ; 205.04,54.26 205.98,54.26 206.75,53.48 ; 205.04,54.26 205.44,53.85 205.44,53.45 205.25,53.25 CN1400.27 ; U4555.F24 v1(138.73,62.26) ; U4555.F24 U4555.E23 ; U4555.F24 v1(138.07,62.26) U4555.D25 ; U4555.N25 U4555.N27 ; U4555.N27 v1(143.1,60.46) ; CN2500.12 10.75,42.83 v1(10.8,42.79) ; CN1400.G2 219.2,53.1 220.14,52.16 v1(220.39,52.16) 220.39,51.38 220.65,51.12 C4768.2 221.52,51.12 C1401.1 ; v1(211.83,73.98) 211.5,73.98 211.08,73.56 U7400.4 ; v1(97.92,16.4) 97.92,15.93 98.38,15.47 CN4100.14 ; CN4125.196 221.59,12.37 221.59,14.27 v1(221.77,14.45) ; CN4100.30 v1(102.38,13.72) 102.38,13.8 103.2,14.62 103.2,14.62 v1(103.3,14.72) ; v1(108.88,13.72) 108.88,12.37 CN4100.56 ; U4555.CN5 179.49,74.63 U4555.CM5 178.6,74.73 178.6,75.22 U4555.CM4 178.46,75.37 177.85,75.37 U4555.CK4 177.62,75.21 U4555.CJ4 ; v1(263.98,62.14) 263.79,62.14 C2778.2 ; U4555.BT15 v1(169.55,68.8) U4555.BT14 ; CN1951.39 257.65,13.19 v1(257.65,13.19) ; C1307.2 49.61,22.6 50.12,22.6 50.38,22.35 v1(50.38,21.93) ; U4555.B2 U4555.A3 135.67,76.24 v1(135.33,75.9) 135.64,75.59 U4555.A4 ; v1(219.4,22.43) 219.24,22.43 218.84,22.03 218.84,20.83 CN4125.185 ; v1(110.51,57.09) 110.96,57.54 C60516.2 ; C1302.2 59.97,18.61 v1(59.71,18.35) 60.07,18 C1304.2 ; CN4100.252 159.88,13.69 v1(160.08,13.9) ; 219.99,95.44 219.71,95.44 218.7,94.43 R4559.1 ; 219.99,95.44 U3003.2 ; v1(186.73,61.27) 186.5,61.04 R4578.1 ; v1(256.88,58.34) 257.08,58.14 C2770.2 ; CN1400.71 216.25,51.35 v1(216.53,51.07) 216.75,51.29 CN1400.73 ; 170.53,13.23 171.09,12.67 171.09,12.37 CN4125.2 ; U4555.CM37 v1(178.07,54.25) 177.74,54.3 U4555.CK37 v1(177.05,54.25) 177.01,54.34 U4555.CJ36 ; CN2500.18 v1(7.75,43.08) ; D7505.1 87.98,30.9 87.68,31.21 v1(87.68,31.49) 87.68,31.55 87.15,32.08 Q4300.4 ; CN4125.181 217.83,21.87 217.39,22.3 v1(217.27,22.3) 216.58,22.3 216.33,22.05 CN4125.175 ; CN1300.19 v1(69.74,21.25) ; CN4125.6 v1(172.08,14.09) ; CN3000.28 v1(20.6,31.25) ; CN3000.14 v1(21,24.25) 21.05,24.25 20.55,24.75 CN3000.15 ; C4828.2 188.22,74.73 v1(188.1,74.86) ; C4517.2 183.05,85.01 v1(183.05,85.77) ; CN4100.231 154.63,19.33 v1(154.6,19.3) ; v1(196.14,97.83) 195.7,97.4 195.7,96.59 196.21,96.08 196.21,95.36 196.21,95.36 196.21,95.16 195.48,94.43 C7010.2 194.94,93.6 Q7005.4 194.94,92.09 195.27,91.76 195.68,91.76 195.94,91.51 Q7005.1 195.96,91.08 C7003.2 ; U4555.BK33 165.69,56.88 U4555.BL32 ; CN375.G4 267.9,38.79 268.65,39.54 v1(268.65,39.82) ; U1401.3 U1401.2 213.79,63.18 v1(213.59,63.38) ; v1(275.9,62.11) 275.91,62.12 R2641.2 ; U4555.AV4 v1(158.14,75.68) U4555.AV3 ; U4555.AV4 158.75,75.17 U4555.AW4 ; U4555.AV4 157.52,75.17 U4555.AU4 ; U4555.BC29 160.5,59.85 v1(160.42,59.85) ; CN4125.39 180.33,22.19 180.48,22.35 v1(180.48,22.36) ; v1(177.08,14.95) CN4125.26 ; CN303.5 107.25,6.87 v1(107.03,6.66) ; v1(190.63,62.89) 190.1,62.89 C4544.2 ; CN1300.13 v1(69.72,19.75) ; CN4300.G2 78.32,38.67 78.58,38.93 v1(79.93,38.93) ; CN4100.1 95.12,20.82 v1(95.12,19.25) ; v1(111.27,101.62) 110.81,101.62 C60630.2 ; v1(139.09,18.28) 139.63,18.81 CN4100.171 ; C7558.2 171.35,94.93 ; U7400.4 210.4,73.56 209.83,74.13 209.13,74.13 208.84,73.85 R7418.2 C7403.2 ; v1(76.25,35.24) 76.29,35.29 Q1300.S ; v1(103.27,18.62) 103.43,18.62 103.69,18.87 103.69,19.5 103.63,19.56 CN4100.35 ; C1411.2 198.48,62.72 198.14,63.06 ; v1(233.51,14.3) 233.58,14.24 CN4125.244 ; CN4100.213 v1(150.13,19.46) ; v1(148.36,13.72) 148.37,12.43 CN4100.206 ; C3804.2 203.33,77.17 202.63,77.17 202.16,76.71 C3803.2 202.15,76.63 v1(202.15,75.82) ; v1(232.2,14.28) 232.08,14.16 CN4125.238 ; v1(157.12,18.77) 156.63,19.26 CN4100.239 ; CN1300.39 69.82,26.25 v1(69.67,26.41) ; C7008.2 v1(207.92,85.03) ; U4555.BB4 159.96,75.17 U4555.BA4 ; U4555.BB4 160.74,75.17 160.78,75.21 U4555.BC4 161.47,75.21 U4555.BD4 162.12,75.21 U4555.BE4 162.4,75.17 U4555.BF4 v1(163.02,75.68) 163.21,75.68 U4555.BG4 163.68,75.19 v1(164.14,74.72) ; v1(109.88,13.72) 109.88,13.71 CN4100.60 ; CN4100.103 120.63,22.06 120.16,22.52 v1(119.8,22.52) 119.63,22.34 CN4100.99 ; U4555.Y26 146.74,61.23 U4555.Y27 ; CN4125.243 233.33,22.04 v1(233.46,22.17) 233.47,22.19 234.06,22.19 234.33,21.92 CN4125.247 ; CN4125.184 218.59,12.37 v1(218.59,13.72) ; CN4100.61 110.13,18.32 109.55,17.75 v1(109.53,17.75) ; v1(99.52,22.93) 99.72,22.93 100.63,22.02 CN4100.23 ; CN3000.34 v1(20.7,34.25) ; v1(271.98,95.57) 272.18,95.37 C3151.2 ; CN4125.168 214.59,12.37 v1(214.59,13.87) ; v1(119.84,18.99) 120.83,18.99 121.56,19.72 121.56,19.72 121.63,19.79 CN4100.107 ; U4555.C21 137.2,64.88 v1(137.2,64.97) 137.54,64.64 U4555.D21 137.57,64.57 137.94,64.94 138.18,64.7 U4555.F21 U4555.G21 v1(139.39,64.27) U4555.H21 v1(140.03,64.29) U4555.J21 140.65,64.31 140.65,64.3 v1(140.66,64.28) 140.66,64.29 140.68,64.31 U4555.K21 v1(141.35,64.28) ; R60601.2 R60605.2 109.12,107.25 v1(109.12,107.43) ; v1(277.24,80.52) 277.17,80.6 D2820.2 ; C6035.2 231.64,80.55 C60190.2 C60191.2 231.64,78.74 232.64,77.74 v1(232.71,77.74) ; U4555.AC5 149.16,74.47 v1(149.36,74.67) ; CN4125.202 223.09,12.37 223.09,14.22 v1(222.85,14.45) ; v1(277.64,77.01) 277.64,77.01 R2605.2 ; v1(253.97,49.6) 253.79,49.77 CN4941.G1 ; CN4100.77 114.13,18.44 113.9,18.21 113.9,18.21 v1(113.56,17.88) ; C66317.2 108.54,67.49 108.04,66.99 v1(108,66.99) 107.9,67.09 U66310.19 ; v1(169.53,59.89) 169.51,59.88 U4555.BT28 ; v1(101.75,58.23) 101.24,57.72 R7008.1 ; v1(20.6,26.99) 20.33,27.25 CN3000.20 ; CN1951.1 248.15,13 248.34,13.19 v1(248.65,13.19) CN1951.3 ; CN3001.G4 v1(227,108.7) ; CN3000.G1 v1(21.79,15.35) ; CN4100.57 109.13,19.4 v1(108.72,18.99) ; R60526.2 101.72,50.03 v1(101.06,50.03) ; R1009.2 261.03,3.16 v1(261.54,3.67) ; CN4125.60 185.59,12.39 v1(185.59,13.91) ; CN4125.77 189.83,18.38 189.56,18.12 v1(189.17,18.12) ; CN4125.48 182.59,12.37 v1(182.59,13.75) ; CN4125.85 191.83,22.11 v1(191.57,22.36) ; v1(185.04,112.17) 183.54,113.67 U4412.2 ; CN4125.22 v1(176.08,14) ; C60930.2 R60901.2 v1(170.9,100.57) ; v1(229.97,3.88) 229.45,3.88 229.2,4.13 CN4350.G1 ; CN1400.39 208.25,53.24 208,53.49 206.76,53.49 206.75,53.48 ; U4555.AD33 149.71,56.81 149.78,56.88 150.09,56.88 150.16,56.81 U4555.AF33 150.77,56.99 151.66,56.99 U4555.AH33 ; v1(157.15,16.66) 157.63,17.13 CN4100.243 ; CN200.1 61.25,10.06 v1(61.62,10.43) 61.67,10.43 TP854.1 ; U4555.CN9 179.18,72.15 v1(178.95,72.39) ; U302.2 240.51,52.46 240.76,52.21 v1(240.76,51.93) ; v1(183.08,89.35) 183.03,89.4 183.03,89.4 C61416.2 ; v1(182.88,98.3) 182.35,97.77 R61421.2 ; R4900.2 185.76,56.45 v1(185.74,56.44) ; CN4125.107 197.33,22.19 197.05,22.46 v1(197.05,22.47) ; v1(84.78,29.63) 84.78,30.1 D7504.1 ; C7557.2 183.79,103.19 ; v1(163.21,72.73) 163.2,72.72 163.19,72.72 U4555.BE8 ; R1345.1 194.33,62.42 194.58,62.16 v1(194.58,61.28) ; U4555.BN30 v1(167.67,58.56) ; C2777.2 252.95,63.51 v1(252.47,63.99) ; D6035.3 230.91,84.01 230.6,84.31 v1(230.6,84.65) ; v1(159.63,18.79) CN4100.251 ; v1(231.07,17.81) 231.46,18.2 231.46,18.59 231.47,18.6 231.47,18.99 231.46,18.99 231.46,19.26 231.33,19.4 CN4125.235 ; v1(248.71,83.66) 248.87,83.49 CN2701.G1 ; v1(132.4,86.4) 132.22,86.22 132.22,86.2 131.87,85.84 R4529.2 ; Q305.4 49.18,19.95 49.67,19.46 49.96,19.46 50.18,19.24 Q305.1 50.18,18.09 C300.2 49.37,17.97 v1(49.3,18.04) ; R2624.2 v1(278.96,82.14) ; D2819.2 v1(275.85,82.07) ; CN550.G1 6.4,38.15 v1(6.4,41.44) ; v1(181.58,13.74) CN4125.44 ; D2905.2 273.96,63.61 v1(273.61,63.26) ; v1(15.05,42.79) 15.25,42.99 CN2500.3 ; v1(121.05,102.65) 121.65,102.65 C66024.2 ; v1(111.61,22.19) 111.87,22.19 112.12,21.93 CN4100.69 ; CN3001.11 v1(224.06,102.75) ; v1(148.25,18.65) 148.25,18.65 148.25,19.51 148.13,19.64 CN4100.205 ; v1(106.94,13.79) 106.88,13.72 CN4100.48 ; C7041.2 v1(207.92,85.64) 207.92,85.66 208.18,85.92 C7040.1 ; U4555.BD6 U4555.BD7 161.43,72.76 v1(161.37,72.76) ; v1(261.19,61.7) 261.13,61.75 C2783.2 ; CN4100.222 152.38,13.64 v1(152.45,13.72) ; C60916.2 161.99,94.51 v1(161.82,94.68) ; CN3000.5 20.42,19.75 20.67,19.5 v1(20.67,19.24) ; CN1300.1 v1(69.75,16.75) ; CN4125.106 197.08,13.47 196.59,13.96 v1(196.59,14.12) 196.08,13.61 CN4125.102 ; C7560.2 171.35,96.2 ; v1(188.68,13.78) 188.59,13.69 188.59,12.39 CN4125.72 ; D2807.2 286.41,79.89 v1(286.45,79.85) ; R60905.2 v1(170.32,103.92) ; U4555.CB25 v1(172.81,62.1) ; v1(172.81,62.1) U4555.CB24 ; v1(152.16,16.46) 151.96,16.46 151.13,17.3 CN4100.217 ; v1(186.35,76.73) 186.31,76.73 185.47,75.88 v1(185.47,75.07) 185.68,74.85 187.4,74.85 188.99,73.26 191.57,73.26 v1(191.69,73.14) 191.99,73.14 192.24,73.4 v1(192.24,75.31) ; CN1951.57 v1(262.15,13.19) ; CN4125.103 196.33,22.23 v1(196.2,22.36) ; v1(162.24,59.22) 162.63,58.83 U4555.BE30 162.69,58.76 162.51,58.58 162.51,58.36 U4555.BE31 ; CN3001.3 224.21,98.75 v1(224.06,98.59) ; CN4100.78 114.38,13.53 v1(114.58,13.73) ; CN4125.68 v1(187.58,13.8) ; v1(195.33,22.36) CN4125.99 ; v1(253.15,13.19) 253.15,13.19 CN1951.21 ; 206.75,53.48 CN1400.33 ; v1(142.95,13.76) 142.88,13.71 CN4100.184 ; U4555.CK7 177.62,73.25 v1(178.17,73.25) ; CN4100.94 118.38,13.74 v1(118.34,13.78) ; v1(188.64,61.27) 188.64,61.11 ; 188.64,61.11 R4574.1 ; 188.64,61.11 R4572.1 ; R3012.2 220.83,102.98 C2258.2 220.41,104.07 v5(220.41,104.41) 220.59,104.59 C2257.2 221.01,104.97 221.26,105.22 C2256.2 C2255.2 ; Q7000.1 160.18,97.99 160.39,97.77 160.69,97.77 161.18,97.28 Q7000.4 v1(161.18,96.09) ; CN4100.27 101.63,19.07 v1(101.07,18.51) ; C7533.2 144.51,111.26 ; CN4100.89 117.13,19.73 116.79,19.39 v1(116.46,19.39) 116.13,19.73 CN4100.85 116.13,21.96 116.41,22.24 v1(116.61,22.24) ; v1(96.35,13.91) 96.35,12.4 CN4100.6 ; C7503.1 78.43,25.97 ; v1(55.42,26.96) 56.37,26.96 56.57,27.17 56.57,27.8 Q1302.S ; CN4125.36 v1(179.58,13.94) ; CN1300.63 v1(72.24,32.25) ; CN1951.71 v1(265.65,13.19) ; v1(265.4,26.81) 265.79,27.2 C2419.2 ; v1(213,98.92) 213,98.93 212.54,99.39 212.54,101.67 212.8,101.92 R1016.1 213.59,101.12 Q1002.4 214.15,100.27 214.37,100.05 214.66,100.05 215.15,99.56 Q1002.1 ; v1(167.58,7.51) 167.57,7.52 167.57,8.04 C60302.2 166.54,8.27 C60316.2 ; Q301.S 130.46,2.99 130.46,2.99 v1(130.46,2.44) ; D2904.2 274.89,61.67 v1(274.93,61.63) ; v1(141.38,15.51) 141.88,15.01 CN4100.180 ; C66316.2 111.69,68.61 v1(111.05,67.98) ; C60012.2 v5(179.98,102.55) ; v1(211.38,91.43) 211.48,91.32 Q7003.4 211.48,89.73 211.7,89.51 211.99,89.51 212.49,89.02 Q7003.1 ; C76020.2 241.48,62.97 241.45,62.97 ; U4555.CA11 U4555.BY11 v1(171.49,71.42) U4555.BW11 U4555.BV11 170.51,70.96 169.89,70.96 U4555.BU11 ; v1(155.88,72.84) U4555.AN8 ; C7568.2 228.58,86.93 ; CN6000.G2 242.8,88.76 242.21,89.35 v1(241.83,89.35) ; v1(181.18,76.71) U4555.CR2 ; CN4100.10 97.38,14 v1(97.84,14.47) ; C323.2 111.42,7.16 111.42,6.69 111.18,6.45 111.02,6.45 111.02,6.01 110.81,5.8 CN303.G2 109.67,6.51 v1(109.83,6.66) ; v1(235.24,15.11) 235.12,15.11 234.58,14.57 CN4125.248 ; CN1951.73 266.15,13.08 v1(266.26,13.19) ; v1(9.36,43.05) 9.25,43.16 CN2500.15 ; CN3000.31 v1(20.68,32.75) ; R4893.2 179.13,84.9 179.65,85.41 v1(179.88,85.41) 179.88,84.52 R1336.1 ; CN4125.86 v1(192.08,14.24) ; CN4100.2 v1(95.38,14.62) ; CN4100.188 143.87,14.26 v1(144.37,14.75) ; v1(237.97,4.52) 237.67,4.81 CN2200.G2 ; CN2200.G1 231.42,5.8 231.42,5.81 v1(230.8,6.42) ; CN4100.175 140.63,21.87 140.98,22.22 v1(141.46,22.22) ; U4555.H9 v1(140.56,71.69) ; CN300.10 v1(43.29,11.26) ; CN4125.51 183.34,20.83 183.32,20.81 183.32,19.24 v1(183.91,18.66) ; CN4125.65 186.83,22.22 187.08,22.47 v1(187.55,22.47) 187.57,22.47 187.83,22.22 CN4125.69 ; CN4125.27 177.33,18.84 176.57,18.08 v1(176.42,18.08) ; R61428.2 v1(172.88,98.24) ; CN4100.19 99.63,19.51 v1(99.53,19.37) ; U4555.CA22 U4555.CB20 v1(173.42,65.51) ; v1(119.02,96.71) 118.56,97.17 C66026.2 ; v1(254.69,63) 254.92,63.22 C2784.2 ; v1(97.12,26.57) 94.95,26.57 94.7,26.82 CN4100.G1 ; CN4100.192 v1(144.88,11.01) ; v1(249.7,93.77) 250.79,93.77 C7628.2 ; CN2500.6 13.75,42.99 13.5,42.74 v1(13.48,42.74) ; v1(107.69,65.34) 107.69,65.19 107.35,64.85 C66314.2 ; v1(24.76,37.64) 24.76,37.05 24.11,36.4 CN3000.G4 22.68,37.17 20.38,37.17 20.29,37.25 CN3000.40 ; v1(178.17,14.09) 178.08,14 CN4125.30 ; v1(181.24,54.25) v1(180.63,54.25) 180.22,54.3 U4555.CP37 ; R60199.2 222.12,79.02 222.12,78.63 221.64,78.15 v1(221.64,78.14) ; v1(156.77,57.31) 156.34,56.88 156.11,56.88 156.04,56.81 U4555.AP33 155.19,56.81 155.12,56.88 154.43,56.88 U4555.AM33 ; C2744.2 v1(263.78,54.12) ; v1(276.39,74.94) 276.39,75.16 D2817.2 ; R61701.2 223.39,92.06 223.39,93.43 222.98,93.83 v1(222.91,93.83) 224.42,95.35 CN3001.G2 ; v1(139.07,16.63) 138.57,17.13 138.57,20.78 CN4100.167 ; v1(254.69,64.31) 254.69,64.36 C2786.2 ; R2642.1 275.98,67.12 v1(275.23,67.12) 274.42,67.12 D2903.2 ; CN4125.14 174.08,13.67 174.19,13.78 v1(174.19,14.06) ; v1(116.64,22.84) 115.89,22.84 115.13,22.08 CN4100.81 115.13,19.29 v1(116.46,17.95) ; CN4100.22 v1(100.38,13.72) ; C7564.2 180.82,102.8 ; CN4100.44 v1(105.88,13.72) ; Q7306.1 210.49,77.9 v1(210.49,77.23) 211.29,77.23 211.55,76.98 Q7306.4 211.79,76.61 212.08,76.9 C7009.2 ; CN4100.102 120.38,13.41 120.81,13.85 v1(120.96,13.85) 121.38,13.43 CN4100.106 ; CN1300.G2 67.95,36.35 v1(67.59,36.72) ; v1(197.23,100.22) 197.03,100.42 R60255.1 ; CN4100.5 v1(96.13,19.23) ; v1(113.59,19.27) 113.13,19.74 CN4100.73 ; C2758.2 C2760.2 255.47,72.2 v1(254.89,72.79) ; C2765.2 257.77,62.17 v1(257.94,62.35) ; v1(158.8,77.7) 158.79,77.69 U4555.AW1 ; 228.26,86 C7567.2 ; C60216.2 233.02,70.8 v1(232.58,70.37) 231.54,71.41 R60206.2 ; v1(173.42,65.51) U4555.CC20 173.85,65.12 174.36,65.12 U4555.CD20 v1(175,65.53) ; v1(173.42,65.51) U4555.CB19 ; C60050.2 86.66,25.77 v1(87.07,25.36) 86.53,24.83 C7502.2 ; CN375.3 251.3,38.63 v1(250.91,39.03) ; C2771.2 256.99,60.03 v1(256.64,60.39) ; CN4100.98 v1(119.38,13.73) ; C2745.2 v1(263.76,56.6) ; v1(151.38,11.03) CN4100.218 ; v1(158.59,59.22) 158.98,58.83 U4555.AW30 158.87,58.65 158.87,58.36 U4555.AW31 ; CN4125.19 175.33,19.07 v1(174.33,18.08) ; CN4100.65 111.12,17.77 v1(112.02,16.88) ; U7001.11 v1(210.15,85.66) ; U4555.BP4 v1(167.9,75.68) ; R2622.2 v1(278.45,80.02) ; SW1000.T1 81.84,7.29 81.58,7.04 v1(81.27,7.04) ; v5(266.09,46.27) 266.96,47.14 C7504.2 ; v1(146.41,14.32) 146.58,14.32 147.38,13.53 CN4100.202 ; C4826.2 188.11,76.38 v1(188.1,76.38) ; v1(266.26,13.8) 267.5,13.8 267.75,13.55 CN1951.G2 ; v1(175.63,62.39) 175.25,62.77 U4555.CF23 ; CN4100.244 v1(157.88,13.74) ; C1402.2 211.75,61.91 v1(212.21,61.91) ; v1(108.77,109.69) 108.77,109.12 108.51,108.86 R4415.2 108.02,108.78 U4413.2 ; C7521.2 58.57,33.59 v1(58.7,33.47) 58.19,32.96 C7520.2 C7522.2 ; CN4100.64 110.88,13.79 v1(110.95,13.86) ; CN1951.15 v1(251.65,13.19) ; v1(184.43,89.35) C60266.2 ; CN4125.18 v1(175.08,14) ; CN1300.75 v1(72.46,35.25) ; U4555.C33 U4555.B34 ; CN4941.14 260.62,48.54 259.18,49.98 v1(259,49.98) ; U4555.F3 v1(138.22,76.49) U4555.F2 ; v1(116.46,13.86) 116.38,13.78 CN4100.86 ; R4759.2 200.45,74.37 v1(200.42,74.4) R4758.2 ; U4555.BP25 U4555.BR25 U4555.BT25 169.29,61.7 169.32,61.67 169.71,61.67 169.71,61.68 169.74,61.7 U4555.BU25 U4555.BU24 170.18,62.85 v1(170.18,63) 170.18,63.07 U4555.BU23 ; CN4100.168 v1(138.88,14.09) ; v1(97.88,18.53) 98.63,19.27 CN4100.15 98.63,21.89 98.3,22.22 98.19,22.22 v1(97.83,22.58) 97.13,21.88 CN4100.9 ; C7555.2 182.52,103.19 ; CN4100.68 v1(111.88,13.72) ; CN200.G1 v1(63.35,5.4) ; CN1400.45 209.75,53.54 208.92,54.37 207.08,54.37 206.07,55.39 203.73,55.39 203.32,55.8 v1(203.32,56.45) ; U3150.2 v1(275.23,91.32) ; v1(56.03,6.29) 55.82,6.5 CN200.G2 ; U4555.CG7 v1(176.14,73.43) ; C60262.2 188.49,101.79 ; CN4100.214 v1(150.38,13.79) ; R2643.1 v1(275.53,68.79) ; U4555.Y7 v1(147.48,73.49) ; v1(225.09,13.77) 225.09,12.39 CN4125.210 ; CN3001.6 v1(224.06,100.25) ; v1(69.57,27.51) 69.81,27.75 CN1300.45 ; 115.7,88.08 C7562.2 115.21,88.05 ; C7535.2 144.22,110.66 ; CN4100.90 v1(117.38,13.73) ; v1(194.83,63.96) 194.88,63.96 195.29,64.37 195.29,65.76 195.03,66.02 195.03,66.65 196.17,67.8 Q7300.1 ; CN4100.248 158.88,14.09 v1(159.4,14.61) ; C66016.2 139.67,100.7 ; U4555.AE7 v1(150.29,73.35) ; v1(152.13,74.67) U4555.AG5 ; C7559.2 171.35,95.57 ; U4555.W7 v1(146.51,73.5) ; R1317.1 v1(61.24,20.72) ; CN4100.238 v1(156.38,11.03) 155.68,11.03 155.38,11.33 CN4100.234 ; v1(105.63,19.48) CN4100.43 ; CN4100.196 v1(145.88,11.01) ; R68125.2 v1(204.11,111.08) ; CN303.G1 104.33,6.04 104.76,6.48 v1(104.76,6.66) ; CN4125.23 v1(176.33,22.4) ; U4555.BY5 v1(172.47,74.76) ; U4555.CJ23 v1(177.41,62.43) ; v1(165.46,75.68) U4555.BK4
  BOTTOM w0.279: v1(35.3,35.27) 35.53,35.27 35.81,34.99 L7500.5 ; L7502.6 35.81,30.12 35.53,29.83 v1(35.3,29.83) ; L7503.6 35.05,20.57 34.77,20.28 v1(34.54,20.28) ; v1(34.52,33.39) 34.74,33.39 35.02,33.11 L7501.5 ; v1(34.54,21.96) 34.77,21.96 35.05,21.68 L7503.5 ; L7502.5 35.81,31.23 35.53,31.51 v1(35.3,31.51) ; v1(35.3,33.59) 35.53,33.59 35.81,33.88 L7500.6 ; L7501.6 35.02,32 34.74,31.71 v1(34.52,31.71)
  BOTTOM w0.33: CN4125.193 220.83,19.48 v1(220.86,19.45) ; CN4125.223 228.33,19.41 228.72,19.01 v1(228.94,19.01) ; CN4125.217 v1(226.83,19.35) ; v1(223.84,18.66) 222.83,19.67 CN4125.201 ; v1(184.66,14.21) 184.66,13.63 184.58,13.55 CN4125.56 ; CN4100.19 99.63,22.1 v1(99.52,22.2) ; CN4125.197 221.83,18.58 221.15,17.9 v1(220.77,17.9) ; v1(106.2,18.13) 106.63,18.55 CN4100.47 ; v1(116.64,22.84) 117.13,22.84 ; CN4125.189 219.83,18.31 219.47,17.96 v1(219.12,17.96) ; v1(223.72,22.22) 223.83,22.11 CN4125.205 ; CN4100.36 v1(103.88,13.72) ; v1(107.87,13.72) 107.88,13.72 CN4100.52
  BOTTOM w0.381: v1(187.72,16.66) 188,16.66 188.6,17.26 ; 217,62.59 C1408.2 ; v5(284.5,80.58) 284.5,80.41 284.11,80.01 284.05,80.01 283.96,79.92 283.14,79.92 C2815.2 ; 140.07,100.25 C66016.2 ; 170.53,13.23 v1(169.48,14.28)
  BOTTOM w0.508: v5(284.29,64.89) 284.29,64.84 283.73,64.28 283.14,64.28 C2900.2 ; 241.45,62.97 241.45,62.85 242.67,61.63 242.67,60.59 242.16,60.09 240.43,60.09 v1(239.54,60.97)
  vias: v1(0.94,43.93) v1(0.94,40.88) v1(0.94,37.83) v1(1.39,35.24) v1(4.44,35.24) v1(8.44,32.4) v1(9.22,32.93) v1(9.33,30.24) v1(10.21,33.9) v1(13.44,34.53) v1(18.74,14.52) v1(20.11,38.67) v1(20.24,42.33) v1(20.22,41.01) v1(20.57,6.28) v1(21.12,24.89) v1(21.38,42.33) v1(21.36,41.01) v1(22.68,38.7) v1(22.7,42.33) v1(22.78,40.98) v1(23.38,29.38) v1(23.62,6.24) v1(23.87,42.36) v1(23.92,41.01) v1(23.95,39.69) v1(23.9,38.69) v1(23.96,29.9) v1(24.45,29.36) v1(26.67,6.24) v1(29.72,6.24) v1(31.61,46.72) v1(32.38,29.78) v1(32.76,6.24) v1(33.89,44.7) v1(34.44,29.78) v1(35.23,20) v1(35.81,6.24) v1(36.33,42.87) v1(37.33,20) v1(38.86,6.24) v1(38.91,41.26) v1(41.62,39.86) v1(41.91,6.24) v1(42.49,34.03) v1(42.49,32.6) v1(42.49,31.18) v1(42.49,29.76) v1(43.96,20.32) v1(44.44,38.69) v1(44.6,34.03) v1(44.6,32.6) v1(44.6,31.18) v1(44.6,29.76) v1(44.96,6.24) v1(47.14,34.15) v1(47.17,24.45) v1(47.34,37.76) v1(48,6.24) v1(50.31,37.08) v1(51.05,6.24) v1(52.09,18.04) v1(53.23,4.63) v1(53.32,36.65) v1(55.89,4.24) v1(56.37,36.47) v1(58.94,4.24) v1(59.41,36.54) v1(60.64,17.08) v1(60.64,15.81) v1(61.99,4.24) v1(62.44,36.87) v1(65.04,4.24) v1(65.35,11.93) v1(65.43,37.45) v1(67.54,25.8) v1(68.08,4.24) v1(68.37,38.28) v1(71.13,4.24) v1(71.22,39.34) v1(72.27,6.52) v1(73.97,40.65) v1(74.19,35.24) v1(74.19,32.32) v1(74.19,30.8) v1(74.89,27.31) v1(75.03,25.8) v1(75.17,7.04) v1(76.25,30.8) v1(76.61,42.17) v1(76.87,27.36) v1(76.86,25.8) v1(78.22,7.04) v1(79.11,43.91) v1(81.46,45.86) v1(81.56,19.8) v1(81.61,17.97) v1(83.64,47.99) v1(84.32,7.04) v1(85.63,50.3) v1(87.37,7.04) v1(87.8,52.25) v1(89.99,45.05) v1(89.99,39.94) v1(90.41,7.04) v1(90.64,53.34) v1(93.01,55.24) v1(93.18,67.93) v1(93.44,9.82) v1(93.46,7.04) v1(93.54,113.87) v1(93.54,110.83) v1(93.54,107.78) v1(93.54,104.73) v1(93.54,101.68) v1(93.54,98.63) v1(93.54,95.59) v1(93.54,92.54) v1(93.54,89.49) v1(93.54,86.44) v1(94.25,70.51) v1(94.38,84.14) v1(94.32,65.83) v1(94.56,48.2) v1(94.64,82.23) v1(94.64,79.06) v1(94.64,75.88) v1(94.64,72.07) v1(94.59,57.82) v1(95.31,85.16) v1(95.73,60.65) v1(96.16,59.68) v1(96.23,63.59) v1(96.24,58.99) v1(96.19,17.9) v1(96.36,114.96) v1(96.32,15.25) v1(96.51,7.04) v1(96.8,72.17) v1(96.92,73.47) v1(97.43,9.82) v1(98.17,96.13) v1(98.22,100.07) v1(98.22,98.82) v1(98.22,97.45) v1(98.35,85.09) v1(98.32,84.01) v1(98.5,48.2) v1(98.96,74.87) v1(99.21,88.71) v1(99.36,73.83) v1(99.33,31.65) v1(99.53,18.03) v1(99.56,7.04) v1(99.67,98.95) v1(99.69,100.12) v1(99.69,97.45) v1(99.69,96.05) v1(100.61,82.87) v1(100.96,98.97) v1(100.98,15.27) v1(101.01,86.88) v1(100.99,76.39) v1(101.09,83.85) v1(101.77,75.67) v1(101.73,5.42) v1(101.88,80.84) v1(102,78.42) v1(102.1,2.74) v1(102.46,88.05) v1(102.46,58.79) v1(102.83,81.39) v1(103.08,78.38) v1(103.33,17.01) v1(104.8,39.13) v1(104.88,18.18) v1(104.87,15.39) v1(105.15,2.74) v1(106.3,16.76) v1(106.45,38.7) v1(106.45,37.23) v1(106.42,35.96) v1(107.31,39.11) v1(107.46,114.95) v1(107.67,102.16) v1(108.2,2.74) v1(108.35,101.51) v1(108.35,35.98) v1(108.66,41.47) v1(108.66,40.38) v1(108.72,16.78) v1(108.94,37.43) v1(109.14,39.11) v1(109.53,15.23) v1(110.81,116.34) v1(111.24,2.74) v1(111.99,90.49) v1(112.02,15.33) v1(112.3,89.23) v1(112.71,68.65) v1(112.71,67.38) v1(112.71,66.11) v1(112.79,102.94) v1(112.88,89.81) v1(112.8,45.53) v1(113.56,16.66) v1(113.86,117.66) v1(114.09,46.83) v1(114.7,77.66) v1(115.82,102.27) v1(116.36,117.62) v1(116.3,101.79) v1(116.55,55.4) v1(117.55,114.44) v1(118.13,95.19) v1(118.11,0.94) v1(118.61,55.44) v1(119.02,94.3) v1(119.15,55.97) v1(119.58,56.4) v1(120.01,56.83) v1(120.47,88.58) v1(120.67,90.41) v1(121.06,16.53) v1(121.13,89.96) v1(121.16,0.94) v1(121.21,88.58) v1(121.46,115) v1(121.84,89.24) v1(121.94,117.66) v1(122.26,18.31) v1(122.26,16.26) v1(122.87,14.38) v1(123.14,15.69) v1(124.05,56.33) v1(124.73,18.46) v1(124.73,16.3) v1(124.99,117.66) v1(125.87,15.41) v1(126.34,102) v1(126.59,115.81) v1(126.82,101.51) v1(127.25,0.94) v1(127.46,18.59) v1(127.46,17.14) v1(127.63,15.69) v1(127.88,22.77) v1(128.51,60.1) v1(128.62,114.95) v1(128.91,63.31) v1(130.05,22.85) v1(130.02,9.81) v1(130.12,16.89) v1(130.15,14.78) v1(130.28,63.31) v1(130.34,60.58) v1(130.3,0.94) v1(130.48,58.84) v1(130.67,9.81) v1(130.75,64.75) v1(130.81,62.04) v1(131.45,57.68) v1(131.67,114.95) v1(131.82,90.17) v1(131.81,56.33) v1(132.12,64.75) v1(132.18,62.04) v1(132.26,17.19) v1(132.26,14.88) v1(132.34,63.31) v1(132.42,60.58) v1(132.54,58.84) v1(132.56,1.97) v1(133.09,90.17) v1(133.18,56.33) v1(133.59,17.32) v1(133.59,15.69) v1(134.12,79.17) v1(134.28,50.69) v1(134.36,90.17) v1(134.52,52.48) v1(134.72,114.95) v1(134.86,18.11) v1(134.88,16.6) v1(135.34,2.74) v1(136.24,17.99) v1(136.34,51.05) v1(136.33,49.04) v1(137.77,114.95) v1(137.84,49.63) v1(137.93,50.94) v1(138.39,2.74) v1(139.15,50.99) v1(139.17,49.09) v1(140.11,74.69) v1(140.12,74.05) v1(140.45,50.37) v1(140.44,48.46) v1(141.15,46.67) v1(141.33,16.27) v1(141.44,2.74) v1(141.76,49.73) v1(141.88,68.43) v1(141.82,47.76) v1(142.31,63.71) v1(142.64,117.66) v1(142.95,18.09) v1(142.95,16.6) v1(142.95,15.16) v1(143,89.24) v1(143.2,63.67) v1(143.42,68.14) v1(143.42,66.93) v1(143.66,2.77) v1(143.97,48.39) v1(143.97,46.48) v1(143.99,50.45) v1(144.27,89.24) v1(144.34,105.32) v1(144.34,104.56) v1(144.36,16.41) v1(144.44,63.71) v1(144.64,68.14) v1(144.64,66.95) v1(145.69,117.66) v1(145.61,49.79) v1(145.61,47.96) v1(145.84,89.24) v1(145.86,68.14) v1(145.86,66.95) v1(145.86,63.72) v1(145.95,51.45) v1(146.41,16.55) v1(146.58,9.83) v1(147.11,89.24) v1(147.26,47.89) v1(147.25,46) v1(147.59,100.9) v1(147.54,2.74) v1(148.1,64.74) v1(148.23,6.67) v1(148.36,15.28) v1(148.44,74.01) v1(148.68,64.74) v1(148.73,117.66) v1(148.71,50.02) v1(149.28,48.7) v1(149.28,47.24) v1(149.28,46.29) v1(149.48,60.49) v1(149.79,67.62) v1(149.81,62.67) v1(150.06,9.82) v1(150.14,115.61) v1(150.16,18.06) v1(150.37,15.16) v1(150.45,67.61) v1(150.43,63.06) v1(150.39,60.49) v1(150.57,2.64) v1(150.75,115.61) v1(150.82,80.47) v1(150.81,62.48) v1(151.2,49.73) v1(151.2,47.75) v1(151.2,46.51) v1(151.36,115.61) v1(151.3,63.03) v1(151.3,60.49) v1(151.75,62.48) v1(151.96,115.61) v1(151.99,86.88) v1(152.2,79.55) v1(152.21,63.06) v1(152.21,59.88) v1(152.57,115.61) v1(152.57,67.73) v1(152.55,62.55) v1(152.58,0.94) v1(152.8,66.76) v1(152.85,51.29) v1(152.85,49.36) v1(152.85,47.54) v1(153.18,115.61) v1(153.41,66.76) v1(153.58,17.99) v1(153.67,15.06) v1(153.72,80.96) v1(153.79,115.61) v1(153.92,86.88) v1(154.01,67.39) v1(154.01,66.43) v1(154.2,78.73) v1(154.21,51.6) v1(154.21,50.39) v1(154.76,99.53) v1(154.83,117.66) v1(155.01,116.83) v1(155.14,14.98) v1(155.34,7.2) v1(155.58,48.81) v1(155.61,50.68) v1(155.61,46.87) v1(155.62,0.94) v1(155.7,88.79) v1(155.75,87.26) v1(155.75,85.79) v1(155.8,116.88) v1(155.95,7.2) v1(156.41,116.88) v1(156.77,80.02) v1(156.77,77.97) v1(157.27,51.04) v1(157.28,49.15) v1(157.45,85.71) v1(157.45,83.53) v1(157.88,117.66) v1(158,67.39) v1(158.03,66.52) v1(158.58,50.96) v1(158.57,49.63) v1(158.56,47.7) v1(158.67,0.94) v1(158.95,90.67) v1(159.09,91.76) v1(159.19,67.39) v1(159.22,66.49) v1(159.48,83.53) v1(159.78,16.07) v1(160.24,51.71) v1(160.24,49.81) v1(160.93,117.66) v1(160.94,79.85) v1(161.03,30.65) v1(161.46,30.22) v1(161.72,0.94) v1(161.98,80.08) v1(161.98,78.1) v1(161.9,50.67) v1(161.9,48.74) v1(161.9,46.87) v1(161.9,29.78) v1(162.33,29.35) v1(162.42,69.82) v1(162.42,67.38) v1(162.45,63.95) v1(162.53,85.71) v1(162.53,83.53) v1(163.02,79.9) v1(163.04,78) v1(163.15,63.05) v1(163.19,28.49) v1(163.45,51.43) v1(163.45,49.57) v1(163.45,48.34) v1(163.83,85.66) v1(163.83,83.53) v1(163.97,117.66) v1(164.02,69.82) v1(164.02,67.38) v1(164.02,66.16) v1(164.02,64.94) v1(164.02,64.06) v1(164.77,0.94) v1(164.94,49.68) v1(164.94,47.76) v1(164.94,45.76) v1(165.07,74.72) v1(165.17,85.66) v1(165.17,83.53) v1(165.46,79.59) v1(166.37,85.66) v1(166.37,83.53) v1(166.72,101.12) v1(166.74,100.18) v1(166.94,65.33) v1(167.02,117.66) v1(167.64,85.71) v1(167.64,83.53) v1(167.82,0.94) v1(168.96,85.65) v1(168.96,83.53) v1(169.87,1.72) v1(170.07,117.66) v1(170.28,85.64) v1(170.28,83.53) v1(170.34,98.24) v1(170.48,1.72) v1(170.61,74.74) v1(170.86,0.94) v1(171.04,80.58) v1(171.09,1.72) v1(171.65,89.35) v1(171.6,86.43) v1(171.6,84.39) v1(171.77,15.44) v1(171.7,1.72) v1(171.98,94.43) v1(171.98,93.21) v1(171.98,80.48) v1(171.98,78.73) v1(172.06,9.81) v1(172.31,1.72) v1(172.59,94.43) v1(172.59,93.82) v1(172.59,93.21) v1(172.92,86.3) v1(172.92,84.32) v1(172.98,16.15) v1(172.92,1.72) v1(173.2,94.43) v1(173.2,93.82) v1(173.2,93.21) v1(173.53,1.72) v1(173.76,117.64) v1(173.91,0.94) v1(174.14,1.72) v1(174.42,82.1) v1(174.67,9.59) v1(175.3,15.24) v1(176,83.42) v1(176.35,117.64) v1(176.89,80.09) v1(176.96,0.94) v1(177.57,115.94) v1(178.13,16.23) v1(178.43,79.56) v1(178.75,18.08) v1(179.6,15.01) v1(179.73,80.86) v1(181.86,117.64) v1(181.86,116.04) v1(182.38,18.08) v1(182.58,15.15) v1(183.06,0.94) v1(183.94,16.52) v1(184.27,85.77) v1(185.27,117.62) v1(185.56,18) v1(187.14,85.77) v1(187.5,15.21) v1(187.67,18.1) v1(187.82,85.77) v1(188.43,85.77) v1(189.05,15.81) v1(189.15,0.94) v1(189.47,85.77) v1(189.56,114.95) v1(189.69,76.72) v1(190,100.42) v1(190.08,85.77) v1(190.17,110.73) v1(191.13,85.77) v1(191.18,2.53) v1(191.28,105.98) v1(191.39,74.52) v1(191.74,85.77) v1(192.6,114.95) v1(193.44,108.14) v1(193.44,105.98) v1(194.15,3.52) v1(194.21,9.77) v1(194.19,2.74) v1(194.81,3.52) v1(194.92,96.15) v1(195.35,95.72) v1(195.65,114.95) v1(196.08,5.27) v1(196.11,112.55) v1(196.52,16.6) v1(196.89,9.75) v1(197.74,116.32) v1(197.76,16.26) v1(197.8,17.97) v1(198.02,53.53) v1(198.37,48.2) v1(198.93,15.56) v1(199.22,17.29) v1(199.61,14.86) v1(199.92,110.59) v1(200.07,116.63) v1(200.43,17.72) v1(200.68,14.86) v1(201.14,61.84) v1(201.29,98.36) v1(201.51,71.3) v1(201.57,15.81) v1(202.76,48.2) v1(202.84,18.48) v1(202.85,16.22) v1(202.97,92.8) v1(202.91,14.98) v1(203.22,98.31) v1(203.58,3.88) v1(204.44,92.8) v1(204.59,72.98) v1(204.96,16.97) v1(205.76,107.81) v1(205.71,3.88) v1(206.08,16.93) v1(207.08,90.95) v1(208.51,48.45) v1(208.74,17.41) v1(208.74,14.62) v1(210.39,18.4) v1(210.39,16.57) v1(211.76,17.78) v1(211.86,85.66) v1(212.8,17.13) v1(212.8,15.53) v1(215.24,17.64) v1(215.45,15.02) v1(216.42,117.66) v1(217.34,18.72) v1(217.34,15.98) v1(217.42,86.91) v1(217.42,85.08) v1(218.67,15.16) v1(219.14,16.54) v1(219.47,117.66) v1(220.44,86.91) v1(220.44,85.08) v1(220.52,15.19) v1(220.64,16.54) v1(220.9,63.36) v1(223.98,15.1) v1(224.2,16.44) v1(225.22,110.35) v1(225.45,88.71) v1(225.57,29.86) v1(225.55,15.19) v1(226.9,16.41) v1(228.75,94.78) v1(228.75,84.77) v1(228.83,110.35) v1(228.95,106.4) v1(228.95,103.86) v1(228.95,98.6) v1(228.95,83.78) v1(228.93,17.67) v1(228.97,16.35) v1(228.9,14.8) v1(229.08,85.59) v1(229.69,84.72) v1(229.79,35.55) v1(230.15,93.38) v1(230.83,93.16) v1(231.17,15.14) v1(231.56,55.44) v1(231.86,91.82) v1(232.74,109.54) v1(232.97,31.15) v1(232.97,29.22) v1(232.99,53.94) v1(233.26,106.83) v1(233.26,103.78) v1(233.35,39) v1(233.78,100.87) v1(233.85,87.87) v1(233.85,84.14) v1(235.25,16.45) v1(235.31,18.03) v1(235.45,61.3) v1(236.24,99.04) v1(236.2,86.45) v1(236.24,60.97) v1(236.69,100.36) v1(237.11,61.3) v1(237.89,60.97) v1(238.38,74.21) v1(238.38,73.62) v1(238.66,97.94) v1(238.78,92.9) v1(238.78,91.25) v1(238.78,89.35) v1(238.76,75.6) v1(238.76,75) v1(238.76,61.3) v1(238.91,78.73) v1(238.91,78.12) v1(239.29,79.54) v1(239.44,9.79) v1(239.74,100.36) v1(240.18,89.35) v1(240.38,48.27) v1(240.43,92.9) v1(240.43,91.25) v1(240.59,97.91) v1(241.14,2.73) v1(241.25,37.24) v1(242.08,92.9) v1(242.08,91.25) v1(242.06,61.18) v1(242.08,6.87) v1(242.34,70.51) v1(242.39,79.29) v1(242.79,100.36) v1(242.69,20.97) v1(242.92,19.9) v1(243.61,80.16) v1(243.84,76.27) v1(244.65,7.69) v1(245.01,95.06) v1(245.03,16.07) v1(245.01,13.04) v1(245.49,45.07) v1(245.83,100.36) v1(246.1,36.39) v1(246.94,18.45) v1(247.75,90.36) v1(247.7,7.69) v1(247.82,88.94) v1(247.9,10.86) v1(248.31,94.45) v1(248.88,100.36) v1(249.17,66.65) v1(249.09,65.57) v1(249.09,64.23) v1(249.09,62.88) v1(249.17,61.08) v1(249.21,17.47) v1(249.4,35.65) v1(249.96,95.83) v1(249.92,17.19) v1(250.34,15.89) v1(250.75,7.69) v1(250.87,53.66) v1(251.58,15.89) v1(251.93,100.36) v1(252.32,25.62) v1(252.29,24.58) v1(252.52,52.69) v1(252.78,81.97) v1(252.78,79.92) v1(253.95,53.51) v1(253.95,6.95) v1(254.25,48.38) v1(254.61,81.2) v1(254.61,79.16) v1(254.98,100.36) v1(254.91,51.98) v1(255.06,16.83) v1(254.99,4) v1(256.02,14.12) v1(256.22,15.95) v1(256.44,54.12) v1(256.44,52.29) v1(256.42,7.88) v1(256.41,5.32) v1(256.89,84.26) v1(257.73,84.26) v1(258.03,100.36) v1(258.06,16.87) v1(258.42,52.82) v1(258.57,84.26) v1(259.41,84.26) v1(260.25,84.26) v1(260.2,0.94) v1(261.07,100.36) v1(261.08,84.26) v1(261.08,16.8) v1(261.92,84.26) v1(262.26,1.92) v1(263.12,22.87) v1(263.71,7.52) v1(264.06,9.79) v1(264.12,100.36) v1(264.6,95.47) v1(264.6,93.03) v1(264.6,91.81) v1(264.94,22.87) v1(265.66,76.98) v1(265.66,74.97) v1(265.79,56.36) v1(266.74,101.66) v1(266.85,77) v1(266.87,75) v1(266.95,9.79) v1(267.18,26.5) v1(267.2,25.44) v1(267.5,54.16) v1(267.61,66.59) v1(267.61,65.42) v1(267.61,64.23) v1(267.61,63.03) v1(267.61,61.69) v1(267.61,60.62) v1(267.61,59.32) v1(267.61,58.23) v1(267.97,33.44) v1(268.07,76.39) v1(268.07,74.41) v1(268.04,23.31) v1(268.09,78.4) v1(269.02,103.67) v1(269.29,50.94) v1(269.45,8.74) v1(270.25,30.49) v1(270.25,28.54) v1(270.26,23.17) v1(270.26,20.12) v1(270.26,16.46) v1(270.26,14.51) v1(270.26,10.98) v1(271.31,105.69) v1(271.4,31.83) v1(273.22,31.94) v1(273.59,107.71) v1(275.18,80.18) v1(275.21,77.41) v1(281.24,106.45) v1(281.29,89.21) v1(284.63,76.14) v1(284.68,63.51) v1(284.8,79.19) v1(285.04,60.7) v1(285.49,36.73) v1(285.6,81.8) v1(286.19,87.67) v1(286.95,49.63) v1(286.95,43.53) v1(287.33,106.47) v1(287.42,55.44) v1(287.96,79.85) v1(287.96,76.8) v1(287.96,64.61) v1(287.96,61.56) v2(231.42,36.23) v3(151.25,65.93) v5(10.26,32.86) v5(11.02,32.86) v5(11.78,32.86) v5(75.94,21.36) v5(75.94,20.6) v5(75.94,19.84) v5(76.76,21.36) v5(76.76,20.6) v5(76.76,19.84) v5(78.94,35.02) v5(79.7,35.02) v5(100.16,56.2) v5(100.46,69.46) v5(100.46,68.7) v5(100.46,67.94) v5(100.46,67.17) v5(100.48,66.4) v5(100.92,56.2) v5(101.24,70.2) v5(101.22,69.46) v5(101.22,68.7) v5(101.22,67.94) v5(101.22,67.17) v5(101.24,66.4) v5(101.68,56.2) v5(102,70.93) v5(102,70.17) v5(102,69.41) v5(102.45,56.2) v5(102.77,71.31) v5(102.74,70.55) v5(102.77,69.79) v5(103.53,71.69) v5(103.53,70.93) v5(103.5,70.19) v5(106.12,104.56) v5(106.12,103.8) v5(113.49,100.73) v5(113.56,101.91) v5(113.84,103.84) v5(113.9,102.76) v5(114.02,100.19) v5(114.11,101.36) v5(114.45,116.5) v5(114.43,103.3) v5(114.43,102.22) v5(114.56,99.65) v5(114.65,100.82) v5(114.97,102.76) v5(115.1,99.11) v5(115.21,116.5) v5(115.19,100.28) v5(115.64,98.58) v5(115.73,99.74) v5(116.27,99.2) v5(116.32,57.37) v5(116.33,56.58) v5(116.99,58.1) v5(117.75,58.1) v5(118.51,58.1) v5(118.67,57.34) v5(119.28,58.87) v5(119.28,58.1) v5(123.67,100.98) v5(124.15,100.38) v5(124.23,101.56) v5(124.51,103.49) v5(124.56,102.41) v5(124.78,101.01) v5(124.69,99.84) v5(125.1,102.95) v5(125.1,101.87) v5(125.23,99.3) v5(125.32,100.47) v5(125.64,102.41) v5(125.77,98.77) v5(125.86,99.93) v5(126.31,98.23) v5(126.4,99.39) v5(126.94,98.86) v5(138.66,105.48) v5(138.66,104.71) v5(138.66,103.95) v5(139.54,106.24) v5(139.54,105.48) v5(139.54,104.71) v5(139.54,103.95) v5(140.33,113.37) v5(140.43,106.24) v5(140.43,105.48) v5(140.43,104.71) v5(140.43,103.95) v5(141.32,106.24) v5(141.32,105.48) v5(141.32,104.71) v5(141.32,103.95) v5(142.08,109.21) v5(142.08,106.75) v5(142.08,105.98) v5(142.83,109.21) v5(142.83,106.75) v5(142.83,105.98) v5(143.2,105.32) v5(143.2,104.56) v5(150.59,104.89) v5(151.36,105.65) v5(151.36,104.89) v5(151.33,103.39) v5(151.33,102.63) v5(151.46,107.25) v5(151.91,7.94) v5(151.91,7.18) v5(152.22,107.25) v5(152.68,7.94) v5(153.44,7.94) v5(154.2,7.94) v5(154.96,7.94) v5(155.72,7.94) v5(158.57,94.76) v5(158.57,93.99) v5(165.71,105) v5(165.73,104.26) v5(166.56,105.01) v5(166.54,104.23) v5(178.33,102.55) v5(179.85,112.88) v5(179.81,101.28) v5(179.85,100.4) v5(180.62,101.28) v5(180.62,100.4) v5(182.39,111.19) v5(183.16,111.19) v5(185.19,103) v5(185.95,103) v5(186.71,103) v5(187.47,103) v5(228.88,86.32) v5(229.77,84.06) v5(229.77,83.3) v5(232.79,69.56) v5(232.79,68.8) v5(233.55,69.56) v5(233.55,68.8) v5(233.55,68.04) v5(234.31,68.8) v5(234.31,68.04) v5(235.07,68.04) v5(239.65,78.17) v5(239.72,82.63) v5(240.31,79.69) v5(240.31,78.93) v5(240.48,82.63) v5(240.41,78.17) v5(240.94,79.31) v5(241.25,82.63) v5(265.33,46.27) v5(265.58,45.51) v5(265.58,44.74) v5(266.34,45.51) v5(266.34,44.74)
