# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPP_A22: length 20.2
  TOP w0.102: v1(181.22,47.55) 181.61,47.94 v3(182.01,47.94) 182.18,47.77 182.18,45.9 182.58,45.5 182.58,43.07 R4707.2
  BOTTOM w0.076: v1(181.22,47.55) 181.27,47.6 181.27,47.98 178.15,51.11 175.8,51.11 174.92,51.98 174.24,51.98 172.85,53.37 172.85,54.63 172.81,54.74 172.81,54.98 172.85,55.1 172.85,55.28 172.83,55.34 U4555.CA35
GPP_A23: length 27.8
  TOP w0.102: R4549.2 195.16,47.88 194.25,47.88 v3(193.38,48.75) v1(192.47,49.66)
  L3 w0.076: 176.42,53.9 174.99,55.33 173.21,55.33 173.1,55.44 172.5,56.03 v1(172.5,56.98)
  L3 w0.102: v1(192.47,49.66) 191.82,50.31 188.66,50.31 186.34,52.63 177.69,52.63 176.42,53.9
  BOTTOM w0.076: v1(172.5,56.98) 172.59,56.89 U4555.CA34
GPP_D12: length 12.9
  BOTTOM w0.076: U4555.CP22 179.8,63.98 180.06,64.07 180.33,64.24 180.6,64.24 180.87,63.98 181.29,63.98 181.7,64.38 185.51,64.38 185.93,63.96 188,63.96
  BOTTOM w0.102: R4703.2 191.16,65.02 v3(191.16,64.28) 190.86,63.97 190.7,63.97 190.69,63.96 188,63.96
GPP_F22: length 22.3
  BOTTOM w0.076: U4555.CN16 179.53,67.43 180.04,67.43 180.29,67.29 180.3,67.29 180.68,67.29 180.89,67.49 181.21,67.49 181.67,67.03 182.35,67.03 182.94,66.44 185.83,66.44 187.39,67.99
  BOTTOM w0.102: R4811.1 R4538.1
  BOTTOM w0.13: R4538.1 195.56,72.33 195.82,72.07 195.82,71.01 195.31,70.5 v3(194.97,70.5) 194.97,70.15 193.33,68.51 190.27,68.51 189.75,67.99 187.39,67.99
GPP_F23: length 16.2
  TOP w0.076: 188.11,67.61 187.42,66.92 187.42,66.66 185.28,64.52 183.72,64.52 182.03,66.21 181.68,66.21 181.67,66.2 v3(181.25,66.2) 175.84,66.2 v1(175.46,66.58)
  TOP w0.102: 188.11,67.61 188.16,67.66 R4555.2
  BOTTOM w0.076: U4555.CF17 v1(175.46,66.58)
GPP_H0: length 17
  TOP w0.076: 183.28,57.21 183.01,56.93 177.2,56.93 v1(176.84,57.29)
  TOP w0.102: 183.28,57.21 184.59,58.51 186.28,58.51 186.89,59.13 187.57,59.13 187.7,59.26 190.31,59.26 190.47,59.41 190.47,60.13 TP4508.1
  BOTTOM w0.089: v1(176.84,57.29) 176.82,57.31 U4555.CH32
GPP_H8: length 13
  TOP w0.076: 183.28,58.07 182.75,57.54 180.9,57.54 180.51,57.93 v3(180.18,57.93) 179.49,58.62 178.03,58.62 v1(177.89,58.48)
  TOP w0.102: R4542.2 188.47,59.87 187.45,59.87 187.32,59.74 186.64,59.74 186.02,59.12 184.33,59.12 183.28,58.07
  BOTTOM w0.076: U4555.CJ30 v1(177.89,58.48)
GPP_H9: length 13.4
  TOP w0.076: v1(177.75,57.9) 177.94,57.71 v3(178.91,57.71) 179.27,57.34 182.84,57.34 183.28,57.78
  TOP w0.102: R4543.2 188.91,59.67 187.54,59.67 187.4,59.53 186.72,59.53 186.11,58.92 184.42,58.92 183.28,57.78
  BOTTOM w0.076: U4555.CJ31 v1(177.75,57.9)
GPS_XMIT_OFF#: length 64
  TOP w0.076: R4708.2 184.62,62.85 184.33,63.14 183.92,63.14 183.25,62.47 v1(183.25,62.35)
  TOP w0.102: v1(183.68,47.68) 184.28,48.26 189.8,48.26 192.09,45.97 193.73,45.97 194.51,45.2 195.41,45.2 196.08,44.53 203.88,44.53 204.61,45.25 206.12,45.25 206.2,45.18 207.31,45.18 v2(207.82,45.68)
  L5 w0.102: v1(183.68,47.68) 183.56,47.8 183.56,60.2 183.18,60.58 183.18,60.92 183.25,60.99 v1(183.25,62.35) ; v2(207.82,45.68) 207.62,45.89 207.62,55.42 207.79,55.6 207.79,56 v1(207.39,56.4)
  BOTTOM w0.076: U4555.CM24 178.77,63.02 179.66,63.02 180,62.9 180.25,62.9 180.37,62.94 182.66,62.94 v1(183.25,62.35)
  BOTTOM w0.102: CN1400.26 205,58.55 207.15,56.4 v1(207.39,56.4)
GPU_THRM_DMINUS: length 101.5
  L3 w0.097: v1(113.23,45.96) 113.23,46.55 112.1,47.67 112.1,77.22 116.12,81.24 116.12,83.74 v1(115.98,83.89)
  BOTTOM w0.104: v1(113.23,45.96) 113.25,45.99 113.78,45.99 116.71,43.06 151.64,43.06 153.46,44.88 164.26,44.88 164.82,44.32 166.96,44.32 Q4412.2 ; v1(115.98,83.89) 116.23,84.13 116.23,85.16 116.96,85.89 117.31,85.89 117.45,86.04 C4412.2 117.81,86.04 118.01,85.84 118.16,85.84 118.39,86.07 118.61,86.07 118.83,86.28 U4411.3
GPU_THRM_DPLUS: length 100.4
  L3 w0.097: v2(116.68,83.89) 116.32,83.52 116.32,81.16 112.3,77.14 112.3,47.75 v1(113.66,46.39)
  BOTTOM w0.104: U4411.2 117.84,85.63 C4412.1 117.45,85.54 117.31,85.69 117.05,85.69 116.43,85.07 116.43,84.14 v2(116.68,83.89) ; v1(113.66,46.39) 116.8,43.26 151.55,43.26 153.38,45.09 164.35,45.09 164.54,44.9 Q4412.3 166.39,44.9 Q4412.1
H_BPM0_XDP#: length 37
  TOP w0.102: CN4920.21 124.92,64.65 129.12,68.85 129.12,76.07 131.6,78.55 134.5,78.55 135.92,79.97 136.5,79.97 137,80.48 137.73,80.48 137.98,80.73 140.7,80.73 141.25,81.29 142.8,81.29 v1(143.07,81.01)
  BOTTOM w0.076: U4555.U1 145.28,77.51 144.98,77.8 144.98,79.97 144.81,80.14
  BOTTOM w0.13: v1(143.07,81.01) 143.41,81.34 v3(144.04,81.34) 144.52,80.87 144.52,80.44 144.81,80.14
H_BPM1_XDP#: length 38.4
  TOP w0.102: CN4920.23 125.14,65.15 128.92,68.93 128.92,76.16 131.51,78.75 134.41,78.75 135.84,80.18 136.42,80.18 136.92,80.68 137.64,80.68 137.9,80.94 140.61,80.94 141.5,81.82 v1(141.53,81.82)
  BOTTOM w0.076: 144.79,80.74 145.17,80.36 145.17,77.84 145.44,77.57 145.44,77.5 145.58,77.36 145.58,76.86 145.28,76.55 U4555.U2
  BOTTOM w0.13: 144.79,80.74 144.79,81.43 144.33,81.89 v3(142.84,81.89) 142.78,81.82 v1(141.53,81.82)
H_PECI: length 136.6
  TOP w0.13: v1(228.24,61.28) 228.24,61.07 230.82,58.5 232.3,58.5 232.79,58.01 232.79,55.93 233.49,55.23 R4606.2 234.29,54.8 v3(234.36,54.88) 235.21,54.88 235.75,54.34 235.75,51.48 R328.2
  L3 w0.097: v1(156.28,78.3) 156.28,80.11 159.08,82.91 159.08,88.09 159.32,88.33 160.31,88.33 161.89,89.9 162.24,89.9 167.56,95.22 169.14,95.22 170.9,96.99 190.95,96.99 191.13,97.17 191.83,97.17 192.01,96.99 194.65,96.99 194.66,96.98 196.18,96.98 196.19,96.99 197.07,96.99 199.35,94.72 209.3,94.72 211.13,96.55 211.13,98.48 211.98,99.33 213.17,99.33 213.4,99.09 213.4,97.43 216.43,94.4 216.43,93.37 217.18,92.63 217.18,92.29 217.18,92.29 217.18,91.89 221.74,87.33 221.74,79.57 220.77,78.6 v1(220.77,78.09)
  L6 w0.127: v1(228.24,61.28) 227.76,61.76 227.76,63.28 223.48,67.57 223.48,72.02 220.77,74.72 v1(220.77,78.09)
  BOTTOM w0.13: U4555.AR1 156.35,78.23 v1(156.28,78.3)
H_PECI_R: length 5
  TOP w0.076: U300.M7 238.67,44.98 238.67,45.44 238.78,45.56 238.78,46.43 238.76,46.45
  TOP w0.127: v3(237.44,48.4) 237.44,48.06 238.59,46.91 238.59,46.62 238.76,46.45
  TOP w0.13: R328.1 237.44,48.94 v3(237.44,48.4)
H_PRDY#: length 39.5
  TOP w0.102: CN4920.5 124.19,60.64 124.95,61.41 124.95,62.82 125.21,63.07 125.21,63.52 130.53,68.84 v1(130.53,75.17)
  L3 w0.102: v1(130.53,75.17) 130.96,75.6 131.8,75.6 136.89,80.7 140.75,80.7 141.63,79.82 145.64,79.82 v1(146.06,79.4)
  BOTTOM w0.076: v1(146.06,79.4) 146.06,79.26 145.64,78.84 145.64,78.49 145.87,78.26 146.04,78.26 146.59,77.71 U4555.W1
H_PREQ#: length 39.5
  TOP w0.102: CN4920.3 124.19,60.14 125.45,61.41 R4933.2 125.45,63.48 130.81,68.83 130.81,74.79 v2(131.21,75.2)
  L3 w0.102: v2(131.21,75.2) 131.71,75.2 137.01,80.49 140.55,80.49 141.45,79.59 145.22,79.59 v1(146.1,78.71)
  BOTTOM w0.076: U4555.W2 146.59,76.75 146.85,77.01 146.85,77.83 146.1,78.58 v1(146.1,78.71)
H_PWRGD: length 4.8
  TOP w0.076: v1(155.67,78.3) 155.18,77.81 v3(154.15,77.81) 153.57,77.23
  TOP w0.102: 153.57,77.23 153.46,77.12 R4527.1
  BOTTOM w0.076: v1(155.67,78.3) 156.09,77.88 156.09,76.78 U4555.AR2
H_TCK: length 34.4
  TOP w0.076: v1(144.74,74.03) 144.36,74.41 144.36,74.83 144.38,74.85 144.38,75.78
  TOP w0.13: v1(125.37,75.18) 125.37,74.61 124.4,73.64 CN4920.57 ; 144.38,75.78 144.23,75.94 R4500.1 R4509.1 144.23,78.1 v3(144.22,78.12)
  L3 w0.097: v1(125.37,75.18) 125.37,75 126.23,74.13 132.01,74.13 137.02,79.15 140.48,79.15 141.22,78.41 143.59,78.41 145.16,76.85 145.16,74.46 144.74,74.04 v1(144.74,74.03)
  BOTTOM w0.13: v1(144.74,74.03) U4555.T6
H_TDI: length 43.6
  TOP w0.13: v1(145.67,74.03) 145.15,74.55 145.15,74.84 145.05,74.94 145.05,79.83 145.08,79.86 145.08,80.69 142.66,83.11 140.44,83.11 137.84,85.72 v1(137.84,86.4) 136.91,87.33 126.66,87.33 123.66,84.33 120.09,84.33 116.65,80.89 v3(116.28,80.89) 115.87,80.48 R4615.2
  BOTTOM w0.13: R4508.1 v1(137.84,86.4) ; v1(145.67,74.03) U4555.U6
H_TDO: length 56.4
  TOP w0.13: R4612.2 113.88,75.6 v3(113.23,75.6) 112.77,76.07 112.77,82.97 116.37,86.58 116.89,86.58 124.28,86.58 126.06,88.36 138.52,88.36 v1(140.48,86.4) 141.73,85.16 144.16,85.16 145.81,83.51 147.33,81.99 147.33,75.36 147.47,75.22 147.47,74.71 v1(147.51,74.67)
  BOTTOM w0.13: U4555.Y5 v1(147.51,74.67) ; R4920.1 v1(140.48,86.4)
H_TMS: length 42.8
  TOP w0.13: R4614.1 115.73,79.59 120.21,84.08 123.89,84.08 126.89,87.08 136.2,87.08 v1(136.87,86.4) 136.87,85.49 139.51,82.85 142.18,82.85 v3(142.44,82.59) 142.82,82.59 144.82,80.59 144.82,79.96 144.79,79.93 144.79,75.89 144.83,75.85 144.83,74.75 v1(144.74,74.67)
  BOTTOM w0.13: v1(144.74,74.67) U4555.T5 ; R4507.1 v1(136.87,86.4)
H_TRST#: length 48.7
  TOP w0.076: v1(147.48,74.08) 146.68,74.87 146.68,75.65
  TOP w0.13: 146.68,75.65 146.81,75.78 146.81,80.06 v3(143.25,83.62) 140.66,83.62 139.15,85.13 139.15,86.57 137.87,87.85 126.28,87.85 124.5,86.07 117.37,86.07 116.82,85.52 116.21,85.52 113.46,82.78 R4526.1 113.46,82.03 114.07,81.42 R4613.1
  BOTTOM w0.13: U4555.AB6 147.7,74.09 v1(147.48,74.08) U4555.Y6
HDA_BCLK: length 164.5
  TOP w0.13: C7625.1 25.53,37.76 v1(25.55,37.78) 25.55,37.8 25.55,37.8 25.55,38.46 25.37,38.65 U500.14 ; R4910.1 174.74,44.36 175.07,44.69 v2(175.07,44.85)
  L3 w0.097: v1(25.55,37.78) 25.56,37.78 26.01,37.34 26.46,37.34 26.9,36.9 40.53,36.9 41.48,35.95 46.8,35.95 48.69,34.07 60.36,34.07 60.84,33.59 66.53,33.59 69.88,36.94 70.77,36.94 71.32,37.49 71.88,37.49 72.42,38.03 72.85,38.03 73.1,38.28 73.97,38.28 74.99,39.3 75.49,39.3 75.93,39.3 77.33,40.71 89.32,40.71 89.57,40.95 92.13,40.95 97.63,46.46 103.99,46.46 v1(104.47,45.98)
  BOTTOM w0.13: v1(104.47,45.98) 106.84,43.6 108.4,43.6 109.1,43.6 112.87,39.83 153.19,39.83 154.45,41.08 171.46,41.08 175.07,44.69 v2(175.07,44.85)
HDA_BCLK_PCH: length 16.2
  TOP w0.13: R4910.2 175.02,43.4 175.27,43.66 175.27,44.04 175.62,44.39 175.62,46.41 175.69,46.49 175.69,46.76 175.02,47.42 v1(174.91,47.42)
  BOTTOM w0.076: U4555.BN37 167.69,54.39 167.69,53.24 168.01,52.92 168.69,52.92 168.97,52.71 170.72,50.96 171.44,50.96 173.34,49.06 173.34,48.67 173.56,48.45 173.88,48.45 v3(174.4,47.92) v1(174.91,47.42)
HDA_RST#_PCH: length 16.5
  TOP w0.13: v2(173.88,46.15) 174.05,45.98 174.05,45.11 173.25,44.32 R4901.2
  BOTTOM w0.076: U4555.BL35 166.36,55.83 166.66,55.22 166.66,54.42 166.31,54.07 166.31,53.41 167.3,52.42 168.53,52.42 168.65,52.34 170.52,50.47 171.23,50.47 172.74,48.96 172.74,47.38 172.82,47.31
  BOTTOM w0.13: 172.82,47.31 173.17,46.96 173.17,46.86 v2(173.88,46.15)
HDA_SDI0: length 173.9
  TOP w0.13: R504.2 27.26,37.93 v1(27.72,37.93)
  L3 w0.097: v1(107.74,45.98) 106.34,47.38 97.25,47.38 91.75,41.88 89.19,41.88 88.94,41.63 76.94,41.63 75.54,40.23 74.6,40.23 73.58,39.21 72.72,39.21 72.46,38.95 72.03,38.95 71.5,38.42 70.94,38.42 70.39,37.87 69.49,37.87 66.14,34.52 61.23,34.52 60.94,34.8 60.75,35 49.07,35 47.19,36.88 46.42,36.88 42.58,36.88 40.78,38.68 38.82,38.68 38.02,37.88 30.91,37.88 30.27,38.53 28.31,38.53 v1(27.72,37.93)
  BOTTOM w0.076: U4555.BN35 167.3,55.31 167.2,54.82 167.13,54.68 167.13,54.31 167.34,54.1 167.34,53.55 167.36,53.52 167.36,53.1 167.88,52.59 168.59,52.59 168.76,52.46 170.59,50.63 171.3,50.63 173.01,48.92 173.01,47.6 173.1,47.52
  BOTTOM w0.13: v1(107.74,45.98) 109.09,44.63 109.44,44.63 109.52,44.63 113.3,40.85 152.77,40.85 154.02,42.11 171.04,42.11 174.05,45.11 174.05,45.74 174.29,45.98 174.29,46.33 173.1,47.52
HDA_SDI0_R: length 2.5
  TOP w0.13: R504.1 26.72,38.14 25.41,39.45 U500.16
HDA_SDO: length 250
  TOP w0.13: v2(211.15,46.83) 209.78,46.83 209.35,47.25 204.82,47.25 203.36,45.78 196.6,45.78 195.93,46.46 195.03,46.46 194.26,47.23 192.61,47.23 190.33,49.52 176.28,49.52 174.18,47.42 v1(173.83,47.42) ; Q4754.3 249.49,49.88 v1(247.14,47.59)
  L3 w0.097: v1(247.14,47.59) 246.07,46.52 243.63,46.52 242.59,47.57 240.12,47.57 239.88,47.81 236.23,47.81 236.18,47.76 232.95,47.76 232.93,47.74 232.22,47.74 232.03,47.74 231.82,47.53 230.72,47.53 225.48,42.28 223.76,42.28 222.34,43.7 220.53,43.7 218.85,43.7 216.77,45.78 216.16,45.78 216.16,45.78 212.19,45.78 v2(211.15,46.83) ; v1(107.06,45.98) 105.88,47.16 97.34,47.16 91.84,41.65 89.28,41.65 89.03,41.41 77.04,41.41 75.64,40.01 74.7,40.01 73.68,38.99 72.81,38.99 72.56,38.73 72.13,38.73 71.59,38.19 71.03,38.19 70.48,37.64 69.58,37.64 66.24,34.29 61.13,34.29 60.66,34.77 48.98,34.77 47.09,36.65 46.51,36.65 46.51,36.65 41.77,36.65 40.82,37.6 39.8,37.6 v1(39.12,38.28)
  BOTTOM w0.076: 173.68,47.57 173.18,48.07 173.18,48.99 171.37,50.8 170.66,50.8 168.86,52.59 168.64,52.75 167.95,52.75 167.53,53.17 167.53,54.14 167.29,54.38 167.29,54.64 U4555.BN36
  BOTTOM w0.13: v1(39.12,38.28) 38.69,37.84 Q4756.D ; v1(107.06,45.98) 108.66,44.37 109.33,44.37 109.33,44.37 109.42,44.37 113.19,40.59 152.87,40.59 154.13,41.85 171.14,41.85 174.3,45.01 174.3,45.63 174.51,45.84 174.51,46.74 v1(173.83,47.42) 173.68,47.57
HDA_SDO_Q: length 0.8
  BOTTOM w0.13: R4869.2 39.84,34.68 Q4756.S
HDA_SDO_R: length 18.1
  TOP w0.13: v1(25.83,39.71) 25.7,39.85 U500.17
  L3 w0.097: v1(37.87,38.31) 37.67,38.1 31.01,38.1 30.36,38.75 26.8,38.75 v1(25.83,39.71)
  BOTTOM w0.13: v1(37.87,38.31) 38.27,37.91 38.27,35.29 39.08,34.48 R4869.1
HDA_SYNC: length 166.8
  TOP w0.13: v1(175.03,46.08) 174.56,45.6 174.56,44.9 174.23,44.57 174.23,44.02 173.96,43.76 R4903.1 v3(173.89,43.02) ; v1(26.18,37.89) 26.13,37.93 26.13,38.34 25.43,39.05 U500.15
  L3 w0.097: v1(26.18,37.89) 26.59,37.89 27.1,37.38 40.72,37.38 41.67,36.43 46.61,36.43 47,36.43 48.88,34.55 60.56,34.55 61.04,34.07 66.33,34.07 69.68,37.42 70.57,37.42 71.13,37.97 71.68,37.97 72.22,38.51 72.65,38.51 72.91,38.76 73.77,38.76 74.79,39.78 75.73,39.78 77.13,41.18 89.13,41.18 89.37,41.43 91.93,41.43 97.44,46.93 104.8,46.93 104.8,46.93 v1(105.76,45.98)
  BOTTOM w0.13: v1(175.03,46.08) 175.03,46 174.56,45.53 174.56,44.9 171.25,41.59 154.23,41.59 152.98,40.34 113.08,40.34 109.31,44.11 109.22,44.11 107.63,44.11 v1(105.76,45.98)
HDA_SYNC_PCH: length 17.3
  TOP w0.13: R4903.2 173.89,44.58 173.89,44.59 174.3,45.01 174.3,45.87 174.38,45.95 174.38,46.1 v2(175.01,46.74)
  BOTTOM w0.076: 173.78,49.38 173.64,49.51 173.13,49.51 171.51,51.13 170.79,51.13 169.08,52.84 168.75,53.08 168.08,53.08 167.86,53.31 167.86,54.75 167.82,54.78 167.82,55.35 167.82,56.21 U4555.BN34
  BOTTOM w0.13: 173.78,49.38 175.42,47.74 175.42,47.14 v2(175.01,46.74)
HP_OUT_L1: length 23.2
  TOP w0.254: v1(4.81,45.01) 5.7,45.9 TP2515.1 ; U500.27 23.45,44.18 v1(23.6,44.33)
  L3 w0.254: v1(23.6,44.33) 22.81,45.12 21.46,45.12 20.67,45.91 10.3,45.91 10.09,45.71 5.84,45.71 5.81,45.68 5.48,45.68 v1(4.81,45.01)
  BOTTOM w0.254: CN2500.24 4.75,44.95 v1(4.81,45.01)
HP_OUT_L1_DB: length 3.1
  TOP w0.254: v2(35.8,73.4) 35.8,73.8 35.5,74.11 R9230.1
  BOTTOM w0.254: CN9202.7 35.75,73.34 v2(35.8,73.4)
HP_OUT_R1: length 25.1
  TOP w0.254: v1(23.97,45) 24.13,44.85 24.13,44.13 23.85,43.85 U500.26 ; v1(4.25,44.79) 4.25,45.7 TP2517.1
  L3 w0.254: v1(23.97,45) 23.34,45.63 21.67,45.63 20.88,46.42 10.09,46.42 9.88,46.22 5.17,46.22 4.25,45.29 v1(4.25,44.79)
  BOTTOM w0.254: v1(4.25,44.79) CN2500.25
HP_OUT_R1_DB: length 2.6
  TOP w0.254: v1(35.25,72.91) 34.88,72.91 v3(34.53,73.27) 33.77,73.27 R9231.1
  BOTTOM w0.254: CN9202.6 v1(35.25,72.91)
HP_OUT_R_L1_DB: length 1.9
  TOP w0.254: R9200.1 32.74,74.3 v3(32.97,74.08) 32.99,74.11 R9230.2
HP_OUT_R_R1_DB: length 2.8
  TOP w0.254: R9231.2 32.59,72.94 31.85,72.94 31.62,72.71 R9201.1 v3(31.18,71.85)
HP_OUT_R_R_L1_DB: length 5.1
  TOP w0.254: R9200.2 31.28,73.45 v3(31.19,73.55) 31.11,73.63 C9228.1 30.1,73.58 28.97,72.45 JACK9200.1
HP_OUT_R_R_R1_DB: length 14.8
  TOP w0.254: v2(30.87,68.61) 30.87,68.14 30.62,67.89 C9227.1 ; R9201.2 v1(30.33,72.08)
  L3 w0.254: JACK9200.2 23.85,73.8 28.58,73.8 30.3,72.08 v1(30.33,72.08) 30.38,72.04 30.38,70.22 30.63,69.97 30.63,68.86 v2(30.87,68.61)
HP_VERF_L: length 2.8
  TOP w0.254: R511.1 23.39,44.84 23.05,44.5 U500.28
HP_VERF_R: length 1.6
  TOP w0.102: TP508.1 22.68,44.81 22.68,43.38 U500.29
HPOUT_DET: length 25.3
  TOP w0.102: R503.2 16.68,33.72 17.18,33.22 v1(18.45,33.22) ; v1(3.28,44.82) 3.28,44.53 TP2518.1
  L3 w0.102: v1(3.28,44.82) 3.28,42.93 6.37,39.84 9.38,39.84 12.67,36.55 15.16,36.55 16.67,35.04 16.67,34.98 18.43,33.22 v1(18.45,33.22)
  BOTTOM w0.102: CN2500.27 3.25,44.78 v1(3.28,44.82)
HPOUT_DET_DB: length 24.3
  L3 w0.102: v2(33.94,71.11) 33.94,72.86 33.84,72.96 31.38,72.96 31.28,72.86 31.28,64.32 29.33,62.38 26.72,62.38 25.65,63.45 JACK9200.6
  BOTTOM w0.102: v2(33.94,71.11) 34.25,71.42 CN9202.4
I2C_ALS_SMCLK: length 90.2
  TOP w0.076: 188,66.29 187.76,66.29 185.5,64.02 182.98,64.02 182.12,63.16 177.67,63.16 v1(177.36,63.47)
  TOP w0.13: 188,66.29 188.42,66.29 188.63,66.5 189.24,66.5 189.78,67.04 189.98,67.04 190.75,67.81 207.56,67.81 208.11,68.37 209.2,68.37 209.65,68.81 213.12,68.81 213.68,68.25 214.96,68.25 215.99,69.28 v1(217.67,69.28) 217.67,69.77 R4591.2
  BOTTOM w0.13: v1(217.67,69.28) 218.21,69.81 218.21,70.08 218.21,70.86 218.91,71.57 218.91,75.8 218.29,76.42 217.24,77.47 217.24,78.81 215.92,80.13 215.92,81.19 218.23,83.5 218.23,87.06 216.82,88.46 216.82,99.48 217.31,99.96 217.31,102.01 221.13,105.83 v3(221.48,105.83) 221.91,106.25 CN3001.18 ; U4555.CJ22 v1(177.36,63.47)
I2C_ALS_SMDATA: length 93.7
  TOP w0.076: v1(176.73,63.47) 177.22,62.98 177.77,62.98 177.79,62.99 182.05,62.99 182.19,62.99 183.05,63.86 185.57,63.86 187.72,66.01 187.9,66.01
  TOP w0.13: R4590.2 v1(218.28,69.28) 217.86,68.86 215.94,68.86 215.07,67.99 213.58,67.99 213.02,68.55 209.75,68.55 209.31,68.11 208.22,68.11 207.66,67.56 190.86,67.56 190.08,66.78 189.89,66.78 189.35,66.24 188.73,66.24 188.5,66.01 187.9,66.01
  BOTTOM w0.13: CN3001.19 224.26,106.75 224.02,106.51 221.44,106.51 216.81,101.88 v3(216.81,100.17) 216.57,99.92 216.57,88.36 217.97,86.95 217.97,83.6 215.66,81.3 215.66,80.02 216.99,78.7 216.99,77.36 218.18,76.16 218.66,75.69 218.66,71.68 217.95,70.97 217.95,70.15 217.25,69.45 217.25,69.11 217.5,68.86 217.86,68.86 v1(218.28,69.28) ; U4555.CH22 v1(176.73,63.47)
I2C_TOUCH_CLK: length 324.6
  TOP w0.13: Q3005.3 23.08,13.63 23.52,13.2 24.78,13.2 R3010.2 26.37,13.81 v3(27.12,14.57) 29,14.57 v1(29.36,14.92)
  L6 w0.076: 182.89,66.88 180.76,69 178.46,69 178.29,69.18 177.88,69.18 v1(177.36,69.7)
  L6 w0.127: 182.89,66.88 199.88,66.88 201.01,66.88 202.85,65.03 202.85,62.83 202.85,62.47 207.81,57.52 207.81,47.25 208.82,46.24 208.82,43.52 213.32,39.02 213.32,37.91 223.69,27.54 229.64,27.54 230.82,26.35 233.81,26.35 237.23,22.93 237.23,21.71 240.99,17.95 240.99,13.83 239.02,11.86 169.88,11.86 168.59,10.57 162.77,10.57 161.57,11.76 161.36,11.76 93.37,11.76 92.9,12.23 88.14,12.23 85.52,14.85 57.46,14.85 55.7,16.61 52.45,16.61 51.49,15.65 45.2,15.65 44.79,16.07 36.19,16.07 35.04,14.92 v1(29.36,14.92)
  BOTTOM w0.13: U4555.CJ12 v1(177.36,69.7)
I2C_TOUCH_DAT: length 323.8
  TOP w0.13: v1(29.11,16.04) 28.92,15.86 v3(26.13,15.86) R3013.2 25.08,15.86 25.03,15.81 24.88,15.81 Q3005.6
  L6 w0.076: 182.94,67.13 180.58,69.49 178.2,69.49 v1(178,69.7)
  L6 w0.127: v1(29.11,16.04) 28.85,15.79 28.85,14.8 29.14,14.51 29.63,14.51 29.73,14.61 35.09,14.61 36.29,15.81 44.68,15.81 45.1,15.4 51.59,15.4 52.55,16.36 55.59,16.36 57.36,14.59 85.42,14.59 88.04,11.98 92.8,11.98 93.26,11.51 161.47,11.51 162.66,10.31 168.69,10.31 169.99,11.61 239.13,11.61 241.24,13.72 241.24,18.08 237.48,21.84 237.48,23.04 233.91,26.61 230.93,26.61 229.74,27.79 223.8,27.79 213.58,38.01 213.58,39.12 209.08,43.62 209.08,46.34 208.06,47.35 208.06,57.62 203.11,62.58 203.11,65.14 201.11,67.13 200.41,67.13 182.94,67.13
  BOTTOM w0.13: U4555.CK12 v1(178,69.7)
I2C_TOUCH_Q_CLK: length 15.2
  TOP w0.13: v1(25.27,14.82) 25.02,14.57 25.02,14 24.55,13.54 R4928.2 24.23,14.16 Q3005.4
  BOTTOM w0.13: CN3000.11 21.14,22.75 21.56,22.33 22.86,22.33 25.48,19.7 25.48,19.35 25.03,18.89 25.03,17.29 25.27,17.05 v1(25.27,14.82)
I2C_TOUCH_Q_DAT: length 10.5
  TOP w0.13: Q3005.1 23.65,15.93 R4927.2 23.65,16.78 23.65,16.78 v2(23.75,16.88)
  BOTTOM w0.13: v2(23.75,16.88) 22.73,16.88 22.35,17.26 22.35,21.18 21.28,22.25 CN3000.10
I_SET: length 22.4
  TOP w0.102: R60094.2 192.53,112.66 192.53,112.66 193.2,113.33 195.21,113.33 195.41,113.14 196.59,113.14 197.09,112.64 197.27,112.46 v1(197.51,112.46)
  L6 w0.102: v1(197.51,112.46) 200.03,114.98 209.16,114.98 v2(211.3,112.84)
  BOTTOM w0.102: v2(211.3,112.84) 211.42,112.72 211.42,112.72 Q68051.3
ILIM_HI: length 2.3
  TOP w0.102: R2500.2 25.74,26.69 24.71,27.73 U2501.16
ILIM_LO: length 3.2
  TOP w0.102: R2501.1 25.88,26 24.21,27.67 24.21,27.79 24.21,27.79 U2501.15
ILIM_SEL: length 304.3
  TOP w0.076: v1(256.82,28.87) 256.73,28.87 ; U300.A12 v1(234.79,37.71)
  TOP w0.102: v3(254,28.34) 254.15,28.49 R2427.1 255.24,28.94 255.94,28.94 256.01,28.87 256.73,28.87 ; U2501.4 26.9,30.65 R2502.1 27.88,30.75 R2503.2 27.94,30.76 28.36,31.18 31.39,31.18 v1(31.77,31.56)
  L3 w0.076: 232.51,37.14 233.35,37.98 234.52,37.98 v1(234.79,37.71)
  L3 w0.102: 232.51,37.14 232.3,36.93 232.3,32.71 235.25,29.76 235.25,27.55 v1(235.66,27.14) ; v1(101.8,30.43) 101.8,29.13 99.36,26.69 99.36,26.4 99.12,26.16 98,26.16 85.42,13.59 64.6,13.59 63.4,14.8 50.05,14.8 47.8,12.55 47.8,11.09 46.55,9.84 31.74,9.84 30.92,10.65 27.21,10.65 26.77,11.09 26.77,11.43 27.01,11.67 27.03,11.67 27.05,11.68 27.05,15.21 31.26,19.43 31.26,30.23 31.77,30.74 v1(31.77,31.56)
  L5 w0.102: v1(256.82,28.87) 256.59,28.64 256.59,24.28 254.83,22.52 246.11,22.52 244.11,20.51 243.77,20.51 243.53,20.75 243.53,21.02 241.6,22.96 241.26,22.96 240.67,23.54 239.26,23.54 v1(235.66,27.14)
  BOTTOM w0.076: 232.51,37.66 232.84,37.66 233.28,37.23 234.31,37.23 234.79,37.7 v1(234.79,37.71)
  BOTTOM w0.102: 232.51,37.66 229.59,37.66 229.59,37.65 229.17,37.65 225.67,34.15 223.39,34.15 216.23,26.99 173.84,26.99 172.57,25.72 145.95,25.72 145.3,26.36 139.17,26.36 138.94,26.6 137.02,26.6 136.38,27.25 104.98,27.25 v1(101.8,30.43)
ILIM_SEL_PD: length 3.7
  TOP w0.076: U2403.H10 259,27.83 258.75,28.08 257.29,28.08
  TOP w0.102: R2427.2 255.73,28.49 256.13,28.08 257.29,28.08
IMVP_PSYS: length 229.4
  TOP w0.102: R66195.1 107.92,100.5 107.92,96.71 108.12,96.5 108.12,96.03 107.39,95.29 v1(107.16,95.29) ; R443.1 v1(247.75,40.71) ; U60000.30 v1(192.95,102.99) 192.95,100.66 194.31,99.3 R60022.1
  L5 w0.102: v1(220.65,108.88) 222.07,107.46 222.07,105.69 221.38,105 221.38,103.95 224.47,100.87 224.47,98.43 223.72,97.68 223.72,91.77 227.12,88.37 227.12,84.14 229.64,81.62 232.97,81.62 236.67,77.92 238.05,77.92 238.66,77.31 241.16,77.31 241.61,77.76 243.9,77.76 244.24,77.42 244.24,72.61 246.28,70.58 247.74,70.58 248.21,70.1 248.21,67.95 247.66,67.4 247.53,67.4 247.29,67.16 247.29,62.09 248.33,61.05 248.33,59.93 247.95,59.55 247.95,50.59 248.33,50.2 248.33,47.01 247.84,46.52 247.5,46.52 246.76,45.78 246.76,45.28 247.34,44.69 247.92,44.69 248.51,44.1 248.51,41.47 v1(247.75,40.71)
  L6 w0.102: v1(107.16,95.29) 107.59,95.72 123.78,95.72 125.2,97.14 127.1,97.14 127.86,97.91 155.25,97.91 161.06,103.72 168.88,103.72 170.61,105.45 172.16,105.45 172.36,105.65 181.85,105.65 184.99,102.51 187.67,102.51 189.06,103.9 192.03,103.9 v1(192.95,102.99) 193.32,102.99 194.01,103.67 194.34,103.67 197.69,103.67 199.32,105.3 200.63,105.3 203.32,107.99 204.94,107.99 207.06,110.11 208.94,110.11 211.26,107.79 213.74,107.79 214.55,106.97 215.8,106.97 216.62,107.79 219.55,107.79 v1(220.65,108.88)
INPUT3VSEL: length 37
  TOP w0.102: v1(193.13,50.95) 194.57,50.95 v3(195.25,50.28) 195.56,49.96 R4579.2 195.98,49.91 196.26,49.64 196.7,49.64 197.04,49.97 R4582.1
  L6 w0.076: 171.12,54.16 171.12,55.57 170.31,56.38 170.31,56.57 170.08,56.81 170.08,57.55 170.06,57.57 170.06,60 v1(169.56,60.5)
  L6 w0.102: v1(193.13,50.95) 192.29,50.11 188.58,50.11 186.76,51.93 174.71,51.93 173.9,52.74 171.62,52.74 171.46,52.74 171.12,53.08 171.12,54.16
  BOTTOM w0.076: U4555.BT27 169.28,60.78 v1(169.56,60.5)
INTRUDER#: length 263.7
  L6 w0.102: v2(29.23,9.58) 30.02,10.37 44.64,10.37 44.74,10.28 49.19,10.28 49.77,9.69 50.24,9.69 52.33,11.79 53.2,11.79 54.83,10.15 55.95,10.15 56.72,9.38 56.72,6.04 56.82,5.94 62.43,5.94 62.57,6.08 70.23,6.08 72.17,8.01 101.52,8.01 104.14,5.4 104.14,4.89 105.44,3.59 112.86,3.59 114.7,1.75 131.29,1.75 131.73,2.19 131.73,2.39 131.78,2.45 132.98,3.64 151.49,3.64 152.24,2.9 156.64,2.9 157.21,2.33 169.16,2.33 169.18,2.35 177.53,2.35 178.04,1.84 188.78,1.84 191.07,4.13 194.59,4.13 194.75,4.29 214.94,4.29 215.67,3.56 219.22,3.56 220.33,4.67 227.4,4.67 227.47,4.74 229.39,4.74 229.86,4.28 235.39,4.28 236.07,3.61 239.49,3.61 240.21,4.33 240.21,6.07 242.2,8.07 242.63,8.07 242.94,8.38 254.29,8.38 255.2,7.48 259.27,7.48 259.74,7.94 v1(261.31,7.94)
  BOTTOM w0.102: v1(261.31,7.94) 261.37,7.94 261.73,8.31 R1008.2 262.33,8.17 SW1002.2 SW1002.1 ; SW1001.2 SW1001.1 23.23,8.8 23.74,8.28 23.82,8.21 R1011.1 27.51,7.86 v2(29.23,9.58)
INTRUDER#_PCH: length 387.4
  TOP w0.102: v1(24.99,7.36) 20.99,7.36 19.9,8.45 v1(19.9,9.28) ; v1(240.95,11.32) 241.51,11.32 243.37,13.18 243.37,17.2 240.01,20.56 235.02,20.56 234.77,20.81 234.77,23.54 234.11,24.19 220.89,24.19 218.39,26.69 218.39,32.89 212.45,38.82 190.12,38.82 189.81,39.14 178.93,39.14 176.12,41.95 176.12,42.35 176.15,42.38 176.15,43.68 176.5,44.02 176.5,45.87 176.66,46.03 176.66,46.32 v1(176.19,46.79)
  L3 w0.102: v1(258.21,8.29) 256.37,10.12 253.57,10.12 251.91,11.78 242.66,11.78 242.2,11.32 v1(240.95,11.32) 240.33,11.32 238.48,9.47 232.64,9.47 228.56,5.38 228.56,5.26 v1(227.64,4.34)
  L6 w0.102: v1(227.64,4.34) 226.66,3.36 195.66,3.36 195.09,3.93 191.16,3.93 188.87,1.64 177.95,1.64 177.45,2.15 169.27,2.15 168.72,1.6 157.65,1.6 156.63,2.62 152.22,2.62 151.41,3.44 133.06,3.44 131.93,2.31 131.93,2.1 131.38,1.55 114.61,1.55 112.78,3.38 105,3.38 102.48,5.9 102.48,6.76 101.44,7.81 72.26,7.81 70.32,5.87 62.65,5.87 62.52,5.74 62.35,5.74 56.74,5.74 56.52,5.96 56.52,9.29 55.86,9.95 55.07,9.95 54.75,9.95 53.12,11.58 52.42,11.58 50.33,9.49 49.69,9.49 49.22,9.96 44.77,9.96 44.56,10.16 31.14,10.16 v2(30.52,9.55)
  BOTTOM w0.076: v1(176.19,46.79) 175.69,47.29 175.69,47.94 173.96,49.67 173.2,49.67 171.58,51.29 170.86,51.29 169.19,52.96 168.93,53.15 168.92,53.19 168.78,53.31 168.75,53.37 168.69,53.43 168.67,53.5 168.62,53.53 168.62,53.54 168.51,53.92 168.43,54.41 168.43,54.66 168.44,54.69 168.53,54.95 168.53,55.23 168.74,55.71 U4555.BR35
  BOTTOM w0.102: v2(30.52,9.55) 28.63,7.65 25.29,7.65 v1(24.99,7.36) R1011.2 ; C1002.1 261.3,2.6 261.1,2.4 Q1004.G 260.57,2.78 260.57,2.78 R1009.1 260.57,3.28 261.49,4.2 261.49,7.19 260.64,8.04 259.17,8.04 258.64,7.52 258.64,6.29 258.37,6.01 258.37,5.19 SW1002.3 SW1002.4 257.98,8.06 v1(258.21,8.29) ; v1(19.9,9.28) 19.62,9 SW1001.3 SW1001.4
IOT_I2C_EC_INT#: length 60.8
  TOP w0.076: U300.D5 v1(240.18,39.34)
  L5 w0.102: v1(220.75,66.56) 221.92,65.39 221.92,64.03 223.64,62.3 223.64,62.01 226.54,59.12 228.7,59.12 229.14,58.69 229.14,57.83 229.9,57.06 234.55,57.06 236.74,54.87 236.74,52.25 v2(236.33,51.85)
  L6 w0.076: v1(240.18,39.34) 240.53,39.69 240.53,40.2 239.8,40.93 239.38,40.93 239.17,41.14 239.17,42.15 239.4,42.37 239.4,43.45 239.15,43.7 239.15,44.02 240.36,45.22 240.36,46.94
  L6 w0.102: v2(236.33,51.85) 237.28,51.85 239.34,49.78 239.34,48.05 240.36,47.03 240.36,46.94
  BOTTOM w0.102: v2(236.33,51.85) 238.28,49.9 238.28,49.9 R354.1 ; R1409.2 209.04,66.42 211.27,66.42 211.38,66.32 211.38,65.53 211.61,65.29 211.95,65.29 212.19,65.53 212.19,66.46 212.29,66.56 v1(220.75,66.56)
IOT_I2C_EC_SCL: length 61.4
  TOP w0.076: v1(235.28,46.57) 234.63,47.22 234.18,47.22 233.38,48.02 ; v1(237.58,43.24) U300.J8
  TOP w0.13: R391.1 231.8,48.88 v3(232.13,48.55) 232.27,48.41 233,48.41 233.38,48.02
  L3 w0.076: v1(235.28,46.57) 235.28,45.54 v1(237.58,43.24)
  L6 w0.076: v1(235.28,46.57) 234.91,46.94
  L6 w0.127: 234.91,46.94 232.86,48.99 222.33,48.99 221.75,49.57 221.75,51.75 222.82,52.82 222.82,62.53 220.38,64.97 220.38,65.76 219.94,66.2 219.94,67.78 v1(220.11,67.96)
  BOTTOM w0.13: v1(220.11,67.96) 219.95,67.8 214.9,67.8 214.65,67.55 211.94,67.55 211.39,67 207.59,67 206.26,65.67 206.26,64.66 205.76,64.16 R1407.2
IOT_I2C_EC_SDA: length 58
  TOP w0.076: U300.J9 v1(236.93,43.24) ; 233.02,48.02 234.01,47.03 234.29,47.03 v1(234.69,46.62)
  TOP w0.13: 233.02,48.02 232.99,48.05 231.95,48.05 231.94,48.06 231.92,48.06 231.19,48.79 R394.1 230.76,49.24 230.48,48.96 230.37,48.96 v1(229.92,49.41)
  L3 w0.076: v1(234.69,46.62) 234.69,45.84 236.93,43.6 v1(236.93,43.24)
  L6 w0.127: v1(220.88,68.65) 220.88,67.4 220.49,67.02 220.42,67.02 220.19,66.79 220.19,66.31 220.63,65.86 220.63,65.08 223.07,62.64 223.07,52.72 222.01,51.65 222.01,49.68 222.44,49.24 229.75,49.24 v1(229.92,49.41)
  BOTTOM w0.13: v1(220.88,68.65) 220.88,68.13 220.29,67.54 215,67.54 214.76,67.3 212.05,67.3 211.5,66.74 207.7,66.74 206.65,65.7 R1402.2
IOT_I2C_WWAN_INT#: length 7.6
  BOTTOM w0.102: R1409.1 207.1,65.33 207.1,62.2 v3(207.16,62.14) 206.55,61.53 206.55,61.27 206.25,60.97 205.65,60.97 205.5,60.82 CN1400.28
IOT_I2C_WWAN_SCL: length 4.3
  BOTTOM w0.13: R1407.1 205.76,62.5 v3(204.75,61.48) 204.21,60.95 203.63,60.95 203.5,60.82 CN1400.20
IOT_I2C_WWAN_SDA: length 4.4
  BOTTOM w0.13: CN1400.24 204.5,60.82 204.64,60.96 204.96,60.96 205.48,61.48 v3(206.04,61.48) 206.04,61.76 206.65,62.37 R1402.1
ISH_ACCEL_INT1#: length 22.5
  TOP w0.102: R4714.2 180.97,40.65 180.44,41.19 180.1,41.19 179.33,41.96 179.33,45.66 178.96,46.03 178.96,47.17 v1(179.57,47.78)
  BOTTOM w0.076: U4555.BW35 171.13,55.33 171.11,55.27 171.11,55.09 171.17,54.93 171.15,54.77 171.15,54.74 171.09,54.55 171.09,53.41 171.55,52.94 172.32,52.94 173.94,51.32 174.65,51.32 175.52,50.45 177.66,50.45 179.57,48.53 v1(179.57,47.78)
ISH_ACCEL_INT2#: length 19
  TOP w0.102: v1(180.64,46.28) 180.64,46.12 v3(181.53,45.23) 181.26,44.95 R4715.2
  BOTTOM w0.076: v1(180.64,46.28) 180.03,46.89 180.03,48.36 177.78,50.61 175.59,50.61 174.72,51.49 174.03,51.49 172.23,53.29 172.23,54.07 171.8,54.5 171.8,54.67 171.72,54.84 171.63,55.95 171.52,56.18 U4555.BW34
ISH_ALS_INT#: length 123.4
  TOP w0.102: R4950.2 195.9,52 v1(193.56,52)
  L3 w0.102: v1(193.56,52) 197.47,52 197.61,51.86 200.99,51.86 201.69,52.56 202.03,52.56 202.1,52.49 206.73,52.49 207.69,52.49 211.26,48.92 215.04,48.92 215.24,49.12 v1(215.24,49.82)
  L5 w0.102: v1(215.24,49.82) 214.69,50.37 214.69,59.85 217.62,62.79 217.62,63.75 218.39,64.51 218.39,64.85 216.66,66.58 216.66,69.36 215.87,70.14 215.87,70.31 215.87,70.31 215.87,81.07 218.03,83.22 218.03,87.16 217.79,87.4 217.79,97.51 216.53,98.77 216.53,100.25 216.28,100.51 216.28,105.6 216.94,106.26 216.94,107.23 v1(216.79,107.38)
  L6 w0.076: v1(171.71,53.32) 173.84,53.32 174.83,52.33 183.18,52.33
  L6 w0.102: 183.18,52.33 186.93,52.33 188.74,50.51 191.35,50.51 192.83,52 v1(193.56,52) ; v1(216.79,107.38) 217.83,106.34 223.47,106.34 v2(224.06,105.75)
  BOTTOM w0.076: U4555.BW37 171.37,53.66 v1(171.71,53.32) ; CN3001.17 v2(224.06,105.75)
ISH_I2C0_SCL: length 35
  TOP w0.076: v1(176.73,64.51) 177.21,64.02 v3(179.32,64.02) 181.01,64.02 181.09,64.1 181.15,64.1 181.4,64.35 185.36,64.35 187.94,66.93
  TOP w0.13: 187.94,66.93 188.15,66.93 188.36,67.14 188.97,67.14 189.52,67.68 189.71,67.68 190.49,68.45 207.29,68.45 207.84,69.01 R4557.2
  BOTTOM w0.13: U4555.CH20 v1(176.73,64.51)
ISH_I2C0_SDA: length 35.3
  TOP w0.076: 187.94,66.54 187.79,66.54 185.43,64.19 181.82,64.19 v3(181.28,63.64) 181.16,63.53 178.15,63.53 v1(178.11,63.57)
  TOP w0.13: R4556.2 209.44,69.65 209.3,69.51 209.3,69.18 209.32,69.16 209.32,68.85 209.1,68.62 208,68.62 207.45,68.07 190.65,68.07 189.87,67.3 189.68,67.3 189.13,66.75 188.52,66.75 188.31,66.54 187.94,66.54
  BOTTOM w0.13: U4555.CK22 v1(178.11,63.57)
JD1: length 5
  TOP w0.076: 18.39,36.57 18.39,36.73 19.15,37.49 U500.48
  TOP w0.102: 18.39,36.57 18.39,35.64 R501.1 R503.1
JD2: length 3.6
  TOP w0.076: U500.47 18.77,38.65 18.58,38.45 18.58,37.18 18.18,36.79 18.18,36.57
  TOP w0.102: TP509.1 18.18,36.34 18.18,36.57
JTAGK_TCK: length 3.4
  TOP w0.076: 143.91,75.5 144.2,75.22 144.2,74.41 v2(143.82,74.03)
  TOP w0.13: R4500.2 143.91,75.87 143.91,75.5
  BOTTOM w0.13: v2(143.82,74.03) U4555.P6
KB_PIN3: length 1.8
  TOP w0.102: v1(46.79,11.26) 46.76,11.23 TP300.1
  BOTTOM w0.102: CN300.3 v1(46.79,11.26)
KB_PIN14: length 2
  TOP w0.102: v1(41.29,11.26) 41.68,10.87 TP305.1
  BOTTOM w0.102: CN300.14 v1(41.29,11.26)
KB_PIN15: length 2
  TOP w0.102: TP304.1 40.28,10.86 v1(40.68,11.26)
  BOTTOM w0.102: v1(40.68,11.26) 40.79,11.37 CN300.15
KBC_PWR_ON: length 240.1
  TOP w0.076: v1(238.23,41.94) U300.G7
  TOP w0.102: v1(224.46,41.16) 223.94,40.65 223.7,40.65 223.63,40.58 R326.1 ; R7024.1 214.9,84.66 214.48,85.08 v1(214.32,85.08)
  L5 w0.102: v1(214.8,107.58) 214.8,107.18 215.87,106.11 215.87,103.84 v1(215.46,103.44) 215.87,103.03 215.87,100.34 216.13,100.08 216.13,97.38 212.85,94.11 212.85,92.29 v1(211.99,91.43) 214.04,89.37 214.04,86.68 214.32,86.4 v1(214.32,85.08) 214.12,84.88 v1(214.12,83.61) ; v1(216.89,103.44) 216.73,103.29 216.73,100.63 216.94,100.42 216.94,100.42 218.89,98.46 218.89,97.96 218.64,97.7 218.64,79.92 217.11,78.4 217.11,73.36 217.27,73.2 217.27,68.52 218.79,67 218.79,66.02 219.33,65.48 219.33,62.86 225.02,57.17 225.02,53.01 226.31,51.71 226.31,48.21 226.31,47.88 225.45,47.01 225.45,46.39 223.62,44.56 223.62,42 v1(224.46,41.16)
  L6 w0.102: v1(214.8,107.58) 213.97,108.42 211.2,108.42 209.11,110.52 206.89,110.52 204.77,108.4 203.15,108.4 200.46,105.7 199.15,105.7 198.79,105.35 195.11,105.35 194.11,104.35 188.45,104.35 187.88,103.77 184.6,103.77 182.32,106.06 172.19,106.06 172.06,105.93 157.6,105.93 155.22,108.32 139.01,108.32 138.5,107.81 138.39,107.81 138.12,107.54 124.32,107.54 123.42,108.45 108.22,108.45 107.74,107.97 107.74,107.33 v2(107.69,107.28)
  BOTTOM w0.076: v1(238.23,41.94) 238.73,41.94 239.4,42.61 239.4,43.45 238.91,43.94 238.91,44.17 238.51,44.57 237.29,44.57 237.21,44.49 236,44.49 235.4,43.89 232.63,43.89 232.59,43.86 232.51,43.86
  BOTTOM w0.102: R4800.1 107.08,106.67 v2(107.69,107.28) ; v1(215.46,103.44) v1(216.89,103.44) ; Q7003.5 v1(211.99,91.43) ; v1(224.46,41.16) 224.46,42.01 225.77,43.32 229.66,43.32 230.53,44.19 231.25,44.19 231.58,43.85 231.97,43.85 232.51,43.86 ; v1(214.12,83.61) 213,82.49 R7018.1
KBL_DET#: length 207.3
  TOP w0.102: v1(182.79,46.15) 182.79,46.01 183.34,45.47 183.62,45.47 183.99,45.09 183.99,44.4 183.84,44.25 183.84,42.94 R4729.2
  L3 w0.102: v1(219.88,40.91) 219.73,41.06 219.73,42.5 216.68,45.55 216.07,45.55 216.06,45.56 211.49,45.56 209.6,47.45 197.16,47.45 196.94,47.45 195.05,45.56 183.39,45.56 v1(182.79,46.15)
  L6 w0.102: v1(219.88,40.91) 221.31,39.49 221.31,37.85 221.53,37.63 221.53,37.63 222.98,36.18 224.19,36.18 226.79,33.59 226.79,33.3 227.03,33.06 229.6,33.06 229.91,32.76 230.04,32.76 230.04,32.75 231.89,32.75 232.09,32.55 232.37,32.55 232.93,32.55 233.26,32.22 235.37,32.22 235.61,31.98 235.61,31.65 235.61,31.38 237.23,29.75 237.23,25.92 237.23,25.25 237.23,25.04 242.31,19.96 242.31,19.65 242.74,19.22 242.74,11.18 241.66,10.1 241.34,10.1 239.43,8.19 238.18,8.19 237.97,7.99 231.19,7.99 229.54,9.64 218.83,9.64 218.53,9.34 212.2,9.34 212.18,9.32 176.02,9.32 175.12,10.22 171.56,10.22 170.66,9.32 167.83,9.32 164.57,6.06 147.85,6.06 147.49,6.42 147.49,6.59 v2(147.42,6.67)
  BOTTOM w0.076: 182,48.11 178.51,51.6 176,51.6 175.13,52.48 174.44,52.48 173.44,53.48 173.44,53.62 173.44,54.59 173.5,54.77 173.5,54.94 173.46,55.07 173.46,55.29 173.5,55.42 173.5,55.59 173.48,55.65 U4555.CB34
  BOTTOM w0.102: 182,48.11 182,47.22 182,47.18 182,46.94 v1(182.79,46.15) ; CN301.3 147.75,5.47 147.75,6.34 v2(147.42,6.67)
KSCAN_3S_IN<0>: length 14.9
  TOP w0.102: v1(37.53,17.91) 36.92,17.3 36.03,17.3 33.56,14.82 32.73,14.82 v1(31.29,13.37)
  BOTTOM w0.102: CN300.34 v1(31.29,13.37) ; v1(37.53,17.91) 38.94,19.32 v3(39.27,19.32) 40.95,21.01 D302.1
KSCAN_3S_IN<1>: length 16.9
  TOP w0.102: v1(42.74,20.32) 42.74,20.37 42.18,20.93 41.68,20.93 39.1,18.35 39.1,17.56 38.43,16.89 36.66,16.89 v3(36.34,16.58) 35.89,16.58 32.79,13.47 v1(32.79,13.37)
  BOTTOM w0.102: CN300.31 v1(32.79,13.37) ; v1(42.74,20.32) 42.74,20.94 43.46,21.66 D302.5
KSCAN_3S_IN<2>: length 10.8
  BOTTOM w0.102: CN300.32 32.29,13.19 32.3,13.21 32.3,13.68 34.77,16.14 v3(38.78,16.14) 38.9,16.03 D304.1
KSCAN_3S_IN<3>: length 11.9
  BOTTOM w0.102: D304.5 41.73,16.68 41.47,16.42 41.47,15.94 41.17,15.64 35.63,15.64 v3(34.87,14.87) 33.29,13.29 CN300.30
KSCAN_3S_IN<4>: length 13.3
  TOP w0.102: v1(38.69,17.91) 37.88,17.09 36.12,17.09 33.65,14.62 33.51,14.62 33.51,14.62 33.14,14.62 v1(31.89,13.37)
  BOTTOM w0.102: CN300.33 31.79,13.27 v1(31.89,13.37) ; D303.1 39.83,18.47 v3(39.42,18.05) 39.28,17.91 v1(38.69,17.91)
KSCAN_3S_IN<5>: length 14
  TOP w0.102: v1(44.57,20.32) 43.96,19.71 41.81,19.71 39.91,17.82 39.91,17.22 v1(37.57,14.87)
  BOTTOM w0.102: v1(37.57,14.87) 37.29,14.59 37.29,14.59 CN300.22 ; D303.5 43.96,19.12 44.57,19.73 v1(44.57,20.32)
KSCAN_3S_IN<6>: length 41.7
  BOTTOM w0.102: CN300.21 37.79,11.68 36.95,10.85 27.01,10.85 26.77,11.09 26.77,13.13 28.97,15.33 v3(29.97,15.33) 31.06,15.33 34.24,18.52 35.31,18.52 35.39,18.59 36.77,18.59 37.74,19.56 37.74,20.3 41.53,24.08 41.53,26.55 42.78,27.81 43.22,27.81 45.5,30.09 D301.2
KSCAN_3S_IN<8>: length 17.2
  BOTTOM w0.102: CN300.37 29.79,13.49 33.38,17.08 36.13,17.08 37.76,18.72 37.89,18.72 39.26,20.08 39.63,20.08 39.93,20.38 39.93,21.1 v3(40.33,21.5) 40.48,21.66 D302.2
KSCAN_3S_IN<9>: length 16.7
  TOP w0.102: v1(43.71,22.86) 45.59,20.98 45.59,20.16 43.95,18.52 43.91,18.52 43.56,18.16 43.56,17.74 43.32,17.5 42.37,17.5 42.14,17.74 42.14,18.07 41.9,18.31 41.56,18.31 40.73,17.48 40.73,16.86 40.11,16.25 v1(40.11,14.87)
  BOTTOM w0.102: D302.4 v1(43.71,22.86) ; CN300.17 39.79,14.55 v1(40.11,14.87)
KSCAN_3S_IN<10>: length 12.7
  BOTTOM w0.102: D304.2 v3(37.61,16.68) 33.55,16.68 30.79,13.91 CN300.35
KSCAN_3S_IN<11>: length 9.1
  TOP w0.102: v1(42.54,17.91) 42.54,17.96 42.42,18.08 41.98,18.52 41.48,18.52 40.52,17.56 40.52,16.95 39.32,15.75 v2(39.32,14.39)
  BOTTOM w0.102: D304.4 42.44,17.8 v1(42.54,17.91) ; CN300.18 39.29,14.36 v2(39.32,14.39)
KSCAN_3S_IN<12>: length 15.3
  BOTTOM w0.102: D303.2 v3(40.69,19.12) 39.78,19.12 39.48,18.81 39.02,18.81 37.09,16.88 33.47,16.88 30.29,13.7 CN300.36
KSCAN_3S_IN<13>: length 11.9
  TOP w0.102: v1(43.15,17.91) 42.48,18.57 42.34,18.72 41.39,18.72 40.32,17.65 40.32,17.03 38.84,15.55 v1(38.84,14.87)
  BOTTOM w0.102: CN300.19 38.79,14.82 v1(38.84,14.87) ; D303.4 43.46,19.77 43.09,19.39 43.09,17.97 v1(43.15,17.91)
KSCAN_3S_IN<14>: length 25.2
  BOTTOM w0.102: CN300.38 29.29,13.27 34.32,18.31 35.39,18.31 35.47,18.39 36.86,18.39 38.25,19.78 v3(38.25,20.08) 38.25,20.52 41.73,24 41.73,26.27 42.45,26.99 43.12,26.99 44.32,28.2 D301.1
LAN_DISABLE#: length 22.7
  TOP w0.102: v1(178.13,46.15) 178.55,46.15 179.12,45.57 179.12,41.82 TP4505.1
  BOTTOM w0.076: v1(178.13,46.15) 178.36,46.39 178.73,46.79 178.73,48.51 178.16,49.08 176.42,49.08 175.55,49.95 175.32,49.95 174.44,50.83 173.68,50.83 172.06,52.45 171.34,52.45 170.49,53.29 170.49,53.56 170.43,54.13 170.37,54.32 170.33,54.39 170.33,56.22 U4555.BU34
LAN_WAKE#: length 31.7
  TOP w0.102: v1(193.56,51.39) 193.65,51.47 v3(194.26,51.47) 195.11,51.47 R4717.2
  L6 w0.076: 171.31,54.08 171.31,55.62 170.48,56.45 170.48,56.64 170.46,56.66 v1(170.46,57.26)
  L6 w0.102: 171.31,54.08 171.31,53.16 171.54,52.93 173.98,52.93 174.78,52.13 186.84,52.13 188.66,50.31 191.43,50.31 192.51,51.39 v1(193.56,51.39)
  BOTTOM w0.076: U4555.BU32 v1(170.46,57.26)
LANLINK_STATUS: length 20.5
  L3 w0.076: 180.51,65.21 178.78,65.21 178.47,64.89 176.48,64.89 v1(176.09,64.51)
  L3 w0.102: 180.51,65.21 181.02,65.21 181.42,64.81 182.26,64.81 182.63,65.18 193.97,65.18 v2(194.58,64.57)
  BOTTOM w0.089: U4555.CG20 v1(176.09,64.51)
  BOTTOM w0.102: v2(194.58,64.57) 194.81,64.8 R4734.2
LED_3S_SATA#: length 7.5
  BOTTOM w0.076: R4816.2 186.23,72.98 v3(185.77,72.98) 182.29,72.98 182.07,73.2 180.34,73.2 180.17,73.13 180.08,73.13 179.87,73.21 179.68,73.21 U4555.CN7
LED_PWRSTBY: length 4.2
  BOTTOM w0.102: R403.2 49.2,21.26 v3(48.16,20.26) 48.16,19.66 48.86,18.95 Q305.3 Q305.2
LED_PWRSTBY#: length 276.3
  TOP w0.102: v1(49.94,10.1) 49.6,10.44 49.6,16.07 50.99,17.45 v1(50.99,21.93)
  L6 w0.102: v2(242.59,51.88) 244.33,51.88 250.85,45.37 250.85,44.86 250.85,40.2 251.74,39.31 251.74,33.09 248.69,30.04 248.69,22.16 249.02,21.83 249.02,20.59 248.41,19.98 248.41,17.62 249.83,16.19 249.83,13.45 249.74,13.36 249.74,10.17 248.7,9.13 242.71,9.13 242.64,9.07 242.25,8.68 241.95,8.68 240.04,6.77 238.77,6.77 236.71,4.72 235.82,4.72 235.65,4.89 230.15,4.89 229.68,5.35 227.14,5.35 227.06,5.28 207.27,5.28 204.64,7.91 176.98,7.91 175.61,6.54 170.97,6.54 168.78,4.35 156.13,4.35 155.93,4.15 132.28,4.15 128.21,8.22 73.17,8.22 68.55,12.84 57.53,12.84 56.31,11.62 54.37,11.62 54,11.99 52.25,11.99 50.54,10.28 50.12,10.28 v1(49.94,10.1)
  BOTTOM w0.102: U302.6 242.06,51.88 v2(242.59,51.88) 242.59,51.57 242.14,51.12 R303.1 R361.1 ; v1(50.99,21.93) 50.95,21.93 50.52,21.5 R404.1 50.33,21.27 49.68,20.63 Q305.5
LED_PWRSTBY#_CNTR: length 3.2
  BOTTOM w0.102: Q305.6 50.18,20.24 50.62,19.8 R371.1 51.81,20.41 v3(51.81,20.46) 51.81,20.83 R404.2
LED_PWRSTBY#_CNTR_R: length 10.1
  BOTTOM w0.102: v3(52.07,19.12) 51.9,18.95 R371.2 50.64,18.95 50.53,18.84 50.53,15.41 50.75,15.2 50.75,14.8 50.47,14.52 49.48,14.52 47.79,12.82 CN300.1
LFRAM#_ESPI_CS#: length 117.9
  TOP w0.076: v1(243.1,49.37) 242.94,49.21 242.94,46.81 242.77,46.64 242.77,44.73 242.58,44.55 242.24,44.55 241.91,44.21 U300.L2
  L3 w0.076: v1(173.19,59.84) 173.18,59.77 173.57,59.38 173.57,57.79 173.56,57.78 173.56,57.06 173.88,56.74 174.56,56.74 174.72,56.59 175.72,56.59 176.74,55.57 178.74,55.57 180,54.31
  L3 w0.097: v1(243.1,49.37) 241.69,49.37 241.42,49.64 240.7,49.64 240.2,50.14 235.62,50.14 235.3,49.81 234.22,49.81 225.7,49.81 225.22,49.33 223.08,49.33 222.8,49.04 218.75,49.04 217.7,50.09 216.33,50.09 215.58,50.84 210.33,50.84 207.98,53.19 206.44,53.19 202.4,53.19 202.32,53.26 201.4,53.26 200.7,52.56 197.9,52.56 197.65,52.82 197.26,53.21 196.58,53.89 196.29,53.89 193.15,53.89 191.81,55.23 188.02,55.23 187.34,54.55 184.42,54.55 184.32,54.46 184.32,54.29 184.42,54.2 186.57,54.2 186.67,54.1 186.67,53.94 186.57,53.84 180.47,53.84 180,54.31
  L6 w0.127: v1(243.1,49.37) 243.1,47.81 243.42,47.5 243.42,46.26 243.54,46.13 244.38,46.13 244.51,46 244.51,45.82 244.38,45.7 243.76,45.7 243.64,45.57 243.64,45.39 243.76,45.26 244.38,45.26 244.51,45.14 244.51,44.96 244.38,44.83 243.76,44.83 243.64,44.7 243.64,44.52 243.76,44.39 244.38,44.39 244.51,44.27 244.51,44.09 244.38,43.96 243.76,43.96 243.64,43.83 243.64,43.65 243.76,43.53 244.38,43.53 244.51,43.4 244.51,43.22 244.38,43.09 243.76,43.09 243.64,42.97 243.64,42.63 244.13,42.14 244.13,39.95 244.92,39.15 244.92,35.06 245.98,34 v1(246.17,34)
  BOTTOM w0.076: U4555.CA28 172.93,60.13 v1(173.19,59.84)
  BOTTOM w0.13: R308.1 251,33.39 250.47,32.87 248.52,32.87 247.83,33.56 247.38,34 v3(246.86,34) v1(246.17,34)
LFRAM#_ESPI_CS#_R: length 3.2
  BOTTOM w0.13: CN375.6 252.8,34.97 252.48,34.65 252.48,34.22 252.22,33.95 v3(252.22,33.42) 252.19,33.39 R308.2
LID_SW#_3: length 355.4
  TOP w0.076: v1(240.83,42.59) U300.H4
  TOP w0.102: R129.1 248.84,42.86 v1(249.3,42.86) ; TP2521.1 5.51,42.13 3.34,42.13 v2(2.25,43.21) ; v1(25.67,7.04) 25.67,7.48 25.19,7.96 D3001.3 ; v1(246.24,22.01) 245.09,23.16 243.77,23.16 243.03,22.42 241.9,22.42 241.45,22.86 241.45,24.45 241.8,24.79 241.8,25.35 242.38,25.93 242.38,26.48 242.28,26.59 241.63,26.59 241.12,27.09 240.67,27.09 240.3,27.46 238.72,27.46 238.29,27.03 Q1003.G
  L3 w0.076: 245.44,42.19 241.23,42.19 v1(240.83,42.59)
  L3 w0.102: v1(249.3,42.86) 248.46,42.03 246.03,42.03 245.87,42.19 245.44,42.19 ; v1(25.67,7.04) 25.82,6.9 66.17,6.9 67,6.08 70.4,6.08 72.54,8.22 88.99,8.22 89.19,8.02 101.75,8.02 104.72,5.04 105.93,5.04 105.98,4.99 110.45,4.99 114.13,8.68 130.88,8.68 132.31,7.25 133.52,7.25 133.73,7.46 135.84,7.46 136.24,7.05 138.14,7.05 139.99,8.9 141.38,8.9 142.34,7.94 150.89,7.94 151.09,7.94 152.05,8.9 157.81,8.9 158.18,9.26 158.85,9.26 159.28,8.84 159.93,8.84 159.93,8.84 160.11,8.84 162.12,8.84 162.2,8.76 162.44,8.53 162.6,8.36 162.67,8.29 162.73,8.23 169.02,8.23 169.42,8.63 177.25,8.63 177.5,8.88 190.46,8.88 191.72,8.88 192.35,8.25 213.78,8.25 215.74,6.29 v1(218.61,6.29) 219.53,5.37 221.56,5.37 222.48,4.46 227.24,4.46 227.24,4.51 227.47,4.74 227.64,4.74 232.56,9.67 236.62,9.67 245.83,18.88 245.83,21.6 v1(246.24,22.01)
  L6 w0.102: v1(246.24,22.01) 246.24,22.42 246.55,22.74 246.55,25.29 247.11,25.85 247.11,31.05 247.65,31.59 247.65,31.59 249.75,33.7 249.75,34.49 249.4,34.84 249.12,34.84 248.62,35.35 248.62,42.18 v1(249.3,42.86) ; v1(25.67,7.04) 25.47,6.85 22.02,6.85 22.02,6.85 21.07,6.85 19.35,8.57 19.35,11.64 20.57,12.86 20.57,15.94 19.99,16.52 19.99,30.44 19.38,31.05 10.44,31.05 9.62,31.87 9.62,34.25 8.54,35.34 6.1,35.34 5.75,35.69 5.75,39.71 v2(2.25,43.21)
  BOTTOM w0.102: CN2500.29 v2(2.25,43.21) ; Q307.5 214.02,5.37 214.84,6.19 218.52,6.19 v1(218.61,6.29)
LID_SW#_3_DB: length 84.6
  TOP w0.102: v1(41.93,109.95) v3(41.93,118.48) 41.93,119.03 41.75,119.22 U9204.OUTPUT ; D9206.1 v1(44.21,66.74)
  L3 w0.102: v1(44.21,66.74) 44.15,66.79 39.46,66.79 37.07,69.18 33.61,69.18 32.53,70.26 v1(32.53,70.6)
  L6 w0.102: v1(32.53,70.6) 32.53,70.46 33.46,69.54 36.29,69.54 37.61,70.86 37.61,71.25 36.84,72.02 36.84,76.05 33.77,79.12 33.77,90.15 36.48,92.86 36.48,96.12 34.98,97.61 34.98,101.49 34.61,101.86 33.42,101.86 33.01,102.28 33.01,105.22 33.42,105.64 36.46,105.64 38.66,107.84 38.66,110.3 38.67,110.32 38.67,110.32 38.91,110.56 39.25,110.56 39.86,109.95 v1(41.93,109.95)
  BOTTOM w0.102: v1(32.53,70.6) 33.25,71.32 CN9202.2
LID_SW_3: length 3.3
  BOTTOM w0.102: Q307.3 Q307.2 214.02,3.65 214.27,3.4 215.35,3.4 v3(215.54,3.6) 215.69,3.75 R445.2
LIMIT_SIGNAL: length 78
  TOP w0.102: TP6001.1 209.9,116.07 v1(209.9,116.68)
  L5 w0.102: v1(238.71,82.56) 238.71,83.53 238.6,83.63 v1(230.6,83.63)
  L6 w0.102: v1(238.71,82.56) 239.26,83.12 241.03,83.12 244.24,86.33 244.24,86.67 242.49,88.42 242.49,93.07 241.22,94.34 231.2,94.34 224.87,100.67 224.87,105.51 221.91,108.47 221.29,108.47 221.05,108.71 221.05,109.08 220.85,109.29 220.48,109.29 220.22,109.03 217.35,109.03 217.2,108.88 215.23,108.88 214.86,109.25 214.86,110.13 215.06,110.34 215.06,110.67 211.1,114.64 211.1,115.48 v1(209.9,116.68)
  BOTTOM w0.102: R68068.1 210.63,114.8 209.9,115.53 v1(209.9,116.68) ; CN6000.4 238.5,82.77 v1(238.71,82.56) ; v1(230.6,83.63) 230.59,83.62 D6035.2
LOW_PWR_VTG_SHIFT_N: length 117.1
  L3 w0.102: v1(114.91,82.89) 111.97,82.89 111.83,82.75 104.27,82.75 103.63,82.11 103.63,81.4 103.78,81.24 103.78,76.82 96.92,69.97 96.92,61.56 96.64,61.28 96.64,58.1 v1(96.24,57.7)
  L6 w0.102: v1(180.78,98.91) 180.58,98.71 179.95,98.71 179.05,97.8 172.82,97.8 171.52,97.8 169.11,95.39 164.76,95.39 162.5,93.13 156.29,93.13 151.29,88.13 128.94,88.13 126.72,85.91 119.64,85.91 118.11,84.37 115.14,84.37 114.91,84.13 v1(114.91,82.89)
  BOTTOM w0.102: R60525.2 96.57,57.37 v1(96.24,57.7) ; v1(180.78,98.91) 180.99,99.12 181.88,99.12 R61424.2
LP#: length 2.9
  BOTTOM w0.102: U61400.6 180.76,96.21 v3(180.87,96.1) 180.9,96.08 R61422.2 R7155.2
LPC_ESPI_<0>: length 117.8
  TOP w0.076: 245.44,43.23 245.28,43.23 245.08,43.03 244.03,43.03 243.43,42.43 242.79,42.43 242.63,42.26 U300.H1 ; R4846.2 173.98,56.59 174.66,56.59 176.21,55.04 176.39,55.04
  TOP w0.13: 176.39,55.04 183.54,55.04 184.52,56.01 185.91,56.01 186.69,56.79 186.99,56.79 187.6,57.41 188.28,57.41 188.42,57.54 193.84,57.54 195.8,59.51 200.59,59.51 200.71,59.38 211.73,59.38 211.74,59.39 213.48,59.39 214.4,60.31 214.41,60.31 214.87,60.77 214.87,60.78 214.95,60.86 214.95,62.43 214.95,63.07 215.51,63.63 215.98,63.63 216.62,64.26 218.5,64.26 v3(218.74,64.51) 219.6,65.36 230.96,65.36 234.45,61.87 234.45,60.78 234.68,60.55 236.66,60.55 239.7,57.51 239.7,57.1 240.3,56.5 240.3,54.94 241.22,54.01 241.63,54.01 242.49,53.14 243.12,53.14 245.2,51.06 245.2,46.45 246.09,45.56 246.09,44.99 246.56,44.52 246.56,44.21 246.2,43.85 v1(246.2,43.35) 246.08,43.23 245.44,43.23
  L6 w0.127: v1(247.04,31.94) 247.2,32.11 247.21,32.11 247.86,32.76 247.86,34.99 247.99,35.12 247.99,39.24 247.33,39.9 247.33,42.22 v1(246.2,43.35)
  BOTTOM w0.13: R319.1 252.86,31.31 247.67,31.31 v1(247.04,31.94)
LPC_ESPI_<1>: length 117.5
  TOP w0.076: U300.J1 242.48,42.91 243.94,44.37 v1(246.17,44.37) ; 176.51,54.65 175.51,54.65 173.49,56.67 173.4,56.67 173.11,56.96 R4847.2
  TOP w0.13: 176.51,54.65 183.7,54.65 184.68,55.63 186.07,55.63 186.85,56.41 187.15,56.41 187.76,57.03 188.44,57.03 188.58,57.16 193.99,57.16 195.96,59.12 200.43,59.12 200.56,59 211.89,59 211.9,59 213.64,59 214.56,59.93 214.57,59.93 215.25,60.61 215.25,60.62 215.33,60.7 215.33,61.02 215.33,61.02 215.33,62.59 215.33,62.91 215.67,63.24 216.14,63.24 216.77,63.88 219.64,63.88 v3(220.01,64.25) 220.74,64.98 230.8,64.98 234.07,61.72 234.07,60.63 234.52,60.17 236.5,60.17 239.32,57.35 239.32,56.94 239.91,56.34 239.91,54.78 240.36,54.34 241.06,53.63 241.47,53.63 242.34,52.76 242.96,52.76 244.81,50.9 244.81,46.29 245.87,45.23 245.87,44.67 v1(246.17,44.37)
  L6 w0.127: v1(246.17,44.37) 245.78,43.97 245.78,40.2 247.61,38.37 247.61,35.54 247.38,35.31 247.38,32.87 v1(247.04,32.53)
  BOTTOM w0.13: R323.1 252.63,31.69 247.88,31.69 247.05,32.53 v1(247.04,32.53)
LPC_ESPI_<2>: length 119.1
  TOP w0.076: 175.96,53.84 175.8,53.84 174.51,55.13 173.72,55.13 173.1,55.76 R4848.2 ; U300.K1 242.48,43.56 243.26,44.34 243.26,46.44 243.44,46.61 243.44,47.59 244.34,48.5 244.34,48.84 v1(243.94,49.25)
  TOP w0.13: 175.96,53.84 183.43,53.84 184.84,55.25 186.23,55.25 187.01,56.03 187.31,56.03 187.92,56.64 188.6,56.64 188.73,56.78 194.15,56.78 196.12,58.74 200.27,58.74 200.4,58.62 212.05,58.62 212.06,58.62 213.8,58.62 214.72,59.55 214.73,59.55 215.64,60.45 215.64,60.46 215.72,60.54 215.72,61.18 215.72,62.75 215.83,62.86 216.3,62.86 216.93,63.5 220.44,63.5 v3(221.3,64.36) 221.54,64.59 230.65,64.59 233.68,61.56 233.68,60.47 234.36,59.79 236.34,59.79 238.93,57.19 238.93,56.78 239.53,56.18 239.53,54.62 240.2,53.95 240.9,53.25 241.31,53.25 242.18,52.38 242.8,52.38 243.94,51.24 v1(243.94,49.25)
  L6 w0.127: v1(243.94,49.25) 243.93,49.25 243.52,48.84 243.52,48.46 244,47.98 244.11,47.98 244.69,47.4 244.69,46.49 244.89,46.29 244.89,40.01 245.68,39.21 245.68,36.22 245.93,35.97 246.26,35.97 246.62,35.61 246.62,33.24 246.24,32.86 246.24,32.49 v1(246.2,32.46)
  BOTTOM w0.13: v1(246.2,32.46) 246.69,32.95 247.35,32.95 247.51,32.79 248.23,32.07 251.9,32.07 252.16,32.33 252.16,32.43 R340.1
