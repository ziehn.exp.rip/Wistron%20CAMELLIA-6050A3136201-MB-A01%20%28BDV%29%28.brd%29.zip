# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_CAP: length 5.2
  TOP w0.076: 237.92,35.32 238.17,35.58 238.17,35.88 239.2,36.91 U300.A6
  TOP w0.102: 237.92,35.32 237.54,34.94 v3(237.16,34.94) 236.45,34.94 C302.1
EC_GPIO57: length 6.9
  TOP w0.076: U300.L3 241.15,44.36 241.48,44.69 241.48,45 241.51,45.02 241.51,45.93 241,46.43 241,48.6 240.53,49.07 240.53,49.77 240.36,49.95 240.36,50.36
  TOP w0.102: 240.36,50.36 TP307.1
EC_GPIO67: length 8.4
  TOP w0.076: v1(241.48,43.24) U300.J3
  TOP w0.102: v3(247.14,43.32) 247.47,43.65 v1(247.75,43.65) 247.82,43.58 R353.2
  L3 w0.076: 245.44,43.35 245.33,43.24 v1(241.48,43.24)
  L3 w0.102: v1(247.75,43.65) 247.55,43.85 245.94,43.85 245.44,43.35
EC_GPIOF2: length 12.4
  TOP w0.076: v1(238.88,40.64) U300.F6
  TOP w0.102: TP303.1 237.26,31.59 v1(237.49,31.82)
  L3 w0.076: 236.09,35.32 236.09,38.82 236.9,39.63 237.07,39.63 238.08,40.64 v1(238.88,40.64)
  L3 w0.102: 236.09,35.32 236.09,33.21 v1(237.49,31.82)
EC_RSMRST_PG: length 17.1
  TOP w0.076: U300.H9 v1(236.93,42.59)
  TOP w0.102: v1(226.49,41.16) 225.36,40.03 225.36,38.96 226.36,37.95 R377.2
  BOTTOM w0.076: 232.51,41.95 232.83,41.63 234.09,41.63 234.13,41.58 236.42,41.58 236.93,42.09 v1(236.93,42.59)
  BOTTOM w0.102: v1(226.49,41.16) 226.49,41.95 226.96,42.42 230.06,42.42 231.64,42.42 231.74,42.33 232.13,42.33 232.51,41.95
EC_RTCRST_CTRL: length 38.8
  TOP w0.076: U300.J11 235.61,43.25 235.44,43.25 235.43,43.25 234.64,43.25 234.18,43.7 233.45,43.7 232.56,44.59 232.51,44.59
  TOP w0.102: 232.51,44.59 231.79,44.59 231.25,45.13 230.26,45.13 230.04,45.35 227.95,45.35 227.62,45.02 226.81,45.02 225.96,44.16 223.3,44.16 222.65,43.51 221.32,43.51 v1(220.75,42.94) ; v2(221.31,56.73) 221.89,57.32 R1019.2
  L5 w0.102: v2(221.31,56.73) 223.63,54.41 223.63,52.11 220.75,49.22 v1(220.75,42.94)
  BOTTOM w0.102: v2(221.31,56.73) 221.6,56.44 222.92,56.44 223.02,56.54 223.02,57.89 D1000.1
EC_VCC: length 67.3
  TOP w0.254: 243.96,35.6 244.6,35.6 244.83,35.37 C315.1 244.83,34.39 244.83,34.39 C131.1 ; 243.96,35.6 v1(243.94,35.6) ; 243.96,35.6 244.38,36.03 244.38,36.39 244.12,36.65 243.37,36.65 243.11,36.91 243.11,37.86 242.61,38.36 U300.B1 ; U300.M8 237.9,45.04 238.02,45.15 238.02,45.72 237.93,45.8 237.93,46.31 237.57,46.67 v1(237.56,46.67) 237.18,46.67 235.73,48.12 v3(235.73,48.4) 235.48,48.66 C319.1 C308.1 ; U300.A7 238.55,37.22 237.05,35.73 236.6,35.73 C314.1 234.69,34.5 v1(233.96,33.77) ; R379.2 230.67,40.81 v1(230.88,40.6) 231.01,40.73 C303.1 C310.1 232.59,40.73 232.66,40.65 233.52,40.65 234.52,39.66 U300.D12
  L3 w0.254: v1(230.88,40.6) 230.88,40.93 232.65,42.7 232.65,46.48 233.44,47.27 236.96,47.27 v1(237.56,46.67)
  L5 w0.254: v1(243.94,35.6) 242.08,33.75 242.08,33.07 241.45,32.43 241.05,32.43 239.94,33.54 236.8,33.54 236.58,33.77 v1(233.96,33.77)
  L6 w0.254: v1(233.96,33.77) 233.58,33.77 233.48,33.87 232.92,33.87 232.64,33.87 232.44,34.08 231.79,34.08 230.58,34.08 229.31,35.35 229.31,36.36 231.06,38.11 234.4,38.11 235.07,38.78 235.07,39.15 233.57,40.65 230.94,40.65 v1(230.88,40.6)
EC_VHIF: length 7.3
  TOP w0.254: C317.1 244.35,41.32 243.99,40.96 U300.F1
  TOP w0.279: R359.2 249.32,41.4 C307.1 248.4,41.4 247.3,41.4 v3(247.19,41.52) 246.8,41.52 246.4,41.12 245.99,41.12 245.8,41.32 C317.1
EC_VSPI: length 62.7
  TOP w0.254: R347.1 226.06,39.76 226.67,40.37 226.99,40.37 227.71,41.09 v1(227.71,41.57) ; C324.1 232.26,43.78 v1(233.45,42.59) 233.77,42.26 U300.H12 ; v1(232.56,25.34) 232.05,24.83 230.4,24.83 R355.1 229.81,25.29 229.27,24.75 221.33,24.75 v3(220.49,25.59) 219.19,26.9 219.19,28.32 C316.1 U366.8 CN366.8 219.99,31.37 219.99,33.59 R346.2 ; v1(231.49,25.92) 231.37,26.05 231.21,26.05 R344.2
  L3 w0.254: v1(227.71,41.57) 227.71,40.99 226.24,39.52 226.24,38.93 225.94,38.63 223.29,38.63 222.4,37.73 222.4,36.62 224.56,34.46 225.06,34.46 226.15,33.37 226.15,32.94 228.67,30.41 228.67,30.16 228.67,30.16 228.67,29.85 231.39,27.13 231.49,27.03 v1(231.49,25.92)
  L6 w0.254: v1(227.71,41.57) 227.71,41.37 228.12,40.96 230.56,40.96 232.19,42.59 v1(233.45,42.59)
  BOTTOM w0.254: v1(232.56,25.34) 232.22,25.34 231.64,25.92 v1(231.49,25.92)
EDP_AUX_C_DN: length 20.7
  BOTTOM w0.119: C3009.2 34.11,19.17 33.25,19.17 33,19.42 33,20.03 25.17,27.86 25.17,29.28 24.06,30.39 20.53,30.39 20.39,30.25 CN3000.26
EDP_AUX_C_DP: length 20.7
  BOTTOM w0.119: CN3000.27 20.39,30.75 20.53,30.61 24.15,30.61 25.39,29.37 25.39,27.95 33.22,20.12 33.22,19.51 33.34,19.39 34.11,19.39 C3010.2
EDP_AUX_DN: length 164.4
  L6 w0.127: v1(36.66,20.02) 36.69,20.02 37.12,19.59 37.51,19.59 41.61,23.69 41.61,26.98 42.94,28.31 61.41,28.31 62,28.89 73.2,28.89 73.86,29.55 79.58,29.55 80.71,30.68 82.04,30.68 88.43,37.07 90.39,37.07 101.52,48.2 111.2,48.2 112.73,49.73 112.73,58.86 115.52,61.65 115.87,61.65 117.9,63.69 117.9,71.62 121.08,74.8 123.47,74.8 124.17,75.49 124.77,75.49 125.1,75.82 128.29,75.82 130.54,78.08 136.5,78.08 136.99,78.56 138.51,78.56 139.8,79.85 145.6,79.85 145.79,80.04 148.24,80.04 149.83,78.45 151.05,78.45 151.33,78.73 151.33,80.47 151.62,80.76 152,80.76 v1(152.2,80.95)
  BOTTOM w0.076: v1(152.2,80.95) 152.48,80.66 152.66,80.66 152.84,80.48 152.84,79.41 152.15,78.72 152.15,76.49 152.3,76.34 152.3,76.03 152.04,75.77 U4555.AH4
  BOTTOM w0.119: C3009.1 34.87,19.01 36.41,19.01 36.65,19.26 36.65,20.01 v1(36.66,20.02)
EDP_AUX_DP: length 164.3
  L6 w0.127: v1(152.2,80.21) 152.2,80.32 151.98,80.53 151.71,80.53 151.56,80.38 151.56,78.63 151.14,78.22 149.74,78.22 148.14,79.82 145.88,79.82 145.69,79.62 139.9,79.62 138.6,78.33 137.08,78.33 136.6,77.85 130.64,77.85 128.38,75.6 125.2,75.6 124.87,75.27 124.27,75.27 123.57,74.57 121.17,74.57 118.13,71.52 118.13,63.59 115.96,61.42 115.61,61.42 112.96,58.76 112.96,49.63 111.29,47.97 101.61,47.97 90.49,36.84 88.52,36.84 82.13,30.46 80.81,30.46 79.68,29.33 73.95,29.33 73.29,28.67 62.09,28.67 61.51,28.08 43.04,28.08 41.84,26.89 41.84,23.6 37.6,19.36 37.02,19.36 36.78,19.6 36.48,19.6 36.07,20.02 v2(35.91,20.02)
  BOTTOM w0.076: v1(152.2,80.21) 152.48,80.5 152.59,80.5 152.68,80.41 152.68,79.48 151.98,78.79 151.98,76.24 U4555.AH3
  BOTTOM w0.119: C3010.1 35.18,19.23 36.31,19.23 36.43,19.35 36.43,19.55 35.96,20.02 v2(35.91,20.02)
EDP_BKLT_EN: length 318.5
  TOP w0.102: R3009.1 v1(21.74,22.75) R3008.1
  L5 w0.076: 182.43,70.32 181.23,70.32 180.81,70.74 v2(178.02,70.74)
  L5 w0.102: 182.43,70.32 183.01,69.74 185.23,69.74 185.81,70.32 192.28,70.32 192.76,70.8 192.76,71.22 194.13,72.59 194.13,73.51 195.27,74.65 195.27,76.74 194.86,77.14 194.86,77.32 194.86,77.49 194.74,77.61 194.13,78.22 194.13,78.46 194.13,82.81 192.96,83.98 192.96,101.64 192.34,102.26 192.34,105.51 190.46,107.38 182.17,107.38 181.84,107.71 162.38,107.71 162.38,107.71 161.54,107.71 161.03,107.71 159.61,109.14 156.03,109.14 155.65,108.75 147.49,108.75 145.77,107.03 145.77,101.67 144.84,100.75 128.84,100.75 125.01,104.59 124.01,104.59 123.67,104.59 120.7,107.56 113.76,107.56 111.68,105.47 111.68,105.46 111.48,105.26 111.48,103.07 112.29,102.27 112.29,100.67 116.28,96.68 116.28,87.35 113.59,84.66 113.59,80.71 106.85,73.98 106.85,56.86 104.67,54.68 104.67,54.67 104.17,54.17 99.36,54.17 92.78,47.59 91.91,47.59 83.23,38.91 83.23,38.23 82.37,37.36 82.37,31.82 79.45,28.89 79.45,19.17 79.35,19.06 59.86,19.06 59.76,19.17 52.87,19.17 52.7,19.17 52.33,18.79 41.75,18.79 39.42,16.46 35.01,16.46 34.78,16.69 31.62,16.69 31.25,17.06 24.72,17.06 21.72,20.06 21.6,20.06 21.6,20.06 21.52,20.06 20.32,21.26 20.32,21.65 20.7,22.03 20.7,22.26 21.19,22.75 v1(21.74,22.75)
  BOTTOM w0.089: U4555.CK11 v2(178.02,70.74)
EDP_HPD: length 303.2
  TOP w0.102: R3021.1 v1(22.63,24.96)
  L5 w0.102: v2(182.25,74.08) 182.65,73.69 185.39,73.69 185.65,73.43 186.69,73.43 188.17,71.95 192.05,71.95 193.11,73.01 193.11,82.68 192.15,83.64 192.15,101.01 187.36,105.81 187.2,105.81 186.87,106.14 156.06,106.14 155.89,106.14 155.89,106.14 155.72,106.14 153.92,107.94 148.11,107.94 146.78,106.61 146.78,98.01 145.77,96.99 125.6,96.99 125,96.4 120.93,92.32 117.6,92.32 117.09,91.81 117.09,87.02 114.4,84.32 114.4,82.35 114.92,81.83 115.25,81.83 115.48,82.06 115.86,82.06 116.19,81.73 116.19,77.89 114.88,76.59 114.88,75.03 107.26,67.41 107.26,56.66 106.9,56.3 106.9,55.98 104.47,53.56 104.27,53.56 102.96,52.24 102.96,50.88 101.14,49.06 96.01,49.06 86.71,39.77 86.71,38.7 83.68,35.67 83.68,31.6 82.24,30.16 81.89,30.16 80.06,28.34 80.06,19 78.75,17.69 52.32,17.69 49.65,15.03 40.82,15.03 40.36,15.48 34.27,15.48 33.51,16.25 33.04,16.25 33.01,16.28 31.46,16.28 31.09,16.65 30.58,16.65 30.22,16.29 30.22,15.87 29.98,15.64 27.56,15.64 26.68,16.51 24.98,16.51 21.64,19.85 21.44,19.85 20.11,21.17 20.11,21.73 20.49,22.11 20.49,22.34 22.63,24.47 v1(22.63,24.96)
  BOTTOM w0.076: v2(182.25,74.08) 181.7,73.53 180.59,73.53 180.23,73.68 180.03,73.68 179.9,73.63 179.7,73.63 179.57,73.68 179.56,73.68 179.39,73.68 179.26,73.63 179.05,73.41 U4555.CM7
  BOTTOM w0.102: v1(22.63,24.96) 22.2,25.39 22.2,25.73 21,26.92 21,27.16 20.76,27.4 20.75,27.4 20.39,27.75 CN3000.21
EDP_PWM_OUT: length 407.2
  TOP w0.102: R430.2 244.26,32.76 244.26,31.63 244.03,31.39 243.69,31.39 242.93,32.15 242.49,32.15 242.14,32.51 241.08,32.51 241.01,32.58 240.65,32.58 239.91,33.32 239.29,33.32 238.99,33.62 234.85,33.62 231.28,30.05 231.28,29.49 v1(231.3,29.47) ; v2(28.98,18.23) 28.77,18.43 26.4,18.43 26.28,18.3 25.88,18.3 25.75,18.43 24.16,18.43 R3017.1
  L5 w0.076: 182.34,70.09 180.69,70.09 180.46,70.33 177.13,70.33 v1(176.73,70.74)
  L5 w0.102: v2(28.98,18.23) 29.94,17.26 31.34,17.26 31.71,16.89 34.87,16.89 35.09,16.66 39.33,16.66 41.67,18.99 52.24,18.99 52.62,19.37 52.96,19.37 52.96,19.37 65.56,19.37 72.39,26.2 76.74,26.2 77.7,27.16 77.7,27.98 80.59,30.88 81.1,30.88 82.17,31.94 82.17,37.45 83.03,38.31 83.03,39 91.82,47.79 92.7,47.79 99.27,54.37 104.08,54.37 104.47,54.75 104.47,54.76 106.63,56.92 106.63,74.04 113.38,80.79 113.38,84.75 116.07,87.44 116.07,96.6 112.08,100.59 112.08,102.18 111.27,102.99 111.27,105.34 111.47,105.54 111.47,105.56 113.68,107.76 120.78,107.76 123.75,104.79 123.92,104.79 123.92,104.79 125.09,104.79 128.93,100.95 144.76,100.95 145.56,101.76 145.56,107.12 147.4,108.96 155.57,108.96 155.95,109.34 159.69,109.34 161.12,107.91 161.45,107.91 161.45,107.91 162.3,107.91 181.92,107.91 182.25,107.58 190.55,107.58 192.54,105.59 192.54,102.67 193.16,102.04 193.16,84.06 194.33,82.89 194.33,78.55 194.33,78.3 194.47,78.17 194.49,78.15 194.94,77.69 195.06,77.57 195.06,77.23 195.47,76.82 195.47,76.65 195.47,74.48 194.33,73.34 194.33,72.51 192.96,71.14 192.96,70.71 192.09,69.84 185.6,69.84 185.31,69.55 182.93,69.55 182.38,70.09 182.34,70.09
  L6 w0.076: 183.18,69.92 182.75,70.34 179.24,70.34 179.17,70.42 178.71,70.42 178.65,70.35 177.11,70.35 v1(176.73,70.74)
  L6 w0.102: v1(231.3,29.47) 230.1,30.67 222.45,30.67 219.26,33.86 219.26,35.2 210.17,44.3 210.17,46.78 209.79,47.16 209.79,57.74 206.65,60.87 206.65,64.88 205.91,65.62 204.73,65.62 202.57,67.78 200.67,67.78 199.5,67.78 199.5,67.78 187.2,67.78 185.92,69.06 184.03,69.06 183.18,69.92
  BOTTOM w0.089: U4555.CH11 v1(176.73,70.74)
EDP_PWM_OUT_R: length 3
  TOP w0.102: v3(24.76,18.94) 24.47,18.94 24.05,19.36 24.05,19.64 23.89,19.79 R3017.2 23.64,20.23 23.76,20.35 U3001.3
EDP_PWM_OUT_RC: length 1.4
  TOP w0.102: R432.2 C306.2 243.56,32.91 244.06,33.41 244.11,33.41 R430.1
EDP_PWM_R: length 11.8
  TOP w0.102: R3004.2 v1(25.93,20.26) 26.08,20.11 R428.2 v3(26.08,18.79)
  BOTTOM w0.102: v1(25.93,20.26) 25.93,20.39 22.63,23.69 22.25,23.69 21.59,24.35 21.59,25.62 20.95,26.25 19.55,26.25 CN3000.18
EDP_PWM_R_OUT: length 2
  TOP w0.102: R3004.1 24.15,20.59 24.15,21.66 23.91,21.9 U3001.4
EDP_TX0_C_R_DN: length 33.5
  BOTTOM w0.076: L7503.2 34.61,21.41 34.79,21.22 35.35,21.22 35.54,21.41 L7503.1
  BOTTOM w0.119: L7503.2 34.35,21.41 34.17,21.23 33.52,21.23 33.4,21.35 33.4,22.3 27.29,28.41 27.27,28.41 23.56,32.11 20.53,32.11 20.39,32.25 CN3000.30 ; L7503.1 35.78,21.41 35.95,21.23 37.78,21.23 v4(38.24,21.69) 40.89,24.35 40.89,28.87 41.14,29.12 41.35,29.12 C3012.2
EDP_TX0_C_R_DP: length 33.5
  BOTTOM w0.076: L7503.4 35.51,20.83 35.29,21.06 34.81,21.06 34.58,20.83 L7503.3
  BOTTOM w0.119: L7503.4 35.73,20.83 35.9,21.01 37.87,21.01 41.11,24.25 v4(41.11,27.57) 41.11,28.78 41.23,28.9 41.4,28.9 C3011.2 ; CN3000.29 20.39,31.75 20.53,31.89 23.47,31.89 27.17,28.19 27.2,28.19 28.78,26.61 29.98,25.41 33.18,22.21 33.18,21.26 33.43,21.01 34.17,21.01 34.35,20.83 L7503.3
EDP_TX0_DN: length 147.7
  L6 w0.127: v1(150.82,79.07) 150.57,79.32 150,79.32 147.9,81.43 142.9,81.43 142.44,80.97 141.86,80.97 141.17,80.28 139.61,80.28 138.99,79.66 137.17,79.66 136.02,78.51 130.36,78.51 128.11,76.26 124.92,76.26 124.59,75.93 123.99,75.93 123.29,75.23 120.9,75.23 117.47,71.8 117.47,71.35 117.47,71.21 117.47,63.9 115.66,62.08 115.34,62.08 112.3,59.04 112.3,49.92 111.01,48.63 101.34,48.63 90.21,37.51 88.25,37.51 84.41,33.67 83.74,33 83.03,33 81.15,31.12 80.53,31.12 79.57,30.15 73.84,30.15 73.02,29.33 61.69,29.33 61.13,28.77 43.7,28.77 43.43,29.03 43.43,29.51 v2(43.17,29.77)
  BOTTOM w0.076: U4555.AG4 151.2,75.72 151.2,76.03 151.14,76.16 151.14,76.16 151.14,76.17 151.04,76.38 151.04,76.65 151.1,76.8 151.1,76.9 151.04,77.05 151.04,77.44 151.26,77.66 151.26,79.21 151.19,79.28 151.04,79.28 v1(150.82,79.07)
  BOTTOM w0.119: v2(43.17,29.77) 43.17,29.33 42.88,29.04 42.39,29.04 C3012.1
EDP_TX0_DP: length 147.7
  L6 w0.127: v1(43.92,29.77) 43.66,29.51 43.66,29.12 43.79,29 61.03,29 61.59,29.55 72.92,29.55 73.75,30.38 79.47,30.38 80.44,31.35 81.06,31.35 82.94,33.22 83.65,33.22 84.32,33.9 88.15,37.73 90.12,37.73 101.24,48.86 110.91,48.86 112.07,50.01 112.07,59.13 115.25,62.31 115.56,62.31 117.24,63.99 117.24,71.21 117.24,71.35 117.24,71.89 120.81,75.46 123.2,75.46 123.9,76.15 124.5,76.15 124.83,76.48 128.02,76.48 130.27,78.74 135.92,78.74 137.08,79.89 138.89,79.89 139.51,80.51 141.08,80.51 141.77,81.2 142.35,81.2 142.81,81.66 147.99,81.66 150.1,79.55 150.57,79.55 v1(150.82,79.81)
  BOTTOM w0.076: U4555.AG3 151.61,76 151.61,76.08 151.52,76.18 151.36,76.18 151.28,76.26 151.21,76.42 151.21,76.62 151.26,76.77 151.26,76.93 151.21,77.08 151.21,77.38 151.43,77.59 151.43,79.28 151.25,79.45 151.18,79.45 v1(150.82,79.81)
  BOTTOM w0.119: v1(43.92,29.77) 42.97,28.82 42.18,28.82 C3011.1
EDP_TX1_C_R_DN: length 23.8
  BOTTOM w0.076: L7502.1 36.28,30.96 36.09,30.77 35.56,30.77 35.37,30.96 L7502.2
  BOTTOM w0.119: C3014.2 41.32,30.52 38.43,30.52 38.16,30.78 v4(37.54,30.78) 36.66,30.78 36.49,30.96 L7502.1 ; CN3000.33 20.39,33.75 20.52,33.61 22.58,33.61 22.97,33.23 23.36,33.23 25.8,30.78 34.91,30.78 35.08,30.96 L7502.2
EDP_TX1_C_R_DP: length 23.8
  BOTTOM w0.076: L7502.3 35.35,30.39 35.57,30.61 36.05,30.61 36.28,30.39 L7502.4
  BOTTOM w0.119: CN3000.32 20.39,33.25 20.53,33.39 22.49,33.39 22.88,33.01 23.27,33.01 25.71,30.56 34.93,30.56 35.11,30.39 L7502.3 ; L7502.4 36.49,30.39 36.67,30.56 38.07,30.56 38.34,30.3 v4(39.39,30.3) 41.43,30.3 C3013.2
EDP_TX1_DN: length 149.5
  L6 w0.127: v2(43.17,31.19) 43.17,31.14 43.38,30.93 43.38,30.66 43.67,30.37 44.58,30.37 45.43,29.52 60.87,29.52 61.39,30.04 72.79,30.04 73.06,30.31 73.06,30.31 74.13,31.37 78.64,31.37 79.05,31.78 80.88,31.78 82.76,33.66 83.47,33.66 84.14,34.33 87.98,38.17 89.94,38.17 101.06,49.29 110.73,49.29 111.6,50.16 111.6,59.28 115.07,62.74 115.3,62.74 116.81,64.25 116.81,71.07 116.81,71.17 116.81,71.71 116.81,72.07 120.63,75.89 123.02,75.89 123.72,76.59 124.32,76.59 124.65,76.92 127.84,76.92 130.81,79.89 132.51,79.89 132.95,80.32 138.5,80.32 140.42,82.24 141.7,82.24 141.85,82.09 148.52,82.09 148.72,81.89 151.94,81.89 v1(152.2,81.64)
  BOTTOM w0.076: U4555.AG2 151.77,77.05 151.77,81.71 151.86,81.8 152.03,81.8 v1(152.2,81.64)
  BOTTOM w0.119: v2(43.17,31.19) 43.17,30.76 42.85,30.44 42.42,30.44 C3014.1
EDP_TX1_DP: length 149.5
  L6 w0.127: v1(152.2,82.37) 151.94,82.12 148.82,82.12 148.61,82.32 141.95,82.32 141.79,82.47 140.33,82.47 138.4,80.55 132.85,80.55 132.42,80.12 130.71,80.12 127.74,77.14 124.55,77.14 124.22,76.81 123.62,76.81 122.93,76.12 120.53,76.12 116.58,72.17 116.58,71.62 116.58,71.17 116.58,71.07 116.58,64.35 115.21,62.97 114.97,62.97 111.38,59.37 111.38,50.26 110.64,49.52 100.97,49.52 89.85,38.39 87.88,38.39 84.05,34.56 83.37,33.89 82.66,33.89 80.79,32.01 78.95,32.01 78.55,31.6 74.03,31.6 72.9,30.47 72.9,30.47 72.83,30.4 72.7,30.27 61.3,30.27 60.77,29.75 45.53,29.75 44.68,30.6 43.77,30.6 43.61,30.75 43.61,30.93 43.87,31.19 v1(43.92,31.19)
  BOTTOM w0.076: U4555.AG1 151.61,77.3 151.61,81.78 151.79,81.96 151.99,81.96 152.2,82.16 v1(152.2,82.37)
  BOTTOM w0.119: v1(43.92,31.19) 42.95,30.22 42.16,30.22 C3013.1
EDP_TX2_C_R_DN: length 23.8
  BOTTOM w0.076: L7501.2 34.58,32.84 34.77,32.65 35.3,32.65 35.49,32.84 L7501.1
  BOTTOM w0.119: L7501.1 35.73,32.84 35.9,32.66 v4(36.73,32.66) 40.46,32.66 41.17,31.96 41.37,31.96 41.58,32.17 C3016.2 ; CN3000.36 20.46,35.25 20.6,35.12 21.26,35.12 22.09,34.28 22.82,34.28 23.23,33.87 26.6,33.87 27.81,32.66 34.14,32.66 34.32,32.84 L7501.2
EDP_TX2_C_R_DP: length 23.8
  BOTTOM w0.076: L7501.4 35.51,32.27 35.29,32.49 34.78,32.49 34.56,32.27 L7501.3
  BOTTOM w0.119: C3015.2 41.43,31.74 41.07,31.74 40.37,32.44 v4(38.63,32.44) 35.88,32.44 35.7,32.27 L7501.4 ; CN3000.35 20.39,34.75 20.53,34.9 21.16,34.9 22,34.06 22.73,34.06 23.14,33.65 26.51,33.65 27.72,32.44 34.14,32.44 34.32,32.27 L7501.3
EDP_TX2_DN: length 148.3
  L6 w0.127: v1(153.72,78.37) 153.47,78.63 153.19,78.63 152.93,78.89 152.93,82.23 152.37,82.79 142.09,82.79 141.97,82.9 140.15,82.9 139.49,82.24 133.84,82.24 132.14,80.55 130.54,80.55 127.56,77.58 124.38,77.58 124.05,77.25 123.45,77.25 122.75,76.55 120.35,76.55 114.22,70.41 110.82,70.41 106.37,65.96 106.37,56.83 89.9,40.36 89.81,40.36 88.28,38.83 87.7,38.83 83.87,34.99 83.87,34.99 83.19,34.32 82.49,34.32 81.08,32.91 74.18,32.91 73.77,32.5 73.77,32.32 72.64,31.19 72.39,31.19 71.9,30.7 45.67,30.7 44.55,31.82 43.64,31.82 43.38,32.08 43.38,32.36 43.17,32.56 v2(43.17,32.61)
  BOTTOM w0.076: U4555.AJ4 152.87,75.72 152.87,76.03 153.03,76.4 153.03,76.64 152.97,76.78 152.97,76.9 153.03,77.05 153.03,77.46 152.93,77.56 152.93,78.18 153.11,78.37 153.72,78.37 v1(153.72,78.37)
  BOTTOM w0.119: v2(43.17,32.61) 43.17,32.18 42.86,31.87 42.43,31.87 C3016.1
EDP_TX2_DP: length 148.3
  L6 w0.127: v1(153.72,79.06) 153.47,78.85 153.29,78.85 153.16,78.98 153.16,82.32 152.46,83.02 142.18,83.02 142.07,83.13 140.05,83.13 139.39,82.47 133.74,82.47 132.05,80.78 130.44,80.78 127.47,77.81 124.28,77.81 123.95,77.48 123.35,77.48 122.65,76.78 120.26,76.78 114.12,70.64 110.73,70.64 106.14,66.06 106.14,56.93 89.8,40.59 89.72,40.59 88.18,39.05 87.61,39.05 83.77,35.22 83.1,34.55 82.39,34.55 80.98,33.14 74.09,33.14 73.54,32.59 73.54,32.41 72.55,31.42 72.3,31.42 71.81,30.93 45.77,30.93 44.65,32.05 43.74,32.05 43.61,32.18 43.61,32.36 43.87,32.61 v1(43.92,32.61)
  BOTTOM w0.076: v1(153.72,79.06) 153.72,78.91 153.34,78.54 153.05,78.54 152.76,78.25 152.76,77.49 152.86,77.39 152.86,77.07 152.81,76.93 152.81,76.75 152.87,76.6 152.87,76.43 152.71,76.06 U4555.AJ3
  BOTTOM w0.119: C3015.1 42.14,31.65 42.95,31.65 v1(43.92,32.61)
EDP_TX3_C_R_DN: length 23.8
  BOTTOM w0.076: L7500.1 36.28,34.72 36.1,34.54 35.53,34.54 35.35,34.72 L7500.2
  BOTTOM w0.119: CN3000.39 20.38,36.75 20.52,36.62 21,36.62 22.64,34.97 27.47,34.97 27.9,34.54 34.93,34.54 35.11,34.72 L7500.2 ; C3018.2 41.35,33.39 39.32,33.39 38.17,34.54 v4(37.54,34.54) 36.72,34.54 36.54,34.72 L7500.1
EDP_TX3_C_R_DP: length 23.8
  BOTTOM w0.076: L7500.4 36.28,34.14 36.05,34.37 35.57,34.37 35.34,34.14 L7500.3
  BOTTOM w0.119: CN3000.38 20.39,36.25 20.53,36.39 20.91,36.39 22.55,34.75 27.37,34.75 27.81,34.32 34.93,34.32 35.11,34.14 L7500.3 ; L7500.4 36.51,34.14 36.69,34.32 38.08,34.32 39.23,33.17 v4(40.56,33.17) 41.4,33.17 C3017.2
EDP_TX3_DN: length 149.6
  L6 w0.127: v1(153.72,80.38) 153.89,80.21 154.37,80.21 154.48,80.32 154.48,81.61 152.64,83.45 142.36,83.45 142.25,83.56 134.07,83.56 131.72,81.21 130.26,81.21 127.29,78.24 124.1,78.24 123.77,77.91 123.17,77.91 122.47,77.21 120.08,77.21 113.94,71.07 110.55,71.07 105.69,66.21 105.69,57.08 89.63,41.02 89.54,41.02 88.13,39.61 86.05,39.61 83.84,37.4 83.84,36.61 80.85,33.62 73.27,33.62 72.32,32.67 72.06,32.67 70.75,31.36 46.44,31.36 44.55,33.24 43.64,33.24 43.38,33.5 43.38,33.78 43.17,33.99 v1(43.17,34.04)
  BOTTOM w0.076: U4555.AJ2 152.33,76.99 152.33,78.48 153.08,79.23 153.08,79.93 153.29,80.14 153.53,80.14 v1(153.72,80.38)
  BOTTOM w0.119: C3018.1 42.29,33.41 43.18,33.41 43.3,33.53 43.3,33.91 v1(43.17,34.04)
EDP_TX3_DP: length 149.6
  L6 w0.127: v1(43.92,34.04) 43.87,34.04 43.61,33.78 43.61,33.6 43.74,33.47 44.65,33.47 46.53,31.59 70.66,31.59 71.97,32.9 72.22,32.9 73.17,33.85 80.76,33.85 83.61,36.7 83.61,37.5 85.96,39.84 88.04,39.84 89.45,41.25 89.53,41.25 105.46,57.18 105.46,66.3 110.45,71.3 113.85,71.3 119.98,77.44 122.38,77.44 123.08,78.14 123.68,78.14 124.01,78.47 127.19,78.47 130.17,81.44 131.63,81.44 133.98,83.79 142.34,83.79 142.45,83.68 152.74,83.68 154.71,81.71 154.71,80.23 154.46,79.98 153.98,79.98 v2(153.72,79.72)
  BOTTOM w0.076: v2(153.72,79.72) 153.47,79.97 153.36,79.97 153.25,79.86 153.25,79.16 152.5,78.41 152.5,77.26 U4555.AJ1
  BOTTOM w0.119: v1(43.92,34.04) 43.52,33.64 43.52,33.44 43.28,33.19 42.29,33.19 C3017.1
EDP_VDD_EN: length 288
  TOP w0.102: v1(51.78,9.39) 51.78,8.67 52.34,8.11 R3003.1
  L5 w0.076: v1(176.14,70.74) 176.75,70.13 178.32,70.13 178.54,69.91 178.54,69.71 178.95,69.29 181.66,69.29 181.68,69.27 181.73,69.27 181.96,69.05
  L5 w0.102: v2(55.91,21.45) 57.6,19.78 65.39,19.78 72.68,27.07 74.08,27.07 75.37,28.36 76.86,28.36 81.76,33.26 81.76,37.62 82.62,38.48 82.62,39.17 92.27,48.81 92.66,48.81 98.63,54.78 102.74,54.78 105.81,57.85 105.81,73.8 112.98,80.96 112.98,84.92 115.67,87.61 115.67,96.42 114.73,97.35 114.73,97.37 111.68,100.42 111.68,102.01 110.87,102.82 110.87,106.59 112.44,108.17 120.95,108.17 122.59,106.53 123.43,106.53 126.93,106.53 127.31,106.14 130.92,106.14 131.53,106.75 134.59,106.75 135.19,106.14 138.81,106.14 139.06,106.4 139.06,106.44 139.34,106.72 139.38,106.72 139.89,107.23 145.16,107.23 145.16,107.28 147.23,109.36 155.4,109.36 155.78,109.75 159.86,109.75 161.29,108.32 162.13,108.32 171.77,108.32 174.15,110.71 175.62,110.71 177.73,108.6 181.81,108.6 182.42,107.99 190.71,107.99 193.57,105.13 193.57,104.97 193.57,84.27 194.74,83.11 194.74,78.72 194.74,78.47 195.35,77.86 195.47,77.74 195.47,77.4 195.88,76.99 195.88,76.82 195.88,76.82 195.88,76.65 195.88,76.48 195.88,74.31 194.74,73.18 194.74,72.34 193.37,70.97 193.37,70.51 191.38,68.52 186.51,68.52 186,69.03 182.86,69.03 182.85,69.05 181.96,69.05
  BOTTOM w0.089: U4555.CG11 175.9,71.02 176.15,70.78 176.15,70.74 v1(176.14,70.74)
  BOTTOM w0.102: v2(55.91,21.45) 55.91,17.09 53.44,14.62 53.44,11.93 53.34,11.83 52.39,11.83 52.29,11.72 52.29,10.14 51.78,9.63 v1(51.78,9.39) U3000.3
EMMC_CLK: length 27.6
  TOP w0.13: R3803.1 R3801.2 195.59,72.57 195.44,72.42 195.18,72.42 195.1,72.34 193.12,72.34 192.99,72.21 192.99,72.02 193.19,71.82 193.67,71.82 193.8,71.69 193.8,71.21 194,71.01 194.21,71.01 194.34,71.15 194.34,71.67 194.47,71.8 194.74,71.8 194.87,71.67 194.87,71.24 195,71.11 195.21,71.11 v2(195.39,71.25)
  BOTTOM w0.076: U4555.CP16 179.85,67.72 180.34,67.46 180.61,67.46 180.8,67.66 181.28,67.66 181.73,67.2 182.42,67.2 183.01,66.6 185.69,66.6 186.96,67.87
  BOTTOM w0.13: 186.96,67.87 187.17,68.08 187.17,68.08 187.59,68.5 189.54,68.5 190.05,69.02 193.11,69.02 194.32,70.23 194.32,71.19 194.53,71.4 195.24,71.4 v2(195.39,71.25)
EMMC_CLK_IC: length 15.5
  TOP w0.076: 201.84,77.57 202.33,78.05 205.18,78.05 205.26,77.98 205.26,77.41 U3800.M6
  TOP w0.13: 201.84,77.57 201.23,76.95 201.23,76.2 201.1,76.07 200.54,76.07 200.4,75.93 200.4,74.95 200.27,74.82 200.02,74.82 199.89,74.95 199.89,75.73 199.76,75.86 199.5,75.86 199.37,75.73 199.37,74.45 199.23,74.31 198.98,74.31 198.85,74.44 198.85,74.76 198.72,74.89 198.52,74.89 198.33,74.69 198.33,73.42 198.11,73.21 v3(197.83,73.21) R3803.2
EMMC_CMD: length 20.9
  TOP w0.13: v1(195.39,71.91) 195.77,71.91 195.9,71.78 195.9,71.11 196.03,70.98 196.39,70.98 196.52,71.11 R3823.1 R3802.1
  BOTTOM w0.076: U4555.CR16 180.54,67.72 180.65,67.83 181.34,67.83 181.77,67.41 182.44,67.41 183.08,66.77 185.55,66.77 187.36,68.58
  BOTTOM w0.13: 187.36,68.58 187.49,68.71 187.49,68.71 187.79,69.01 189.32,69.01 189.84,69.53 192.56,69.53 193.81,70.78 193.81,71.4 v3(193.82,71.41) 193.82,71.78 193.95,71.91 v1(195.39,71.91)
EMMC_CMD_IC: length 22.4
  TOP w0.076: 201.84,76.84 202.56,77.56 203.76,77.56 204.09,77.89 204.92,77.89 204.99,77.81 204.99,77.49 204.81,77.31 U3800.M5
  TOP w0.13: 201.84,76.84 201.74,76.74 201.74,75.69 201.61,75.56 201.05,75.56 200.92,75.43 200.92,75.24 201.05,75.12 202.34,75.12 202.47,74.99 202.47,74.8 202.38,74.71 201,74.71 200.87,74.58 200.87,74.4 201,74.27 201.59,74.27 201.72,74.14 201.72,73.96 201.59,73.83 200.67,73.83 198.94,72.1 198.78,72.1 198.67,72.21 198.67,72.4 200.15,73.87 200.15,74.06 200.02,74.19 199.83,74.19 197.83,72.19 v3(197.83,71.76) 197.19,71.76 R3802.2
EMMC_DATA_0: length 32.5
  TOP w0.13: R3804.1 198.24,80.96 R3800.1 197.7,80.42 v1(197.7,79.94)
  BOTTOM w0.076: U4555.CR20 180.53,65.28 181.38,65.28 181.54,65.12 186.6,65.12 187.42,65.94 187.77,65.94
  BOTTOM w0.13: 187.77,65.94 189.95,65.94 190.6,65.94 191.12,66.46 193.96,66.46 194.18,66.46 195.96,68.24 196.74,68.24 196.87,68.37 196.87,69.15 198.05,70.33 198.05,71.73 198.72,72.4 198.72,74.01 197.11,75.61 197.11,76.85 197.79,77.53 197.79,79.84 v1(197.7,79.94)
EMMC_DATA_0_IC: length 10.6
  TOP w0.076: 201.84,82.21 202.41,82.77 202.41,82.91 202.56,83.05 203.41,83.05 U3800.A3
  TOP w0.13: 201.84,82.21 200.8,81.16 200.02,81.16 199.89,81.03 199.89,80.33 200.52,79.69 200.52,79.51 199.94,78.93 199.58,78.93 199.45,79.06 199.45,81.03 199.32,81.16 199.05,81.16 R3804.2
EMMC_DATA_1: length 36.9
  TOP w0.13: R3805.1 196.87,81.93 R3814.1 196.61,81.6 196.17,81.16 v1(195.87,81.16)
  BOTTOM w0.076: U4555.CM20 178.57,65.28 178.84,65.56 179.32,65.56 179.41,65.46 179.89,65.46 180.02,65.41 180.23,65.41 180.36,65.46 181.43,65.46 181.61,65.28 186.53,65.28 187.45,66.2 187.87,66.2
  BOTTOM w0.13: 187.87,66.2 190.49,66.2 191.01,66.71 194.07,66.71 196.7,69.34 196.7,69.34 197.79,70.43 197.79,71.83 198.46,72.5 198.46,73.9 196.86,75.51 196.86,76.96 197.54,77.64 197.54,79.4 197.2,79.73 197.2,80.14 197.3,80.24 197.3,81 197.15,81.16 v3(196.77,81.16) v1(195.87,81.16)
EMMC_DATA_1_IC: length 7.7
  TOP w0.076: 201.84,83.07 202.16,83.38 203.67,83.38 204.07,82.98 204.07,82.89 U3800.A4
  TOP w0.13: R3805.2 197.73,82.53 v3(197.84,82.64) 197.92,82.56 201.34,82.56 201.84,83.07
EMMC_DATA_2: length 36.9
  TOP w0.13: R3806.1 R3815.1 195.94,83.36 v1(195.87,83.29)
  BOTTOM w0.076: U4555.CN19 179.48,65.83 179.68,65.63 179.92,65.63 180.05,65.58 180.2,65.58 180.33,65.63 181.5,65.63 181.68,65.45 186.46,65.45 187.47,66.45 187.87,66.45
  BOTTOM w0.13: v1(195.87,83.29) 196.37,82.79 196.37,82.02 196.08,81.73 195.85,81.73 195.45,81.33 195.45,80.98 195.7,80.74 195.93,80.74 196.37,80.29 196.37,80.2 197.28,79.29 197.28,77.75 196.6,77.06 196.6,75.4 197.95,74.05 197.95,73.2 v3(197.94,73.19) 197.95,73.18 197.95,72.35 197.53,71.94 197.53,70.54 197.36,70.37 193.96,66.97 190.9,66.97 190.39,66.45 187.87,66.45
EMMC_DATA_2_IC: length 8.5
  TOP w0.076: 201.84,83.71 203.84,83.71 204.57,82.98 204.57,82.89 U3800.A5
  TOP w0.13: R3806.2 197.05,83.91 v3(197.71,83.91) 198.29,83.34 201.38,83.34 201.76,83.71 201.84,83.71
EMMC_DATA_3: length 36.2
  TOP w0.13: R3807.1 198.35,78.89 198.85,78.4 R3816.1 198.85,78.25 197.6,77 195.35,77 195.22,77.13 195.22,77.32 195.35,77.44 196.66,77.44 196.78,77.57 v1(196.78,77.96)
  BOTTOM w0.076: 187.77,66.71 187.49,66.71 186.39,65.61 182.6,65.61 182,66.21 181.62,66.21 181.46,66.05 180.4,66.05 180.22,66.11 180.03,66.11 179.94,66.08 179.93,66.07 179.68,66.07 179.57,66.11 179.09,66.11 U4555.CM19
  BOTTOM w0.13: 187.77,66.71 190.28,66.71 190.8,67.23 193.86,67.23 196.48,69.85 197.28,70.65 197.28,72.23 197.11,72.4 197.11,74.53 196.34,75.29 196.34,77.51 v1(196.78,77.96)
EMMC_DATA_3_IC: length 7
  TOP w0.076: 201.84,81.34 202.56,82.05 202.91,82.05 U3800.B2
  TOP w0.13: 201.84,81.34 201.4,80.9 201.4,79.66 200.03,78.29 199.49,78.29 R3807.2
EMMC_DATA_4: length 33.4
  TOP w0.13: R3808.1 198.35,80.28 198.85,79.78 R3817.1 198.85,79.67 198.58,79.4 198.31,79.4 198.26,79.36 198.03,79.13 196.9,79.13 v1(196.78,79.02)
  BOTTOM w0.076: 187.79,66.97 187.51,66.97 186.33,65.78 182.67,65.78 182.07,66.37 181.55,66.37 181.4,66.22 180.39,66.22 180.24,66.28 180.01,66.28 179.89,66.23 179.71,66.23 179.59,66.28 179.29,66.28 U4555.CN18
  BOTTOM w0.13: v1(196.78,79.02) 196.09,78.32 196.09,77 v3(195.81,76.72) 195.44,76.36 195.44,74.47 195.57,74.34 196.18,74.34 196.85,73.67 196.85,72.29 197.02,72.12 197.02,70.75 196.85,70.58 193.75,67.48 190.69,67.48 190.17,66.97 187.79,66.97
EMMC_DATA_4_IC: length 9.9
  TOP w0.076: 201.84,81.84 202.56,82.55 203.41,82.55 U3800.B3
  TOP w0.13: R3808.2 199.06,80.35 199.19,80.23 199.19,78.95 199.6,78.54 199.92,78.54 201.14,79.77 201.14,79.95 201.01,80.08 200.83,80.08 200.76,80.01 200.57,80.01 200.38,80.2 200.38,80.38 201.84,81.84
EMMC_DATA_5: length 31.7
  TOP w0.13: v1(195.87,80.09) 196.34,80.81 R3818.1 R3809.1
  BOTTOM w0.076: U4555.CR18 180.55,66.4 181.34,66.4 181.48,66.54 182.14,66.54 182.74,65.94 186.26,65.94 187.54,67.22 187.69,67.22
  BOTTOM w0.13: v1(195.87,80.09) 195.68,80.28 195.31,80.28 195.18,80.15 195.18,74.21 195.31,74.09 196.08,74.09 196.52,73.64 196.52,72.47 196.59,72.39 196.59,70.69 196.27,70.37 193.64,67.74 190.59,67.74 190.07,67.22 187.69,67.22
EMMC_DATA_5_IC: length 11.6
  TOP w0.076: 201.84,82.61 202.45,83.22 203.6,83.22 203.91,82.91 203.91,82.56 U3800.B4
  TOP w0.13: R3809.2 197.83,81.42 200.68,81.42 200.81,81.55 200.81,81.73 200.68,81.86 199.16,81.86 199.03,81.99 199.03,82.17 199.16,82.3 201.54,82.3 201.84,82.61
EMMC_DATA_6: length 34.5
  TOP w0.13: R3819.1 195.33,83.34 R3810.1 195.33,82.67 195.77,82.22 v1(195.87,82.22)
  BOTTOM w0.076: U4555.CP18 179.96,66.5 180.09,66.63 180.34,66.76 180.61,66.76 180.8,66.56 181.27,66.56 181.41,66.7 182.21,66.7 182.81,66.11 186.19,66.11 187.56,67.48
  BOTTOM w0.13: v1(195.87,82.22) 195.4,82.7 195.06,82.7 194.93,82.57 194.93,73.96 195.06,73.83 195.97,73.83 196.26,73.54 196.26,72.36 196.34,72.29 196.34,70.8 193.54,68 190.48,68 189.96,67.48 187.56,67.48
EMMC_DATA_6_IC: length 10
  TOP w0.076: U3800.B5 204.41,82.56 204.41,82.91 203.77,83.55 201.96,83.55 201.84,83.43
  TOP w0.13: 201.84,83.43 201.49,83.08 198.1,83.08 198.04,83.14 197.63,83.14 197.13,82.64 v3(196.56,82.64) 196.46,82.74 R3810.2
EMMC_DATA_7: length 36.1
  TOP w0.13: R3811.1 196.28,84.36 v1(195.87,84.36) 195.1,84.36 R3820.1
  BOTTOM w0.076: U4555.CM18 178.91,66.82 180.09,66.82 180.3,66.93 180.67,66.93 180.87,66.73 181.2,66.73 181.35,66.87 182.28,66.87 182.88,66.27 185.98,66.27 187.41,67.7 187.44,67.7
  BOTTOM w0.13: v1(195.87,84.36) 194.67,83.16 194.67,73.59 196.08,72.18 196.08,70.9 193.43,68.25 190.37,68.25 189.85,67.73 187.47,67.73 187.44,67.7
EMMC_DATA_7_IC: length 10.4
  TOP w0.076: 204.1,83.72 204.91,82.91 204.91,82.55 U3800.B6
  TOP w0.13: R3811.2 196.45,85.03 197.3,85.03 198.73,83.59 201.28,83.59 201.66,83.97 203.85,83.97 204.1,83.72
EMMC_PLT_RST#: length 11.8
  TOP w0.076: U3800.K5 204.41,78.55 202.13,78.55 201.84,78.27
  TOP w0.102: 201.84,78.27 199.93,76.36 199.29,76.36 197.83,74.9 v3(197.83,74.48) 197.6,74.25 197.36,74.25 197.3,74.19 197.26,74.17 196.79,74.17 196.52,73.89 R3826.2 196.51,73.83 Q3800.6
EMMC_PRSNT#: length 9.3
  TOP w0.102: v1(177.79,60.12) 177.85,60.18 v3(182.75,60.18) 183.58,60.18 183.78,60.39 R4621.2 184.8,60.39 185.22,59.97 R4620.2
  BOTTOM w0.076: U4555.CM27 178.48,60.8 v1(177.79,60.12)
EMMC_RCLK: length 28.2
  TOP w0.13: v1(194.25,75.69) 194.6,75.69 195.3,74.99 R3813.2 R3822.1
  BOTTOM w0.076: U4555.CM16 178.38,67.8 178.22,67.97 178.22,68.12 178.35,68.25 178.5,68.25 178.67,68.08 179.54,68.08 179.63,67.98 179.89,67.98 179.89,67.98 180.03,67.93 180.23,67.93 180.42,68 181.4,68 181.82,67.59 182.5,67.59 183.15,66.93 185.4,66.93 187.27,68.8
  BOTTOM w0.13: 187.27,68.8 187.99,69.52 189.11,69.52 189.63,70.04 192.35,70.04 193.3,70.99 v3(193.3,75.3) 193.3,76.8 193.43,76.93 193.69,76.93 193.82,76.8 193.82,75.82 193.95,75.69 v1(194.25,75.69)
EMMC_RCLK_IC: length 15.2
  TOP w0.076: 201.84,78.97 201.93,79.05 204.58,79.05 204.66,79.13 U3800.H5
  TOP w0.13: R3822.2 196.66,75.02 196.79,75.15 197.38,75.15 197.51,75.28 197.51,75.62 197.38,75.74 195.4,75.74 195.27,75.87 195.27,76.13 195.4,76.26 197.93,76.26 198.83,77.17 198.93,77.17 199.31,77.55 200.42,77.55 201.84,78.97
EMMC_RCOMP: length 8.6
  TOP w0.254: R4812.1 184.95,66.82 183.16,66.82 v3(182.65,67.32) 182.15,67.82 181.58,67.82 178.75,67.82 178.49,67.57 v1(178.05,67.57)
  BOTTOM w0.254: U4555.CK15 v1(178.05,67.57)
EN_1V5: length 6.6
  BOTTOM w0.13: U61700.1 225.22,90.91 224.74,90.43 223.68,90.43 R7124.2 221.3,91.97 TP61701.1
EN_1V05A: length 4.2
  BOTTOM w0.102: U60900.9 167.46,103.08 R7026.2 168.08,103.27 168.12,103.32 TP60901.1 169.06,103.82 R60903.2
EN_1V8: length 3.5
  BOTTOM w0.102: U60600.9 108.2,102.98 108.2,103.25 107.46,103.99 TP60601.1 107.46,105.43 R4800.2
EN_2V5: length 67.3
  TOP w0.102: U1000.8 138.93,8.78 139.12,8.59 139.12,7.45 139.06,7.4 139.06,6.06 v1(139.32,5.81) 139.42,5.91 R1002.2
  L3 w0.102: v1(139.32,5.81) 140.18,6.67 143.56,6.67 145.32,4.9 145.86,4.9 146.23,4.54 161.51,4.54 162.09,3.95 173.76,3.95 174.01,3.95 177.93,7.86 190.04,7.86 191.29,7.86 191.94,7.22 195.44,7.22 v1(195.86,6.8)
  BOTTOM w0.102: U60400.1 197.71,6.72 TP60410.1 196.57,7.51 195.97,6.9 195.96,6.9 v1(195.86,6.8)
EN_3V: length 4.4
  TOP w0.102: v1(225.68,80.6) 225.19,81.09 TP60101.1
  BOTTOM w0.102: R7112.2 R60110.2 224.73,81.55 v1(225.68,80.6) U60100.11
EN_5V: length 61.1
  TOP w0.102: v1(233.12,74.69) 233.32,74.49 TP60204.1
  L3 w0.102: v1(233.12,74.69) 233.12,75.23 229.18,79.16 229.18,81.49 223.31,87.36 223.31,94 223.08,94.24 219.99,94.24 214.67,99.56 214.67,99.61 213.69,100.59 212.5,100.59 212.23,100.85 205.04,100.85 204.23,100.04 198.68,100.04 v1(198.35,99.71)
  BOTTOM w0.102: v1(233.12,74.69) 233.12,74.58 R60204.1 ; v1(198.35,99.71) 198.2,99.56 R60255.2 R7113.2 194.68,99.56 TP60251.1 194.13,99.56 R60254.1 192.71,99.56 192.28,99.13 192.28,98.91 192.05,98.69 U60250.12
EN_5V_3V: length 358.9
  TOP w0.102: v1(141.56,8.14) 141.12,8.59 141.04,8.65 R1005.2 ; v1(234.16,28.56) 234.93,28.56 235.49,29.12 235.83,29.12 236.39,28.55 R1000.1
  L5 w0.102: v1(215.49,107.58) 216.07,107.58 216.33,107.85 216.33,108.59 216.77,109.03 217.11,109.03 217.4,108.74 217.4,106.14 217.32,106.07 217.32,103.28 216.94,102.9 216.94,100.71 219.1,98.55 219.1,88.83 220.85,87.08 220.85,82.86 222.5,81.21 222.5,79.69 v1(221.64,78.83) 221.31,79.16 221.31,81.47 221.05,81.73 220.79,81.73 217.92,78.87 217.92,72.93 221.92,68.94 221.92,68.6 221.48,68.16 220.89,68.16 220.28,67.55 220.19,67.55 219.53,66.89 219.53,62.95 225.22,57.26 225.22,53.09 226.51,51.79 226.51,47.79 226.51,47.79 226.51,47.53 225.93,46.94 225.93,44.82 228.93,41.82 228.93,41.36 228.93,41.19 227.38,39.64 227.38,36.53 230.11,33.8 231.16,33.8 233.02,31.94 233.31,31.94 234.16,31.09 v1(234.16,28.56)
  L6 w0.102: v1(215.49,107.58) 215.08,107.18 214.64,107.18 213.82,107.99 211.35,107.99 209.02,110.31 206.98,110.31 204.86,108.19 203.23,108.19 200.54,105.5 199.23,105.5 198.43,104.69 196.85,104.69 v1(196.26,104.1) 188.5,104.1 188.5,104.1 187.96,103.57 184.52,103.57 182.23,105.86 172.28,105.86 172.15,105.73 157.52,105.73 155.13,108.12 139.09,108.12 138.58,107.61 138.47,107.61 138.2,107.34 138.04,107.34 124.24,107.34 123.33,108.24 108.59,108.24 v1(108.18,107.83) ; v1(141.56,8.14) 142.63,7.08 147.59,7.08 147.82,6.84 147.82,6.5 148.06,6.26 164.49,6.26 167.87,9.65 170.57,9.65 171.4,10.48 175.36,10.48 176,9.84 193.32,9.84 193.72,10.25 197.93,10.25 198.49,9.69 213.89,9.69 214.53,10.33 237.29,10.33 237.67,10.71 241.41,10.71 242.13,11.43 242.13,11.76 242.13,11.76 242.13,18.97 241.7,19.4 241.7,19.71 234.16,27.25 v1(234.16,28.56)
  BOTTOM w0.102: R7113.1 196.34,101.25 196.34,104.03 v1(196.26,104.1) ; U4413.3 v1(108.18,107.83) ; R7112.1 223.1,82.49 222.08,81.46 222.08,79.54 221.64,79.1 v1(221.64,78.83)
EN_EMMC_PLT_RST#: length 2.9
  TOP w0.102: v3(192.81,73.01) 192.99,72.83 Q3800.3 ; v3(192.81,73.01) R3825.2 ; v3(192.81,73.01) 193.13,73.33 Q3800.2
EN_USB5V: length 72
  TOP w0.076: v1(233.8,44.74) 234.65,43.9 235.21,43.9 235.21,43.89 235.62,43.89 U300.K11
  L3 w0.102: v1(220.21,79.36) 219.81,78.96 219.81,78.2 221.86,76.14 230.11,76.14 231.16,75.1 232.1,75.1 v1(232.51,74.69)
  L6 w0.102: v1(233.8,44.74) 233.17,45.38 231.2,45.38 228.34,48.24 222.02,48.24 219.99,50.28 219.99,53.13 220.14,53.28 220.54,53.28 220.89,53.62 220.89,54.59 222.07,55.77 222.07,60.29 219.63,62.73 219.63,64.49 219.63,65.33 218.82,66.14 218.82,66.84 218.39,67.27 217.27,68.39 217.27,69.45 218.49,70.67 218.49,77.47 219.81,78.79 219.81,78.96 v1(220.21,79.36)
  BOTTOM w0.102: R60206.1 231.09,72.75 231.09,73.8 231.19,73.9 R60202.1 231.72,73.9 v1(232.51,74.69) 232.51,75.33 TP60202.1
EN_VCC_PRIM: length 4.3
  BOTTOM w0.102: R7025.2 183.47,96.37 TP61401.1 182.42,96.92 R61421.1 181.37,96.71 U61400.5
EN_VCCIO: length 3.8
  BOTTOM w0.102: TP60501.1 104.31,59.15 R4821.2 104.31,57.7 R60523.1 104.31,57.25 104.21,57.15 U60500.5
EN_VDDQ: length 24.9
  TOP w0.102: TP60301.1 156.89,3.09 156.89,3.19 v1(156.89,3.75) ; U1000.10 138.81,9.48 139.03,9.48 139.53,8.99 139.53,8.35 R1003.2 140.06,7.71 140.52,7.25 141.53,7.25 v1(142.92,5.86)
  L3 w0.102: v1(156.89,3.75) 155.95,2.81 153.42,2.81 152.56,3.67 143.84,3.67 142.92,4.59 v1(142.92,5.86)
  BOTTOM w0.102: v1(156.89,3.75) 156.99,3.75 157.51,4.27 U60300.15
EN_VTT: length 3.5
  TOP w0.102: TP60351.1 156.87,4.51 v1(156.11,3.75)
  BOTTOM w0.102: R7119.2 155.85,3.49 v1(156.11,3.75) 157.01,4.66 U60300.16
ESDIO_RCOMP: length 15.3
  TOP w0.076: v2(177.93,56.28) 178.37,56.73 183.09,56.73 183.28,56.92
  TOP w0.102: 183.28,56.92 184.67,58.31 186.36,58.31 186.98,58.92 187.65,58.92 187.79,59.06 190.47,59.06 R4819.1
  BOTTOM w0.203: U4555.CK33 v2(177.93,56.28) U4555.CM34
ESIM_CLK: length 3.1
  BOTTOM w0.13: CN1400.44 209.5,60.66 210.23,61.39 C7505.1 210.23,61.83 210.59,62.2 210.59,62.23 U1400.D1
ESIM_DATA: length 4.5
  BOTTOM w0.102: C7506.1 208.61,61.57 208.94,61.24 208.94,60.93 209,60.87 CN1400.42 ; C7506.1 208.21,61.61 R1401.1 ; C7506.1 208.61,61.7 208.91,62 208.91,62.5 U1400.C3
ESIM_PWR: length 13.1
  BOTTOM w0.254: CN1400.48 210.5,60.93 210.95,61.38 C1402.1 210.95,61.73 212.3,63.08 212.3,64.15 212.04,64.4 U1400.A1 210.81,65.32 v3(210.61,65.52) 210.36,65.77 C1409.1 209.6,65.77 208.99,65.16 208.99,63.31 208.32,62.65 208.31,62.65 208,62.34 R1401.2
ESIM_RST: length 6.3
  BOTTOM w0.076: 211.1,62.88 210.97,62.75 210.71,62.75 210.41,62.45 U1400.D2
  BOTTOM w0.102: CN1400.46 210,60.83 210.56,61.39 210.56,61.74 211.88,63.06 C7507.1 211.56,63.34 211.1,62.88
ESPI_0: length 2.5
  TOP w0.076: v1(173.19,59.22) 173.57,58.84 173.57,57.49 R4846.1
  BOTTOM w0.13: U4555.CA29 172.8,59.43 v1(173.19,59.22)
ESPI_1: length 2.6
  TOP w0.076: R4847.1 172.64,57.81 172.64,58.73 172.26,59.11 v1(172.26,59.22)
  BOTTOM w0.13: v1(172.26,59.22) U4555.BY29
ESPI_2: length 6.6
  TOP w0.076: v3(173.81,55.69) 173.16,56.34 R4848.1 172.99,56.45 172.49,56.45 172.07,56.87 172.07,57.37 171.88,57.55 171.88,60.11 v1(172.26,60.49)
  BOTTOM w0.076: U4555.BY27 v1(172.26,60.49)
ESPI_3: length 5.4
  TOP w0.076: R4849.1 172.49,56.22 171.9,56.8 171.9,57.3 171.72,57.48 171.72,60.12 v2(171.35,60.49)
  BOTTOM w0.13: v2(171.35,60.49) U4555.BV27
ESPI_ALERT#: length 2.2
  BOTTOM w0.13: CN375.4 251.74,35.59 251.74,34.72 v3(251.46,34.43) 251.21,34.68 R417.2
ESPI_CLK: length 2.2
  TOP w0.076: v1(171.35,57.31) 171.35,56.72 v3(171.45,56.63) 171.45,56.18 171.6,56.03 R4850.1
  BOTTOM w0.13: v1(171.35,57.31) U4555.BV32
ESPI_FLASH_SHARING: length 13.2
  BOTTOM w0.076: 188,62.08 185.55,62.08 v3(185.11,61.64) 181.08,61.64 180.94,61.77 178.91,61.77 U4555.CM26
  BOTTOM w0.102: 188,62.08 191.27,62.08 R4536.2
ESPI_LPC#: length 83.6
  TOP w0.076: 187.18,69.19 186.68,69.19 186.55,69.06 182.74,69.06 182.57,68.89 182.41,68.89 181.76,68.24 176.69,68.24 v2(176.07,67.62)
  TOP w0.13: R2703.1 250.12,74.32 250.18,74.38 250.18,74.75 249.91,75.01 249.81,75.01 249.03,75.8 249.03,76.77 248.71,77.08 246.09,77.08 245.78,77.08 244.36,75.66 244.36,75.14 242.78,73.56 242.6,73.56 242.35,73.32 242.35,71.68 241.47,70.8 234.41,70.8 232.93,70.8 232.93,70.8 232.61,70.8 232.61,70.8 216.97,70.8 214.8,68.63 213.84,68.63 213.28,69.19 211.13,69.19 209.73,70.6 R4702.2 207.59,70.57 207.46,70.57 206.08,69.19 203.27,69.19 203.27,69.19 202.06,69.19 202.06,69.19 187.18,69.19
  BOTTOM w0.13: U4555.CG15 v2(176.07,67.62)
EXT_MIC_JACK: length 24.3
  TOP w0.254: TP2516.1 3.71,45.4 v1(3.75,45.4) ; R511.2 22.53,45.61 22.04,45.12 22.04,44.8 v1(21.85,44.61) 21.85,44.6 21.79,44.54 21.79,44 21.85,43.94 U500.31
  L5 w0.254: v1(3.75,45.4) 4.35,46 9.38,46 9.6,46.22 20.24,46.22 v1(21.85,44.61)
  BOTTOM w0.254: CN2500.26 3.77,44.02 3.77,45.39 v1(3.75,45.4)
EXT_MIC_JACK_DB: length 8.9
  L3 w0.254: v1(29.25,73.88) 29.46,73.64 33.75,73.64 35.23,72.17 v2(35.23,71.12)
  BOTTOM w0.254: CN9202.5 34.75,71.38 35,71.12 v2(35.23,71.12)
EXT_MIC_JACK_R_DB: length 25.2
  TOP w0.254: v1(28.6,73.09) 28.28,73.09 28.02,73.34 R9217.1 27.77,74.13 C9226.1 ; D9204.1 30.86,69.95 v1(30.86,70.55)
  L5 w0.254: v1(28.6,73.09) 30,73.09 30.86,72.24 v1(30.86,70.55) 30.17,69.86 30.17,64.21 28.67,62.7 20.65,62.7 JACK9200.4
EXT_PWR_GATE#: length 18.5
  TOP w0.102: v2(183.68,46.15) 184.21,46.15 185.62,44.74 185.62,43.54 R4623.2
  BOTTOM w0.076: U4555.CC37 173.89,54.42 173.78,54.3 173.78,53.61 174.58,52.81 175.26,52.81 176.14,51.93 178.76,51.93 182.53,48.17
  BOTTOM w0.102: 182.53,48.17 182.53,47.44 182.77,47.19 182.96,47.19 183.2,46.95 183.2,46.63 v2(183.68,46.15)
EXT_SMI#: length 95.3
  TOP w0.076: v1(240.83,43.24) U300.J4
  L3 w0.102: v1(202.18,72.37) 200.94,72.37 200.08,73.23 197.27,73.23 196.56,73.94 195.51,73.94 195.45,73.89 194,73.89 193.64,74.24 193.64,76.06 191.73,77.97 188.45,77.97 187.74,77.26 186,77.26 183.93,75.2 183.93,73.91 183.69,73.67 183.32,73.67 v1(182.91,74.08)
  L6 w0.102: v2(218.16,45.61) 217.73,46.04 217.73,48.09 214.5,51.31 214.5,54.53 213.88,55.15 213.88,57.98 213.48,58.38 213.48,61.35 214.38,62.25 214.38,66 211.78,68.59 208.02,68.59 207.11,69.51 207.11,69.97 205.46,71.62 202.82,71.62 202.18,72.25 v1(202.18,72.37)
  BOTTOM w0.076: U4555.CP6 179.97,74.24 180.71,74.46 181.41,74.46 181.44,74.49 182.5,74.49 v1(182.91,74.08) ; 232.51,45.28 235.45,45.28 235.58,45.15 237.7,45.15 238.02,45.47 238.02,46.14 238.23,46.34 239.59,46.34 241.18,44.76 241.18,44.07 240.83,43.71 v1(240.83,43.24)
  BOTTOM w0.102: v2(218.16,45.61) 224,45.61 224.1,45.61 225.81,43.9 229.37,43.9 230.75,45.28 232.51,45.28 ; v1(202.18,72.37) 202.21,72.4 R4809.2
FAN1_PWM: length 154.8
  TOP w0.102: C7530.1 226.97,36.41 v1(226.97,36.9) R333.2
  L6 w0.102: v1(100.81,31.65) 101.32,32.16 v1(101.32,38.32)
  BOTTOM w0.102: v1(100.81,31.65) 102.16,31.65 103.98,29.84 156.92,29.84 158.47,31.38 212.17,31.38 213.33,30.22 213.67,30.22 215.04,31.58 219.53,31.58 223.01,35.07 224.43,35.07 225.51,36.15 226.37,36.15 226.97,36.74 v1(226.97,36.9) ; v1(101.32,38.32) 97.28,38.32 91.18,32.22 88.59,32.22 88.24,32.58 Q4300.2
FAN1_PWM_EC: length 17
  TOP w0.076: v1(237.58,41.94) 237.58,41.94 237.9,41.62 U300.G8
  TOP w0.102: v1(227.1,41.16) 227.06,41.16 226.66,40.75 226.51,40.75 225.66,39.9 225.66,39.09 225.76,38.98 225.77,38.98 226.52,38.23 226.64,38.23 R333.1
  BOTTOM w0.076: v1(237.58,41.94) 237.02,41.94 236.45,41.37 232.58,41.37 232.51,41.44
  BOTTOM w0.102: 232.51,41.44 231.93,42.02 231.62,42.02 231.51,42.12 231.12,42.12 227.2,42.12 227.1,42.02 v1(227.1,41.16)
FAN1_PWM_Q: length 3.1
  BOTTOM w0.102: v3(85.04,32.96) 85.46,33.38 R4303.1 86.21,33.38 86.21,33.38 86.52,33.08 Q4300.6 86.99,33.47 86.99,33.69 87.14,33.84 R4302.1
FAN1_PWM_Q_R: length 9.6
  BOTTOM w0.102: R4302.2 86.54,34.6 TP4303.1 85.64,33.71 85.5,33.71 85.23,33.44 84.84,33.44 84.28,32.89 84.28,32 83.84,31.56 D4301.1 83.58,32.08 83.83,32.34 83.83,33.58 84.87,34.63 CN4300.4
FAN2_PWM_EC: length 14.6
  TOP w0.076: v1(236.28,41.94) 236.99,41.94 237.25,41.68 U300.G9
  TOP w0.102: TP308.1 224.86,40.12 v1(225.9,41.16)
  BOTTOM w0.076: v1(236.28,41.94) 232.88,41.94 232.51,42.31
  BOTTOM w0.102: v1(225.9,41.16) 225.9,42 226.53,42.63 229.98,42.63 229.98,42.63 231.33,42.63 231.73,42.63 231.79,42.56 232.25,42.56 232.51,42.31
FN_KEY_LED#: length 211.4
  TOP w0.076: U300.A10 236.6,37.64 236.43,37.47 236.43,37.46 235.45,36.48 234.31,36.48 233.81,35.98 232.84,35.98 232.51,35.65
  TOP w0.102: 232.51,35.65 232.46,35.6 232.26,35.6 232.26,35.6 231.73,35.6 231.07,34.94 v1(230.4,34.94)
  L3 w0.102: v1(99.36,29.42) 99.36,29.55 98.68,30.23 96.78,30.23 96.38,29.82 96.19,29.82 94.5,28.13 94.5,27.98 83.07,16.55 72.62,16.55 71.75,17.41 68.45,17.41 65.98,19.88 65.77,19.88 54.63,19.88 53.72,20.79 48.13,20.79 45.21,17.87 45.21,17.5 v2(45.74,16.96)
  BOTTOM w0.102: v2(45.74,16.96) R389.1 46.25,16.15 R366.1 ; v1(99.36,29.42) 99.36,29.21 99.55,29.01 100.15,29.01 103.33,25.82 135.79,25.82 136.43,25.18 138.35,25.18 138.58,24.94 144.71,24.94 145.36,24.29 173.16,24.29 174.43,25.57 216.82,25.57 221.62,30.37 225.03,30.37 226.42,31.76 227.96,31.76 230.39,34.19 230.39,34.92 v1(230.4,34.94)
FN_KEY_LED#_R: length 4.9
  BOTTOM w0.102: CN300.11 42.82,12.31 42.82,13.63 v3(43.94,14.75) 45.26,16.07 R366.2
FPR_LID_SW#_3: length 20.5
  BOTTOM w0.102: CN2200.1 v3(231.09,7.88) 230.73,7.88 228.25,5.4 221.43,5.4 220.95,5.88 217.12,5.88 R400.1 216.09,5.44 R407.2 214.77,5.44 Q307.6
FPR_LOCK#: length 114.8
  TOP w0.102: v1(234.41,8.63) 234.44,8.59 R2200.1
  L6 w0.102: v1(234.41,8.63) 234.41,8.65 234.92,9.16 236.41,9.16 237.76,10.5 241.49,10.5 242.34,11.35 242.34,19.05 241.91,19.48 241.91,19.79 236.78,24.92 236.78,25.13 236.78,28.2 235.85,29.12 233.76,29.12 233.09,28.46 224.09,28.46 218.86,33.69 218.86,35.03 209.76,44.13 209.76,46.61 209.38,46.99 209.38,57.57 204.8,62.15 204.8,63.03 204.34,63.48 204.34,65.23 202.2,67.37 200.51,67.37 200.51,67.37 199.67,67.37 199.67,67.37 184.75,67.37 v1(183.67,68.45)
  BOTTOM w0.076: U4555.CN14 179.29,68.8 179.59,68.8 179.71,68.76 179.9,68.76 180.01,68.8 180.24,68.8 180.36,68.76 183.36,68.76 v1(183.67,68.45)
  BOTTOM w0.102: CN2200.3 234.25,8.49 234.39,8.63 v1(234.41,8.63)
FPR_OFF#: length 114.7
  TOP w0.102: R4650.2 184.18,43.24 R4533.2 184.2,43.39 184.2,45.18 183.7,45.67 183.48,45.67 183.2,45.95 183.2,47.01 182.95,47.26 182.95,47.64 182.95,47.65 v1(182.92,47.68) 183.38,47.24 183.82,47.24 183.84,47.27 183.85,47.27 184.09,47.51 184.09,47.62 184.1,47.66 184.5,48.06 189.72,48.06 192.32,45.46 v3(192.68,45.46) 192.9,45.68 193.7,45.68 194.49,44.88 195.44,44.88 196.16,44.16 203.81,44.16 204.69,45.05 206.04,45.05 206.11,44.97 210.59,44.97 211.21,44.35 211.37,44.19 211.37,44.19 211.47,44.09 211.57,43.99 211.71,43.85 v1(212.29,43.85)
  L6 w0.102: v1(233.81,8.62) 233.81,8.58 234.19,8.19 235.73,8.19 237.84,10.3 241.58,10.3 242.54,11.26 242.54,19.13 242.11,19.57 242.11,19.88 236.98,25.01 236.98,28.11 236.98,28.28 235.94,29.33 233.67,29.33 233.08,28.73 231.97,28.73 231.71,29 231.71,29.64 230.48,30.88 224.52,30.88 218.7,36.69 218.7,37.75 212.6,43.85 v1(212.29,43.85)
  BOTTOM w0.076: 182.93,48.04 178.88,52.1 176.21,52.1 175.33,52.97 174.65,52.97 173.95,53.67 173.95,54.12 174.11,54.28 174.15,54.32 174.15,54.64 U4555.CC36
  BOTTOM w0.102: v1(182.92,47.68) 182.93,48.04 ; v1(233.81,8.62) 233.75,8.56 CN2200.2
FPR_PWR: length 1.5
  TOP w0.254: C2200.1 236.03,5.67 F2200.2
  vias: v1(236.72,6.95) v1(236.78,6.24) v1(237.33,6.95) v3(237.03,7.56)
FRONT_L_SEL_DB: length 6.3
  TOP w0.102: R9350.2 v2(59.34,110.43) ; MIC9350.3 60.03,115.32 60.03,114.83 59.81,114.6 59.81,114.4 v1(59.4,113.99)
  L3 w0.102: v2(59.34,110.43) 59.34,113.93 v1(59.4,113.99)
FRONT_R_SEL_DB: length 19.9
  TOP w0.102: MIC9352.3 61.07,45.54 v1(61.57,46.05) ; R9352.2 v2(61.24,63.82)
  L6 w0.102: v2(61.24,63.82) 61.04,63.63 61.04,49.17 61.57,48.63 v1(61.57,46.05)
GC6_FB_EN: length 11.4
  BOTTOM w0.076: U4555.CN3 179.32,76.09 179.32,76.39
  BOTTOM w0.089: 180.54,77.26 180.32,77.03 180.32,77.03 180.13,76.84 179.69,76.84 179.32,76.47 179.32,76.39
  BOTTOM w0.102: 180.54,77.26 182.21,78.93 182.21,83.04 181.78,83.47 181.78,83.47 181.38,83.88 181.38,85.17 TP4526.1
GPD7: length 20
  TOP w0.102: R4554.2 179.53,42.51 179.53,45.74 179.16,46.11 179.16,46.66 v2(179.44,46.94)
  BOTTOM w0.076: U4555.BV35 170.97,55 170.98,54.95 170.98,54.78 170.98,54.77 170.92,54.58 170.92,54.55 170.91,54.15 170.91,53.35 171.48,52.78 172.19,52.78 173.81,51.16 174.58,51.16 175.45,50.28 177.53,50.28 179.11,48.7 179.11,47.27 v2(179.44,46.94)
GPIO63: length 4.3
  TOP w0.076: TP309.1 245.13,43.35 244.04,43.35 243.29,42.6 242.12,42.6 U300.J2
GPIOC7: length 11.3
  TOP w0.076: v1(236.28,40.64) U300.F10
  TOP w0.102: v1(235.2,31.82) 235.35,31.66 R378.1 235.79,31.9 235.79,31.9 v3(236.27,32.37)
  L3 w0.102: v1(236.28,40.64) 235.68,40.04 235.68,34.08 235.2,33.59 v1(235.2,31.82)
GPP_A7: length 44.9
  TOP w0.076: 183.28,55.44 183.03,55.44 182.92,55.33 176.18,55.33 174.22,57.29 v1(174.11,57.29)
  TOP w0.102: 183.28,55.44 183.43,55.44 185.15,57.16 186.84,57.16 187.45,57.78 188.13,57.78 188.26,57.91 192,57.91 192.25,58.16 193.92,58.16 195.65,59.88 200.74,59.88 200.87,59.75 211.58,59.75 211.59,59.76 213.1,59.76 v3(213.28,59.93) 213.5,59.93 214.25,60.68 214.26,60.68 214.5,60.92 R4539.2
  BOTTOM w0.089: U4555.CC32 174.09,57.31 v1(174.11,57.29)
GPP_A8: length 29.6
  TOP w0.102: R4537.2 v3(195.53,54.29) 194.87,54.29 194.39,54.77 v1(192.97,54.77)
  L6 w0.076: v1(172.26,58.57) 171.97,58.28 171.97,58.16 171.88,58.08 171.88,57.76 172.11,57.54 172.42,57.54 172.58,57.38 172.82,57.38 173.04,57.15 173.04,56.13 174.72,54.44 176.16,53.01 180.03,53.01
  L6 w0.102: 180.03,53.01 186.5,53.01 186.5,53.01 186.66,53.01 188.74,55.09 190.64,55.09 190.95,54.77 v1(192.97,54.77)
  BOTTOM w0.089: v1(172.26,58.57) U4555.BY30
GPP_A20: length 19.1
  TOP w0.102: v1(180.64,47.55) 180.23,47.14 180.23,46.73 180.03,46.53 180.03,45.44 v3(180.24,45.23) 180.73,44.74 180.73,41.82 R4629.2
  BOTTOM w0.076: U4555.CA37 172.69,54.3 172.69,53.3 174.17,51.82 174.85,51.82 175.73,50.94 178.02,50.94 180.64,48.33 v1(180.64,47.55)
GPP_A21: length 19
  TOP w0.102: v1(180.64,46.91) 180.43,46.71 180.43,46.65 180.23,46.45 180.23,45.92 180.93,45.22 180.93,43.07 R4628.2 181.26,42.06 v3(181.23,42.03)
  BOTTOM w0.076: v1(180.64,46.91) 180.23,47.32 180.23,48.44 177.89,50.78 175.66,50.78 174.78,51.65 174.1,51.65 172.52,53.23 172.52,54.18 172.33,54.38 172.33,54.69 172.59,54.95 U4555.CA36
