# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WWAN_ANTCTL1: length 1.9
  TOP w0.102: TP1412.1 213.26,53.03 v1(213.75,53.53)
  BOTTOM w0.102: v1(213.75,53.53) CN1400.61
WWAN_ANTCTL2: length 2.8
  TOP w0.102: TP1413.1 213.78,54.17 v1(213.75,54.14)
  BOTTOM w0.102: CN1400.63 214.25,53.64 v1(213.75,54.14)
WWAN_ASPM_EXIT: length 52.7
  L3 w0.076: v1(175,59.85) 175.51,60.37 175.51,60.62 175.75,60.85 176.42,60.85 176.59,61.01 177.04,61.01 177.23,60.83 178.92,60.83 179.35,60.4 180.51,60.4
  L3 w0.102: v1(208.51,61.1) 208.02,60.62 199.66,60.62 198.07,62.21 198.04,62.21 198,62.24 195.87,62.24 195.19,61.57 195.19,61.03 194.82,60.66 188.53,60.66 188.01,60.14 181.58,60.14 181.33,60.4 180.51,60.4
  BOTTOM w0.089: v1(175,59.85) U4555.CE28
  BOTTOM w0.102: v1(208.51,61.1) 208.2,61.1 207.67,61.64 207.67,62.71 R4763.2 207.44,64.59 v3(207.62,64.76) 208.51,65.65 209.02,65.65 209.13,65.76 209.13,66.12 209.23,66.22 211.07,66.22 211.17,66.12 211.17,65.45 211.53,65.09 212.03,65.09 212.39,65.45 212.39,65.46 212.78,65.85 215.37,65.85 214.44,64.92 U1401.6
WWAN_CONFIG_0: length 33.6
  TOP w0.076: v1(182.64,62.35) 183.64,63.35 184.76,63.35 R4918.2
  TOP w0.102: v1(199.84,54.38) 200.03,54.54 v3(200.78,54.54) 202.95,54.54 v1(203.24,54.26)
  L5 w0.102: v1(182.64,62.35) 183.05,62.76 184.64,62.76 184.88,62.52 184.88,61.78 186.14,60.52 192.46,60.52 192.7,60.28 192.7,60.28 196.55,56.43 198.96,56.43 200.25,55.14 200.25,54.8 199.84,54.39 v1(199.84,54.38)
  BOTTOM w0.102: v1(203.24,54.26) 203.64,53.85 203.64,53.48 203.75,53.37 CN1400.21 ; v1(182.64,62.35) 182.23,62.76 180.76,62.76 U4555.CR24
WWAN_CONFIG_2: length 62.6
  TOP w0.076: v1(176.82,62.43) 177.03,62.22 177.03,61.28 177.49,60.83 179.66,60.83 v3(179.96,61.13) 180.39,61.57 185.81,61.57 R4915.2
  L3 w0.076: 180.51,61.59 178.59,61.59 178.19,61.99 177.26,61.99 v1(176.82,62.43)
  L3 w0.102: v1(217.45,55.23) 216.56,56.12 216.56,58.84 215.92,59.48 211.77,59.48 208.67,62.57 208.34,62.57 207.77,62.01 207.13,62.01 206.35,61.23 199.91,61.23 198.32,62.82 198.29,62.82 198.26,62.85 195.61,62.85 194.65,61.89 185.08,61.89 184.79,61.59 180.51,61.59
  BOTTOM w0.076: U4555.CH23 v1(176.82,62.43)
  BOTTOM w0.102: v1(217.45,55.23) 217.45,54.83 217.25,54.63 CN1400.75
WWAN_CONFIG_3: length 34
  L3 w0.102: v1(199.23,53.53) 199.64,53.12 200.01,53.12 200.25,53.36 200.25,54.76 200.35,54.87 207.09,54.87 210.48,51.47 217.85,51.47 219.48,49.85 v1(222.42,49.85)
  BOTTOM w0.102: v1(199.23,53.53) 198.85,53.53 198.75,53.42 CN1400.1 198.75,51.33 198.77,51.32 D1400.1 198.26,50.99 R1400.2 ; v1(222.42,49.85) 222.42,50.54 Q1400.G
WWAN_CONFIG_3_PCH: length 84.7
  TOP w0.076: v1(176.24,62.42) 176.87,61.79 176.87,61.22 177.42,60.66 180.5,60.66 180.96,61.13 181.37,61.13 181.65,61.4 185.37,61.4 R4914.2
  L3 w0.076: 180.51,61.39 178.56,61.39 178.12,61.82 176.83,61.82 v1(176.24,62.42)
  L3 w0.102: 180.51,61.39 184.7,61.39 184.87,61.39 185.17,61.69 194.73,61.69 195.7,62.65 198.17,62.65 198.21,62.61 198.24,62.61 199.83,61.03 206.43,61.03 207.22,61.81 208.14,61.81 v1(208.51,62.17)
  L5 w0.102: v1(208.51,62.17) 208.91,61.76 208.91,60.93 208.6,60.63 200.56,60.63 198.94,62.24 195.87,62.24 195.63,62.01 195.63,61.67 198.29,59.01 200.16,59.01 201.9,57.27 205.19,57.27 205.93,56.53 205.93,56.39 204.47,54.93 204.01,54.93 203.65,54.57 203.65,53.33 203.15,52.82 201.84,52.82 200.44,51.42 v2(200.44,50.57)
  BOTTOM w0.076: U4555.CG23 v1(176.24,62.42)
  BOTTOM w0.102: v2(200.44,50.57) 200.52,50.48 D1400.2
WWAN_DET#: length 37.2
  TOP w0.076: v1(238.88,39.99) U300.E6
  TOP w0.102: R4835.2 217.55,51.75 v2(217.55,51.07)
  L6 w0.102: v1(222.98,39.61) 221.71,40.88 221.71,42.84 220.6,43.95 220.6,46.94 220.6,47.34 217.55,50.39 v2(217.55,51.07)
  BOTTOM w0.076: v1(238.88,39.99) 238.79,39.99 238.4,40.38 237.82,40.38 236.84,39.4 235.16,39.4 234.91,39.65 234.68,39.65 233.6,40.73 232.51,40.73
  BOTTOM w0.102: v1(222.98,39.61) 223.62,39.61 223.97,39.97 227.11,39.97 227.89,40.76 228.71,40.76 228.71,40.76 229.66,40.76 229.75,40.85 229.93,40.85 230.49,41.41 230.82,41.41 231.22,41.41 231.78,40.85 232.07,40.85 232.19,40.73 232.51,40.73 ; v2(217.55,51.07) 216.77,50.29 215.85,50.29 215.75,50.4 CN1400.69
WWAN_FWUPD#: length 64.7
  TOP w0.102: R4961.2 195.99,55.18 192.6,55.18 v1(192.57,55.21)
  L3 w0.102: v1(192.57,55.21) 194.31,55.21 195.25,54.27 196.7,54.27 196.72,54.24 196.72,54.24 197.61,53.36 198.05,52.92 200.1,52.92 200.45,53.27 200.45,54.56 200.56,54.66 207.01,54.66 210.47,51.2 215.72,51.2 216.48,50.44 217.85,50.44 218.26,50.03 218.89,49.39 222.65,49.39 222.94,49.68 222.94,49.68 v2(223.11,49.85)
  L6 w0.076: v1(172.26,57.92) 172.27,57.92 172.65,57.54 172.88,57.54 173.2,57.22 173.2,56.2 176.19,53.21 183.18,53.21
  L6 w0.102: v1(192.57,55.21) 190.8,55.21 190.72,55.29 188.66,55.29 186.58,53.21 183.18,53.21
  BOTTOM w0.076: v1(172.26,57.92) 171.88,57.53 U4555.BY32
  BOTTOM w0.102: v2(223.11,49.85) 223.11,50.42 Q1400.S
WWAN_FWUPD#_CONN: length 10.8
  BOTTOM w0.102: CN1400.67 215.25,50.61 215.77,50.09 220.96,50.09 v3(221.26,50.38) 221.52,50.38 Q1400.D 221.69,52.04 C1401.2
WWAN_NC56: length 9.9
  BOTTOM w0.102: C1403.2 218.2,64.33 218.15,64.28 218.01,64.28 217.43,63.69 216.56,63.69 v3(216.02,63.16) 215.9,63.03 215.9,61.73 215.6,61.43 215.18,61.43 214.91,61.7 213.15,61.7 212.5,61.05 CN1400.56
WWAN_NC58: length 9.3
  BOTTOM w0.102: C1404.2 218.87,63.74 v3(218.21,63.74) 217.76,63.74 217.51,63.49 216.64,63.49 216.53,63.38 216.53,62.95 216.1,62.52 216.1,61.64 215.68,61.23 215.09,61.23 214.83,61.5 213.23,61.5 213,61.26 CN1400.58
WWAN_NGFF_DPR: length 4.5
  TOP w0.102: v3(204.77,52.19) 204.75,52.21 R1408.2 204.75,53.23 204.51,53.47 204.51,53.85 v1(204.1,54.26)
  BOTTOM w0.102: v1(204.1,54.26) 204.56,53.8 204.56,53.48 204.75,53.28 CN1400.25
WWAN_OFF#: length 66.5
  TOP w0.076: R349.1 244.47,47.49 v1(243.94,46.95) 243.94,46.88 243.43,46.37 243.43,44.09 242.58,43.25 242.32,43.25 242,43.56 U300.K2
  TOP w0.102: v1(199.92,61.84) 199.93,61.83 R1404.2
  L3 w0.102: v1(199.92,61.84) 200.33,61.43 206.27,61.43 207.05,62.21 207.69,62.21 208.25,62.78 208.59,62.78 208.76,62.78 211.86,59.68 217.35,59.68 217.58,59.45 220.86,59.45 221.14,59.73 223.08,59.73 227.04,55.77 v2(229.49,55.77)
  L5 w0.076: 243.53,48.02 243.58,47.97 243.58,47.31 v1(243.94,46.95)
  L5 w0.102: v1(232.13,58.08) 232.23,57.98 237.07,57.98 243.51,51.54 243.51,49.2 243.35,49.05 243.35,48.2 243.53,48.02
  BOTTOM w0.102: v1(232.13,58.08) 231.72,58.49 229.59,58.49 229.49,58.38 v2(229.49,55.77) ; v1(199.92,61.84) 199.92,61.43 200,61.35 CN1400.6
WWAN_PLT_RST#: length 6.1
  BOTTOM w0.102: CN1400.50 211,60.62 211.89,61.51 212.38,61.51 212.62,61.75 212.62,63.17 212.58,63.21 212.58,63.54 213.14,64.11 U1401.4
WWAN_SSCLK: length 6.7
  TOP w0.102: v1(215.3,56.35) 214.69,55.74 v3(214.63,55.74) 213.96,55.74 R1412.1
  BOTTOM w0.102: v1(215.3,56.35) 214.86,56.35 213.99,57.22 213.99,57.76 215.12,58.89 215.25,58.89 215.5,59.13 CN1400.68
WWAN_TRANSMIT_OFF#: length 33.3
  TOP w0.102: D1410.3 207.7,63.93 v1(207.9,64.12)
  L5 w0.102: v1(207.9,64.12) 207.32,63.55 202.68,63.55 201.6,64.63 201.49,64.63 200.88,65.24 196.69,65.24 195,63.55 194.06,63.55 193.45,64.16 190.95,64.16 v2(190.54,64.57)
  BOTTOM w0.076: U4555.CN22 179.53,64.27 180.07,64.27 180.29,64.41 180.69,64.41 180.91,64.18 181.25,64.18 181.62,64.56 185.58,64.56 185.98,64.16 188,64.16
  BOTTOM w0.102: 188,64.16 190.14,64.16 v2(190.54,64.57) 190.54,65.02 R4766.2
WWAN_TRANSMIT_OFF#_D: length 7.6
  TOP w0.102: v1(200.53,61.84) 200.94,61.43 204.07,61.43 v3(204.57,61.93) D1410.1
  BOTTOM w0.102: CN1400.8 200.5,61.4 200.53,61.43 v1(200.53,61.84)
WWAN_WAKE#: length 73.1
  L6 w0.102: v2(185.37,82.35) 186.18,83.16 194.22,83.16 195.56,81.82 196.28,81.82 196.82,81.27 204.36,81.27 204.75,80.88 206.26,80.88 206.28,80.9 210.47,80.9 212.51,80.9 212.86,80.56 216.62,80.56 216.96,80.9 218.31,80.9 218.74,80.47 218.74,79.23 216.02,76.51 216.02,75.93 216.02,70.75 215.33,70.06 215.06,69.79 215.06,68.59 217.4,66.25 217.4,65.53 217.98,64.94 v1(217.98,64.68)
  BOTTOM w0.076: 185.09,81.97 185.09,74.91 185.41,74.59 186.5,74.59 R4754.2 185.61,73.48 185.57,73.48 185.45,73.36 180.56,73.36 180.43,73.41 U4555.CP7
  BOTTOM w0.102: R1414.1 215.55,63.67 216.24,63.67 216.47,63.9 217.34,63.9 217.8,64.36 217.8,64.51 v1(217.98,64.68) ; 185.09,81.97 185.09,82.07 v2(185.37,82.35)
WWAN_WAKE#_R: length 5.8
  BOTTOM w0.102: CN1400.54 212,60.84 213.06,61.9 215.35,61.9 v3(215.39,61.94) 215.39,62.87 R1414.2
XCLK_BIASREF: length 9.7
  BOTTOM w0.381: U4555.CJ1 177.01,77.16 178.44,78.59 178.83,78.59 180.7,80.46 180.7,81.59 v3(179.93,82.36) 179.93,83.2 179.09,84.04 R4893.1
XDP_CFG<0>: length 7.9
  TOP w0.13: v3(127.4,74.26) 127.65,74.01 127.65,72.62 126.73,71.69 125.38,71.69 R4940.1 124.89,70.35 R4822.2 124.54,70.32 124.34,70.52 124.26,70.52 124.13,70.65 CN4920.45
XDP_CFG<3>: length 3.3
  TOP w0.13: CN4920.1 124.5,59.64 124.65,59.8 R4823.2 125.5,60.6 R4932.2
XDP_DBRESET#: length 271
  TOP w0.102: CN4920.48 116.24,71.15 114.8,72.58 114.8,72.91 R4922.2 114.13,73.79 113.08,74.84 v1(113.08,74.92)
  L3 w0.102: v1(259,49.34) 258.29,49.34 257.71,48.76 257.27,48.76 256.3,47.78 254.08,47.78 252.25,49.6 249.77,49.6 248.82,50.55 246.64,50.55 242.4,54.79 238.38,54.79 237.78,55.39 237.78,55.39 237.26,55.91 233.49,55.91 232.57,56.82 228.32,56.82 225.77,59.37 225.21,59.37 224.69,59.89 224.16,59.89 222.87,61.18 221.89,61.18 219.62,63.45 219.46,63.45 219.25,63.67 215.63,63.67 215.08,64.21 210.52,64.21 206.57,68.16 206.57,70.18 205.93,70.83 204.41,70.83 202.61,69.03 187.16,69.03 185.45,70.74 184.64,70.74 v1(184.3,71.08)
  L5 w0.102: v1(184.3,71.08) 188.52,71.08 188.87,70.73 192.11,70.73 192.35,70.96 192.35,71.39 193.72,72.76 193.72,82.64 192.55,83.81 192.55,101.47 191.93,102.09 191.93,104.33 189.28,106.97 182,106.97 181.75,107.22 155.52,107.22 154.4,108.35 147.66,108.35 146.17,106.86 146.17,100.56 145.96,100.34 128.67,100.34 124.84,104.18 124.17,104.18 124.17,104.18 123.5,104.18 120.53,107.15 113.94,107.15 111.88,105.09 111.88,103.24 112.69,102.44 112.69,100.84 115.75,97.79 116.68,96.85 116.68,87.19 113.99,84.49 113.99,75.83 v1(113.08,74.92)
  BOTTOM w0.076: U4555.CN10 179.29,71.32 179.59,71.32 179.71,71.28 179.9,71.28 180.01,71.32 180.24,71.32 180.37,71.28 182.39,71.28 182.96,70.7 183.92,70.7 v1(184.3,71.08)
  BOTTOM w0.102: CN4941.13 260.12,48.23 v1(259,49.34)
XDP_PRSNT: length 21.7
  TOP w0.102: U4921.6 100.24,37.97 101.02,37.19 103.05,37.19 103.8,37.93 U4920.6 104.89,38.21 106.28,36.82 106.62,36.82 107.84,38.04 111.01,38.04 111.88,38.91 111.88,40.04 Q4921.D R4925.2
XDP_PRSNT#: length 48.2
  TOP w0.102: CN4920.60 117.35,75.83 v1(117.35,75.83) ; v1(106.96,41.7) 106.96,41.94 106.5,42.39 106.5,42.84 106.78,43.11 R4924.1 R4934.2 105.67,43.89 D4920.3
  L5 w0.102: v1(106.96,41.7) 110.31,45.05 111.53,45.05 111.63,45.15 111.63,46.88 113.1,48.35 113.1,61.3 114.35,62.55 116.29,62.55 117.67,63.93 117.67,75.51 v1(117.35,75.83)
  BOTTOM w0.102: v1(117.35,75.83) 116.79,75.83 TP4517.1
XDP_PRSNT#_D: length 242.9
  TOP w0.13: v1(111.48,39.08) 110.6,39.95 108,39.95 106.54,41.42 106.54,41.83 106.17,42.21 104.39,42.21 D4920.1 ; R4929.1 193,41.42 193.19,41.23 206.64,41.23 207.37,41.95 207.95,41.95 208.13,42.14 209.83,42.14 209.87,42.09 210.65,41.31 213.61,41.31 v1(213.86,41.57)
  L3 w0.097: v1(111.48,39.08) 111.48,35.13 100.11,23.76 99.54,23.76 99.12,23.34 99.12,14.29 101.31,12.1 113.12,12.1 113.14,12.12 145.15,12.12 145.52,11.75 150.71,11.75 151.06,12.1 166.82,12.1 167.37,11.55 171.36,11.55 171.37,11.56 197.23,11.56 197.26,11.53 233.74,11.53 235.8,13.6 235.8,16.04 237.01,17.25 237.01,18.48 237.02,18.49 237.02,20 233.84,23.17 233.17,23.17 230.73,25.61 230.73,26.86 228.64,28.96 228.01,29.58 228.01,30.14 227.49,30.67 226.61,30.67 226.16,31.11 226.16,31.64 225.29,32.51 225.29,33.01 224.7,33.6 224.2,33.6 221.38,36.42 220.15,36.42 215,41.57 v1(213.86,41.57)
XDP_PRSNT#_R: length 0.8
  TOP w0.102: Q4921.G 107.39,42.62 R4924.2
XDP_TRST#: length 11.8
  TOP w0.13: R4613.2 114.58,80.96 114.26,80.96 113.61,80.3 113.61,77.41 v3(114.55,76.47) 115.21,75.81 115.21,73.66 116.22,72.65 CN4920.54
XTAL24_IN: length 2.8
  BOTTOM w0.13: X4751.3 189.65,74.21 C4828.1 188.5,75.37 R4898.2 188.03,75.38 L4555.2
XTAL24_IN_PCH: length 11.2
  L6 w0.127: v2(186.35,75.41) 186.02,75.41 184.3,77.13 181,77.13 180,76.13 177.76,76.13 v1(177.48,75.84)
  BOTTOM w0.13: U4555.CK3 177.96,75.75 177.55,75.75 177.48,75.82 v1(177.48,75.84) ; v2(186.35,75.41) 186.38,75.38 L4555.1
XTAL24_OUT: length 4.5
  BOTTOM w0.13: L4555.3 188.03,75.86 R4898.1 188.05,75.88 C4826.1 188.99,75.52 190.5,75.52 X4751.1
XTAL24_OUT_PCH: length 11.2
  L6 w0.127: v2(177.42,76.76) 179.73,76.76 180.74,77.77 184.65,77.77 v1(186.35,76.07)
  BOTTOM w0.13: v2(177.42,76.76) 177.69,76.49 U4555.CK2 ; v1(186.35,76.07) 186.51,75.86 L4555.4
XTAL_SELECT: length 10.4
  TOP w0.076: v1(174.99,61.49) 175.46,61.02 176.83,61.02 177.35,60.5 180.98,60.5 v3(181.15,60.67) 181.72,61.24 183.89,61.24 R4550.2
  BOTTOM w0.076: U4555.CF25 175.25,61.75 v1(174.99,61.49)

## Copper pours and planes (outline as drawn)
AGND_AUDIO on BOTTOM: 2.56,46.04 2.56,44.77 2.82,44.77 3.71,45.66 4.59,45.66 5.1,45.15 5.1,44.64 5.61,44.64 6.12,45.15 6.12,46.93 5.99,47.06 3.58,47.06
AGND_AUDIO on L2: 28.36,42.5 28.36,47.04 2.58,47.04 2.58,43.37 5.36,43.37 5.36,44.39 5.61,44.64 14.63,44.64 14.91,44.37 14.91,43.45 16.71,41.65 17.89,41.65 18.2,41.33 19.6,41.33 19.6,42.9 24.5,42.9 24.5,40.96 28.22,40.96 28.22,42.36
AGND_AUDIO on L4, L6: 28.36,42.48 28.36,47.04 2.58,47.04 2.58,43.37 5.36,43.37 5.36,44.39 5.61,44.64 14.63,44.64 14.91,44.37 14.91,43.47 16.74,41.65 17.89,41.65 18.2,41.33 19.6,41.33 19.6,42.9 24.5,42.9 24.5,40.96 28.22,40.96 28.22,42.34
AGND_AUDIO on L7: 2.58,47.04 2.58,43.37 5.36,43.37 5.36,44.39 5.61,44.64 5.97,44.64 6.06,44.73 6.06,47.02 6.04,47.04
AGND_KBC on TOP: 250.21,39.56 250.21,38.93 250.09,38.8 249.32,38.8 249.09,39.03 249.09,40.86 249.2,40.96 249.58,40.96 249.7,40.83 249.7,39.94 250.09,39.56
AGND_USB on L2, L4: 33.55,70.55 33.55,72.71 32.03,72.71 31.65,72.33 31.65,67.25 32.03,66.87 32.03,64.33 29.23,61.53 17.68,61.53 17.68,74.61 36.47,74.61 36.47,70.55
AGND_USB on L6: 31.65,71.21 31.65,67.25 32.03,66.87 32.03,64.33 29.23,61.53 17.68,61.53 17.68,74.61 36.58,74.61 36.58,72.2 36.07,71.69 32.12,71.69
AGND_USB on L7: 33.55,70.55 33.55,74.61 36.47,74.61 36.47,70.55
DGND on TOP (solid shape): 281.77,54.9 277.06,54.9 277.06,57.5 281.77,57.5
DGND on TOP (solid shape): 288.22,75.76 287.68,75.76 287.68,82.87 288.22,82.87
DGND on TOP (solid shape): 288.22,60.14 287.68,60.14 287.68,67.25 288.22,67.25
DGND on TOP (solid shape): 265.22,39.03 265.22,38.32 264.97,38.06 263.88,38.06 263.62,38.32 263.62,39.03 263.88,39.28 264.97,39.28
DGND on TOP (solid shape): 73.05,9.21 73.05,7.18 71.65,5.78 71.65,4 64.41,4 64.41,9.97 66.44,12 70.25,12
DGND on TOP (solid shape): 3.21,35.52 4.22,35.52 4.33,35.41 5.2,35.41 5.31,35.52 6.35,35.52 6.35,35.01 1.72,35.01 1.72,35.52 3.21,35.52
DGND on TOP (solid shape): 35.25,43.96 35.58,43.63 35.58,39.05 33.55,37.02 30.5,37.02 28.57,38.95 28.57,38.97 28.53,39.07 28.47,39.17 28.47,41.98 30.63,44.13 35.02,44.13
DGND on TOP (solid shape): 8.72,30.52 9.57,30.52 9.57,30.01 8.7,30.01 8.35,30.15 8.21,30.5 8.21,31.62 8.72,31.62
DGND on TOP (solid shape): 279.93,59.76 279.93,59.25 280.57,58.61 284.38,58.61 286.03,60.26 288.22,60.26 288.22,55.65 287.85,55.46 287.55,55.18 275.87,55.18 273.96,57.09 273.96,59.5 275.74,61.28 278.41,61.28
DGND on TOP (solid shape): 172.04,0.71 170.99,0.71 170.7,0.68 170.43,0.6 170.29,0.54 170.2,0.52 170.1,0.51 161.69,0.51 161.59,0.52 161.5,0.54 161.36,0.6 161.09,0.68 160.8,0.71 160.02,0.71 160.02,0.98 172.04,0.98
DGND on TOP (solid shape): 2.31,46.48 1.22,46.48 1.22,35.52 1.85,35.52 1.85,35.01 1.2,35.01 0.85,35.15 0.71,35.5 0.71,46.5 0.85,46.85 1.2,46.99 2.31,46.99
DGND on TOP (solid shape): 194.1,2.99 218.06,2.99 218.09,3.02 233.19,3.02 233.22,2.99 237.24,2.99 237.27,3.02 241.37,3.02 241.37,2.51 192,2.51 191.52,2.43 191.1,2.21 190.93,2.38 190.93,2.71 191,2.75 191.07,2.79 191.52,2.96 192,3.02 194.07,3.02
DGND on TOP (solid shape): 19.02,7.87 19.41,7.22 19.71,6.52 21.15,6.52 21.15,6.01 19.7,6.01 19.41,6.1 19.23,6.34 18.96,6.98 18.6,7.58 18.53,7.71 18.51,7.86 18.51,8.34 19.02,8.34
DGND on TOP (solid shape): 219.85,117.92 220.21,117.76 220.36,117.4 220.36,112.09 220.79,111.04 221.85,110.61 221.96,110.61 221.97,110.61 221.97,110.08 221.8,109.92 216.56,109.92 214.4,112.08 214.4,117.92
DGND on TOP (solid shape): 103.53,63.57 103.53,60.64 101.37,58.49 97.07,58.49 94.72,58.49 94.64,58.53 94.63,58.61 95.85,61.62 95.93,63.7 94.68,65.35 94.64,65.42 94.66,65.5 94.89,65.72 101.37,65.72
DGND on TOP (solid shape): 6.7,35.52 8.13,34.93 8.72,33.5 8.72,30.95 8.21,30.95 8.21,33.5 7.77,34.57 6.7,35.01 3.86,35.01 3.86,35.52
DGND on TOP (solid shape): 231,110.59 232.76,109.86 233.49,108.09 233.49,106.71 232.98,106.71 232.98,108.09 232.4,109.5 231,110.08 221.36,110.08 221.36,110.59
DGND on TOP (solid shape): 288.22,67.12 286.03,67.12 284.38,68.77 283.36,68.77 283.23,68.9 280.57,68.9 280.18,68.52 277.77,68.52 276.86,69.43 276.83,69.5 276.87,69.57 277.34,71.15 275.96,72.06 275.89,72.08 275.87,72.15 275.87,72.71 277.77,74.61 280.06,74.61 280.44,74.23 284.25,74.23 285.9,75.88 288.22,75.88
DGND on TOP (solid shape): 192.38,2.51 192,2.51 191.22,2.29 190.67,1.71 189.85,1.41 189.34,0.71 188.49,0.71 188.49,1.22 189.02,1.22 189.59,1.84 190.36,2.18 191.08,2.79 192,3.02 192.38,3.02
DGND on TOP (solid shape): 282.31,114.22 282.41,114.21 282.5,114.18 282.64,114.12 282.91,114.04 283.19,114.02 284.76,114.02 284.76,106.21 279.91,106.21 279.05,106.71 278.19,106.2 271.5,106.2 274.48,108.84 274.85,109.34 274.98,109.95 274.98,113.7 275.13,114.07 275.5,114.22
DGND on TOP (solid shape): 187,8.2 189.47,7.18 190.5,4.7 190.5,1.67 190.29,1.61 190.12,1.54 190.01,1.49 189.86,1.39 189.71,1.26 189.58,1.11 189.48,0.95 189.4,0.83 189.36,0.68 175.62,0.68 175.62,4.7 176.64,7.18 179.12,8.2
DGND on TOP (solid shape): 274.69,108.31 265.96,100.59 265.34,100.22 264.62,100.08 257.76,100.08 257.68,100.17 256.66,100.17 256.58,100.08 235,100.08 233.57,100.68 232.98,102.1 232.98,107.91 233.49,107.91 233.49,102.1 233.93,101.03 235,100.59 264.62,100.59 265.16,100.69 265.62,100.97 274.33,108.67
DGND on TOP (solid shape): 150,3.02 151.35,2.5 152,1.22 175.79,1.22 175.79,0.71 151.51,0.71 151.51,1 151.07,2.07 150,2.51 134,2.51 132.93,2.07 132.49,1 132.49,0.71 126.9,0.71 126.9,1.22 132,1.22 132.65,2.5 134,3.02
DGND on TOP (solid shape): 252,8.2 254.48,7.17 255.5,4.7 255.5,3.29 254.73,3.29 254.73,4.7 253.93,6.63 252,7.43 244.11,7.43 242.18,6.63 241.38,4.7 241.38,2.48 240.62,2.48 240.62,4.7 241.64,7.18 244.12,8.2
DGND on TOP (solid shape): 273.61,31.71 272,31.71 271.08,31.39 270.54,30.58 270.5,30.39 270.49,30.2 270.49,9 270.35,8.65 270,8.51 269.92,8.51 269.9,8.48 266.7,8.48 264.93,8.07 263.52,6.9 262.92,5.77 262.72,4.5 262.72,0.68 259.53,0.68 259.53,1.22 259.86,1.22 261.98,1.22 261.98,4.5 263.31,7.69 266.5,9.02 269.98,9.02 269.98,10.42 269.98,10.42 269.98,26.06 269.98,30.18 270.57,31.62 272,32.22 273.61,32.22
DGND on TOP (solid shape): outline of 171 points within 275.36,82.74 288.22,91.38
DGND on TOP (solid shape): 19.02,24.9 18.94,24.83 18.94,19.64 19.02,19.57 19.02,18.99 18.94,18.99 18.94,12.89 19.02,12.89 19.02,8.5 19.6,7.1 21,6.52 51.5,6.52 52.92,5.93 53.52,4.52 71.48,4.52 71.48,5.3 72.07,6.73 73.5,7.32 82.57,7.32 82.57,7.3 100.23,7.3 101.5,6.64 102.02,5.3 102.02,3.02 111,3.02 111.5,3.02 112.7,2.62 113.43,1.58 113.43,0.71 113.01,0.71 113.01,1 112.57,2.07 111.5,2.51 111,2.51 101.51,2.51 101.51,5.3 101.07,6.37 100,6.81 73.5,6.81 72.43,6.37 71.99,5.3 71.99,4.01 53.01,4.01 53.01,4.5 52.57,5.57 51.5,6.01 21.1,6.01 21.1,5.98 19.69,5.98 19.61,5.99 19.57,6 19.49,6.03 19.41,6.07 19.36,6.12 19.3,6.17 19.27,6.22 19.21,6.33 19.15,6.48 19.09,6.64 18.86,7.11 18.53,7.65 18.52,7.68 18.5,7.74 18.49,7.8 18.48,7.87 18.48,8.83 18.51,8.83 18.51,28.13 19.02,28.13
DGND on TOP (solid shape): outline of 206 points within 93.99,71.43 102.44,84.43
DGND on TOP (solid shape): 102.59,114.68 98.12,115.22 100.28,16.74 93.8,115.22 31.46,46.48 60.45,36.35 87.03,51.71 89.27,52.44 92.61,54.42 94.81,57.63 96.29,61.28 96.29,63.33 96.52,63.56 95.75,65.11 94.34,66.13 93.25,66.57 93.5,68.18 93.68,69.81 100.72,74.38 103.21,81.14 97.44,85.44 93.82,85.44 93.82,109.92 100.1,109.92 101.62,111.44 102.59,112.28
DGND on TOP (solid shape): outline of 144 points within 93.8,16.74 216.64,117.89
DGND on BOTTOM (solid shape): 19.02,12.61 18.51,12.61 18.51,16.07 19.02,16.07
DGND on BOTTOM (solid shape): 48.54,33.85 45.49,33.85 45.49,36.9 48.54,36.9
DGND on BOTTOM (solid shape): 53.82,15.48 50.77,15.48 50.77,18.53 53.82,18.53
DGND on BOTTOM (solid shape): 61.03,15.41 60.25,15.41 60.25,17.49 61.03,17.49
DGND on BOTTOM (solid shape): 200.94,62.3 195.98,62.3 195.98,63.82 200.94,63.82
DGND on BOTTOM (solid shape): 208.94,88.2 205.89,88.2 205.89,91.25 208.94,91.25
DGND on BOTTOM (solid shape): 223.39,61.48 220.34,61.48 220.34,64.53 223.39,64.53
DGND on BOTTOM (solid shape): 95.6,111.6 97.3,111.6 97.3,109.35 93.35,109.35 93.35,114.6 95.6,114.6
DGND on BOTTOM (solid shape): 128.98,47.4 90.8,47.4 90.8,33.01 89.2,33.01 89.2,49 128.98,49
DGND on BOTTOM (solid shape): 262.71,0.7 259.53,0.7 259.53,1.22 261.98,1.22 261.98,3.49 262.71,3.49
DGND on BOTTOM (solid shape): 119.66,94.43 119.66,94.17 119.15,93.66 119.02,93.66 117.24,95.44 117.24,95.57 117.75,96.08 118.01,96.08
DGND on BOTTOM (solid shape): 245.7,10.5 269.08,10.5 269.08,58.23 270.51,58.23 270.51,9.1 244.3,9.1 244.3,92.29 245.7,92.29
DGND on BOTTOM (solid shape): 73.05,7.94 73.05,7.18 71.65,5.78 71.65,4.03 64.92,4.03 64.92,9.84 66.7,11.62 69.36,11.62
DGND on BOTTOM (solid shape): 123.09,88.71 123.09,87.82 122.58,87.31 120.16,87.31 119.66,87.82 119.66,90.62 119.15,91.12 119.15,91.38 119.66,91.89 119.91,91.89
DGND on BOTTOM (solid shape): 243.5,9 89.24,9 89.24,16.07 90.9,16.07 90.9,10.6 241.9,10.6 241.9,47.4 197.15,47.4 197.15,49 243.5,49
DGND on BOTTOM (solid shape): 181,101.79 181,99.76 179.22,97.98 179.22,96.89 179.07,96.74 178.74,96.74 178.74,97.32 178.46,97.6 178.46,101.41 178.97,101.92 180.87,101.92
DGND on BOTTOM (solid shape): 270.53,70.83 269.08,70.83 269.08,96.8 245.72,96.8 245.72,92.01 244.29,92.01 244.29,96.89 245.13,97.73 252.63,97.73 253.1,98.2 270.53,98.2
DGND on BOTTOM (solid shape): 102.77,56.33 102.77,55.34 102.89,55.21 104.06,55.21 104.19,55.08 104.19,54.73 103.43,54.73 103.22,54.52 99.51,54.52 99.39,54.65 99.39,56.45 99.51,56.58 102.51,56.58
DGND on BOTTOM (solid shape): 156.11,8.19 156.11,7.43 156.49,7.05 158.26,7.05 158.39,6.92 158.39,6.54 157.76,6.54 157.63,6.42 151.66,6.42 151.53,6.54 151.53,8.07 151.79,8.32 155.98,8.32
DGND on BOTTOM (solid shape): 117.91,102.84 117.91,102.48 116.65,101.22 116.65,100.77 117.81,99.6 117.81,99.06 116.29,97.53 115.57,97.53 112.42,100.69 112.42,101.51 113.15,102.25 113.15,103.09 109.75,106.49 109.75,107.38 111.4,109.03 111.72,109.03
DGND on BOTTOM (solid shape): 35.3,43.92 35.58,43.71 35.58,39.05 33.55,37.02 30.5,37.02 28.57,38.95 28.57,38.97 28.53,39.07 28.47,39.17 28.47,41.98 30.63,44.13 35.02,44.13
DGND on BOTTOM (solid shape): 106.45,105.09 106.45,103.8 106.83,103.42 106.83,103.11 106.45,102.73 106.45,102.66 107.03,102.07 107.29,102.07 107.57,102.35 107.82,102.35 108.56,101.61 108.56,101.16 109.04,100.67 108.84,100.47 108.35,100.95 107.69,100.95 102.77,105.88 102.77,106.11 103.65,107 104.54,107
DGND on BOTTOM (solid shape): 123.92,106.16 124.4,106.16 126.99,103.57 127.49,103.57 128.58,102.49 128.58,102.13 127.31,100.87 127.31,100.42 128.48,99.25 128.48,98.71 127.25,97.47 126.51,97.47 123.85,100.14 123.85,100.17 123.36,100.65 123.36,101.26 123.85,101.74 123.85,102.68 120.16,106.36 120.16,106.62 121.69,108.14 121.94,108.14
DGND on BOTTOM (solid shape): 278.85,60.71 278.85,60.71 279.93,59.63 279.93,59.25 280.57,58.61 284.38,58.61 286.03,60.26 288.22,60.26 288.22,55.65 287.85,55.46 287.55,55.18 275.87,55.18 273.96,57.09 273.96,59.5 275.74,61.28 278.27,61.28
DGND on BOTTOM (solid shape): 166.9,107.76 166.9,103.32 166.21,102.63 166.21,102.36 166.21,102.36 166.21,101.62 166.21,101.49 166.37,101.34 166.82,101.34 166.95,101.21 166.95,100.19 166.65,99.89 166.65,99.07 166.34,99.07 166.34,99.92 166.19,100.07 165.88,100.07 165.88,102.35 165.61,102.63 165.61,103.07 165.3,103.37 161.9,103.37 160.93,104.33 160.93,107.76 161.06,107.89 166.77,107.89
DGND on BOTTOM (solid shape): 172.04,0.71 170.99,0.71 170.7,0.68 170.43,0.6 170.29,0.54 170.2,0.52 170.1,0.51 161.69,0.51 161.59,0.52 161.5,0.54 161.36,0.6 161.09,0.68 160.8,0.71 160.02,0.71 160.02,0.98 172.04,0.98
DGND on BOTTOM (solid shape): 18.95,7.74 19.14,7.74 19.14,7.69 19.14,7.69 19.79,7.69 19.79,7.59 22.31,7.59 22.31,7.69 22.96,7.69 22.96,7.74 23.85,7.74 23.85,5.98 19.68,5.98 19.59,6 19.48,6.03 19.41,6.07 19.36,6.11 19.33,6.14 19.29,6.19 19.25,6.24 19.22,6.31 18.95,6.96 18.58,7.56 18.54,7.66 18.54,7.74 18.95,7.74
DGND on BOTTOM (solid shape): 268.61,8.48 267.29,8.48 266.7,8.48 266.08,8.43 265.47,8.29 264.39,7.75 263.52,6.9 263.38,6.69 263.24,6.48 263.24,8.85 268.61,8.85
DGND on BOTTOM (solid shape): 257.4,3.29 254.73,3.29 254.73,4.7 253.93,6.63 252,7.43 250.25,7.43 250.25,8.85 257.4,8.85
DGND on BOTTOM (solid shape): 19.02,7.87 19.41,7.22 19.71,6.52 21.15,6.52 21.15,6.01 19.7,6.01 19.41,6.1 19.23,6.34 18.96,6.98 18.6,7.58 18.53,7.71 18.51,7.86 18.51,8.24 19.02,8.24
DGND on BOTTOM (solid shape): 103.53,63.57 103.53,60.64 101.5,58.61 94.77,58.61 94.69,58.65 94.68,58.74 95.85,61.62 95.97,63.57 94.89,65.2 94.89,65.6 101.5,65.6
DGND on BOTTOM (solid shape): 219.85,117.92 220.21,117.76 220.36,117.4 220.36,112.09 220.79,111.04 221.85,110.61 221.96,110.61 221.97,110.61 221.97,110.08 221.8,109.92 216.56,109.92 214.4,112.08 214.4,117.92
DGND on BOTTOM (solid shape): 273.61,31.71 272,31.71 270.93,31.27 270.49,30.2 270.49,9.55 269.98,9.55 269.98,30.2 270.57,31.63 272,32.22 273.61,32.22
DGND on BOTTOM (solid shape): 231,110.59 232.76,109.86 233.49,108.09 233.49,106.71 232.98,106.71 232.98,108.09 232.4,109.5 231,110.08 228.57,110.08 228.57,110.59
DGND on BOTTOM (solid shape): 192.38,2.51 192,2.51 191.22,2.29 190.67,1.71 189.85,1.41 189.34,0.71 188.22,0.71 188.22,1.22 189.02,1.22 189.59,1.84 190.36,2.18 190.74,2.58 191.22,2.86 192.38,2.86
DGND on BOTTOM (solid shape): 270.49,9 270.35,8.65 270,8.51 266.7,8.51 264.96,8.11 263.56,6.99 263.38,6.99 263.27,7.1 263.27,7.44 264.81,8.6 266.7,9.02 269.98,9.02 269.98,9.74 270.49,9.74
DGND on BOTTOM (solid shape): 288.22,67.12 286.03,67.12 284.38,68.77 283.36,68.77 283.23,68.9 280.57,68.9 280.18,68.52 277.77,68.52 276.86,69.43 276.83,69.5 276.86,69.57 277.34,71.15 275.96,72.06 275.89,72.08 275.87,72.15 275.87,72.71 277.77,74.61 280.06,74.61 280.44,74.23 284.25,74.23 285.9,75.88 288.22,75.88
DGND on BOTTOM (solid shape): 176.59,117.6 176.93,116.65 177.79,116.12 177.79,116.1 177.86,115.65 178.07,115.23 177.48,115.23 177.38,115.48 177.32,115.74 176.48,116.4 176.1,117.38 173.93,117.38 173.93,117.37 173.37,117.37 173.48,117.62 173.54,117.89 176.59,117.89
DGND on BOTTOM (solid shape): 187,8.2 189.47,7.18 190.5,4.7 190.5,1.84 190.11,1.84 188.95,0.68 175.62,0.68 175.62,4.7 176.64,7.18 179.12,8.2
DGND on BOTTOM (solid shape): 274.7,108.32 265.96,100.59 265.34,100.22 264.62,100.08 235,100.08 233.57,100.68 232.98,102.1 232.98,107.2 233.49,107.2 233.49,102.1 233.93,101.03 235,100.59 264.62,100.59 265.16,100.69 265.62,100.97 274.34,108.68
DGND on BOTTOM (solid shape): 188.33,9 190.62,7.37 191.5,4.7 191.5,2.4 191.02,2.12 190.67,1.71 190.06,1.61 189.53,1.18 189.34,0.71 174.62,0.68 174.62,4.7 174.72,5.64 175.01,6.55 175.03,6.56 175.03,6.58 176.15,8.09 177.79,9
DGND on BOTTOM (solid shape): 125.33,9 127.56,7.46 128.49,4.92 128.49,3.69 128.5,3.69 128.5,0.68 112.98,0.68 112.98,1 112.6,1.99 111.66,2.47 111.62,2.48 111.62,4.7 112.49,7.37 114.79,9
DGND on BOTTOM (solid shape): 2.31,46.48 1.22,46.48 1.22,35.52 1.77,35.52 3.23,35.52 3.34,35.41 4.13,35.41 4.24,35.52 6.7,35.52 7.73,35.23 8.48,34.46 8.48,33.97 8.66,33.97 8.7,33.74 8.72,33.5 8.72,31.41 8.72,31.41 8.72,30.52 9.67,30.52 9.67,30.01 8.7,30.01 8.35,30.15 8.21,30.5 8.21,31.62 8.21,31.62 8.21,33.5 7.77,34.57 6.7,35.01 1.85,35.01 1.2,35.01 0.85,35.15 0.71,35.5 0.71,46.5 0.85,46.85 1.2,46.99 2.31,46.99
DGND on BOTTOM (solid shape): 9.67,46.99 86.72,52.14 60.38,36.85 31.67,46.99 98.12,115.22 100.28,16.74 93.8,115.22 31.46,46.48 60.45,36.35 87.03,51.71 17.99,46.48 17.55,46.04 17.04,46.04 16.59,46.48 9.67,46.48
DGND on BOTTOM (solid shape): 150.46,117.85 150.97,116.95 151.95,116.59 152.05,116.59 153.03,116.95 153.54,117.85 153.54,117.89 170.46,117.89 170.46,117.85 170.51,117.67 170.57,117.49 170.56,117.4 170.49,117.36 170.07,117.36 170.07,117.38 158.91,117.38 158.75,117.54 158.16,117.54 158,117.38 153.93,117.38 153.19,116.44 152.05,116.08 151.95,116.08 150.81,116.44 150.07,117.38 149.38,117.38 149.35,117.41 145.97,117.41 145.94,117.38 141.52,117.38 141.52,116.7 141.5,116.42 141.44,116.14 141.03,116.14 140.96,116.18 140.94,116.26 140.99,116.48 141.01,116.7 141.01,117.89 150.46,117.89
DGND on BOTTOM (solid shape): 252,8.9 254.48,8.09 256,5.98 256,3.29 254.73,3.29 254.73,4.7 253.93,6.63 252,7.43 244.11,7.43 242.18,6.63 241.38,4.7 241.38,2.48 239.92,2.48 239.92,4.7 241.15,7.67 244.12,8.9
DGND on BOTTOM (solid shape): outline of 167 points within 274.98,82.74 288.22,91.38
DGND on BOTTOM (solid shape): outline of 224 points within 205,104.85 211,110.85
DGND on BOTTOM (solid shape): 116.59,117.89 118.1,114.59 117.03,115.03 116.59,116.1 121.61,116.1 121.17,115.03 120.1,114.59 121.61,117.89 126.59,117.89 128.1,115.19 127.03,115.63 126.59,116.7 139.59,115.1 139.57,115.17 139.5,115.19 139.5,114.68 139.59,114.69 126.08,116.7 126.67,115.27 128.1,114.68 126.08,117.38 122.12,117.38 120.1,114.08 121.53,114.67 122.12,116.1 116.08,116.1 116.67,114.67 118.1,114.08 116.08,117.38 112.05,116.08 113.19,116.44 113.93,117.38 108.6,114.68 109.79,115.07 110.52,116.08 104.51,114.76 104.72,114.74 104.93,114.68 103.58,114.68 103.78,114.74 104,114.76 98.12,115.22 100.28,16.74 93.8,115.22 101.62,115.22 101.62,115.19 110.1,116.55 109.61,115.58 108.6,115.19 110.11,116.59 113.54,117.85 113.02,116.95 112.05,116.59 113.54,117.89
DGND on BOTTOM (solid shape): outline of 205 points within 93.95,71.43 102.51,84.5
DGND on BOTTOM (solid shape): outline of 115 points within 19.63,0.71 240.31,7.32
DGND on BOTTOM (solid shape): 101.62,114.68 98.12,115.22 100.28,16.74 93.8,115.22 31.46,46.48 60.45,36.35 87.03,51.71 89.27,52.44 92.61,54.42 94.81,57.63 96.16,60.97 96.16,63.06 96.54,63.44 95.79,65.06 94.34,66.13 93.25,66.57 93.5,68.18 93.68,69.81 100.72,74.38 103.21,81.14 97.44,85.44 93.82,85.44 93.82,109.92 99.46,109.92 101.62,112.08
DGND on L4 (solid shape): outline of 206 points within 93.99,71.43 102.44,84.43
DGND on TOP: 266.09,46.93 267.87,46.93 267.99,46.8 267.99,46.14 267,45.15 267,44.67 266.47,44.13 266.47,43.25 266.21,42.99 263.8,42.99 263.67,43.12 263.67,47.44 263.17,47.94 262.66,47.94 262.53,48.07 262.53,48.71 262.66,48.83 264.18,48.83
DGND on TOP: 123.19,90.59 123.19,89.24 123.62,88.81 147.37,88.81 147.44,88.89 147.44,89.68 147.34,89.78 142.44,89.78 141.47,90.74 123.34,90.74
DGND on TOP: 265.07,90.24 264.94,90.11 264.18,90.11 263.8,90.49 263.8,95.82 264.06,96.08 264.94,96.08 265.07,95.95
DGND on TOP: 13.1,33.59 11.2,33.59 10.82,33.21 10.18,33.21 9.93,32.96 9.93,29.91 13.1,29.91
DGND on TOP: 269.24,104.21 274.48,108.84 274.85,109.34 274.98,109.95 274.98,114.33 276.76,114.33 276.76,114.49 284.63,114.49 284.63,109.41 288.69,109.41 288.69,104.21
DGND on TOP: 166.39,64.79 166.39,66.41 166.47,66.41 166.48,66.34 166.56,66.22 166.68,66.18 166.98,66.18 167.01,66.18 167.07,66.2 167.39,65.88 167.39,65 167.18,64.79
DGND on TOP: 140.41,66.52 140.41,68.82 146.11,68.82 147.47,67.47 147.47,66.61 147.37,66.52
DGND on TOP: 250.97,40.71 250.09,40.71 249.96,40.58 249.96,40.2 250.47,39.69 250.47,38.93 250.59,38.8 250.97,38.8 251.1,38.93 251.1,40.58
DGND on TOP: 241.2,80.08 239.42,80.08 238.53,79.19 238.53,77.79 238.66,77.66 240.56,77.66 241.32,78.42 241.32,79.95
DGND on TOP: 242.34,15.18 242.21,15.05 240.18,15.05 240.05,15.18 240.05,16.19 239.04,17.21 237.64,17.21 237.51,17.34 237.51,18.99 237.64,19.12 240.69,19.12 242.34,17.46
DGND on TOP: 239.54,76.01 238.15,76.01 238.02,75.88 238.02,73.34 238.15,73.22 239.54,73.22 239.67,73.34 239.67,75.88
DGND on TOP: 271.29,97.73 269.26,97.73 269.14,97.6 269.14,97.09 269.01,96.97 269.01,96.2 269.14,96.08 271.29,96.08 271.42,96.2 271.42,97.6
DGND on TOP: 162.23,63.43 162.23,70.82 162.38,70.97 163.03,70.97 163.23,70.77 163.23,70.61 163.45,70.39 164.34,70.39 164.34,63.43
DGND on TOP: 30.12,26.35 30.63,26.35 30.88,26.61 30.88,28.01 30.38,28.51 29.23,28.51 29.11,28.39 29.11,27.88 29.36,27.62 29.74,27.62 29.87,27.5 29.87,26.61
DGND on TOP: outline of 84 points within 154.4,58.57 164.12,59.97
DGND on TOP: 261.07,59.21 261.07,61.5 257.93,61.5 257.93,60.67 257.1,61.5 255.41,61.5 255.41,66.15 254.52,67.04 254.52,68.79 253.99,69.32 252.79,69.32 252.41,68.94 252.41,67.8 253,67.21 253.55,67.21 253.55,62.34 252.69,62.34 252.44,62.08 252.44,58.83 252.74,58.53 253.33,58.53 254.01,59.21
DGND on TOP: 141.73,62.01 141.73,64.01 147.4,64.01 147.5,63.91 147.5,62.07 147.44,62.01
DGND on TOP: 261.12,65.54 261.12,60 262.95,60 262.95,68.69 261.5,68.69 260.69,67.87 260.69,65.97
DGND on TOP: 157.35,63.35 157.35,70.47 159.51,70.47 159.51,63.35 158.79,63.35 158.59,63.41 158.4,63.35
DGND on TOP: 149.34,60.26 149.34,65.05 149.35,65.06 149.35,68.83 149.58,69.07 152.83,69.07 153.01,68.9 153.01,67.12 152.57,66.69 152.57,64.73 152.8,64.51 152.8,61.66 152.93,61.66 153.06,61.53 153.06,60.26
DGND on TOP: 257.2,81.98 257.2,80.2 256.26,80.2 256.26,80.33 255.88,80.71 255.88,84.32 256.69,85.13 262.07,85.13 262.61,84.6 262.61,83.83 263.72,82.72 263.72,73.8 260.19,70.27 260.19,68.98 260.09,68.87 259.99,68.87 259.89,68.77 259.89,68.62 259.76,68.49 259.53,68.49 259.46,68.57 259.46,70.4 262.25,73.19 262.25,76.39 262.53,76.67 262.53,82.77 261.41,83.89 257.32,83.89 257.07,83.63 257.07,82.11
DGND on TOP: 152.57,65.44 152.57,66.92 152.68,67.02 153.4,67.02 153.55,67.17 153.55,67.61 153.69,67.75 153.69,70.29 153.82,70.42 154.58,70.42 154.71,70.29 154.71,63.56 154.58,63.44 153.82,63.44 153.69,63.56 153.69,64.32
DGND on TOP, BOTTOM: 285.01,55.82 285.01,37.28 280.69,37.28 278.91,35.5 278.91,30.8 279.17,30.55 288.95,30.55 288.95,55.82
DGND on BOTTOM: 155.47,75.02 155.29,75.2 155.29,76.65 155.44,76.8 157.73,76.8 158.31,77.38 158.31,77.94 158.47,78.09 160.37,78.09 160.37,76.98 160.6,76.75 163.29,76.75 163.83,76.21 163.83,75.14 163.7,75.02
DGND on BOTTOM: 173,94.68 173.38,94.68 173.63,94.43 173.63,88.84 172.62,87.82 171.6,87.82 171.35,88.08 171.35,94.43 171.22,94.55 171.22,96.46 171.35,96.59 171.73,96.59 172.87,95.44 172.87,94.81
DGND on BOTTOM: 182.01,104.33 178.08,104.33 177.57,103.82 177.57,102.3 177.7,102.17 180.74,102.17 181.51,102.94 184.17,102.94 184.3,103.06 184.3,103.19 184.17,103.32 182.27,103.32 182.14,103.44 182.14,104.21
DGND on BOTTOM: 193.67,4.26 193.04,4.26 192.91,4.13 192.91,3.37 193.04,3.24 196.59,3.24 196.72,3.37 196.72,4.89 196.97,5.15 198.37,5.15 198.37,5.65 198.24,5.78 197.1,5.78 196.85,6.03 196.85,7.05 196.72,7.18 196.34,7.18 196.08,6.92 196.08,6.54 195.7,6.16 195.7,3.88 195.58,3.75 194.18,3.75
DGND on BOTTOM: 235.48,68.9 235.48,66.74 235.35,66.61 230.78,66.61 230.02,65.85 229.26,65.85 229.13,65.98 229.13,70.55 229.26,70.68 231.67,70.68 232.43,69.92 234.46,69.92
DGND on BOTTOM: 197.89,23.18 175.41,23.18 174.65,22.42 174.65,22.16 174.77,22.04 197.89,22.04
DGND on BOTTOM: 239.42,62.55 235.99,62.55 235.23,63.31 233.7,63.31 233.58,63.18 233.58,62.55 233.45,62.42 233.45,60.77 233.7,60.52 240.18,60.52 240.31,60.64 240.31,61.66
DGND on BOTTOM: 174.7,61.33 174.7,62.39 174.52,62.57 173.07,62.57 172.67,62.17 171.8,62.17 171.32,62.65 169.49,62.65 169.24,62.39 168.35,62.39 167.46,61.5 167.46,61.05 167.56,60.95 174.32,60.95
DGND on BOTTOM: 115.01,55.01 114.7,55.31 114.7,58.03 115.92,59.25 122.2,59.25 122.78,59.83 122.78,62.4 123.03,62.65 125.88,62.65 126.13,62.4 126.13,56.96 126.01,56.83 123.34,56.83 122.32,55.82 120.8,55.82 119.99,55.01
DGND on BOTTOM: 219.1,63.18 219.1,62.42 218.97,62.3 217.07,62.3 216.94,62.42 216.94,63.18 217.07,63.31 218.97,63.31
DGND on BOTTOM: 284.5,65.34 283.23,65.34 282.85,65.72 281.58,65.72 281.45,65.6 281.45,64.07 281.96,63.57 283.49,63.57 284.63,64.71 284.63,65.22
DGND on BOTTOM: 115.72,116.52 115.72,114.87 115.59,114.75 112.93,114.75 112.8,114.87 112.8,115.64 114.07,116.91 115.34,116.91
DGND on BOTTOM: 105.18,67.71 105.18,75.38 104.29,76.27 104.29,77.15 104.16,77.28 103.45,77.28 103.27,77.1 103.27,76.27 102.89,75.88 102.89,75.88 99.34,72.14 99.34,66.11 99.46,65.98 102.13,65.98 102.51,65.6 102.77,65.6 102.89,65.72 102.89,67.55 103.04,67.71
DGND on BOTTOM: 112.42,69.15 113.18,69.15 113.36,68.98 113.36,65.52 113.31,65.47 112.42,65.47 112.29,65.6 112.29,69.03
DGND on BOTTOM: 155.34,116.02 155.72,115.64 155.72,115.38 155.85,115.25 157.63,115.25 157.63,117.03 157.55,117.11 154.28,117.11 152.98,115.81 149.81,115.81 149.76,115.76 149.76,114.49 149.88,114.37 153.95,114.37 154.07,114.49 154.07,115.76 154.33,116.02
DGND on BOTTOM: 12.85,32.96 12.85,29.91 9.93,29.91 9.93,33.09 10.06,33.21 12.6,33.21
DGND on BOTTOM: 287.68,67.25 287.68,60.14 288.82,60.14 288.82,67.25
DGND on BOTTOM: 111.15,91.51 111.78,91.51 114.32,88.97 114.83,88.97 116.1,87.7 116.1,87.44 115.08,86.43 114.7,86.43 110.77,90.36 110.77,91.12
DGND on BOTTOM: 150.39,102.3 152.8,102.3 152.83,102.33 152.83,105.83 152.68,105.98 151.15,105.98 150.26,105.09 150.26,102.43
DGND on BOTTOM: 148.08,7.31 148,7.24 148,5.12 148.1,5.02 148.99,5.02 149.15,5.17 149.15,7.57 149.05,7.67 148.11,7.67 148.08,7.64
DGND on BOTTOM: 287.68,82.87 287.68,75.76 288.82,75.76 288.82,82.87
DGND on BOTTOM: 241.45,32.7 237.64,32.7 234.97,30.04 234.97,24.96 235.1,24.83 238.15,24.83 239.42,26.1 241.45,26.1 241.58,26.23 241.58,32.58
DGND on BOTTOM: 226.34,30.16 226.34,27.88 224.05,25.59 217.83,25.59 217.7,25.72 217.7,26.23 221.76,30.29 226.21,30.29
DGND on BOTTOM: 80.41,35.5 78.76,35.5 78.64,35.37 78.64,31.69 78.76,31.56 79.4,31.56 79.52,31.69 79.52,33.09 79.65,33.21 80.41,33.21 80.54,33.34 80.54,35.37
DGND on BOTTOM: 185.32,101.03 188.74,101.03 189.63,100.14 189.63,97.6 189.76,97.47 190.78,97.47 190.9,97.6 190.9,99 190.78,99.13 190.52,99.13 190.4,99.25 190.4,100.27 190.9,100.78 190.9,103.32 190.78,103.44 184.93,103.44 184.68,103.19 184.68,101.67
DGND on BOTTOM: 78.89,27.12 78.89,25.59 79.27,25.21 79.27,20.51 79.14,20.39 77.87,20.39 77.49,20 77.49,19.5 77.37,19.37 75.71,19.37 75.59,19.5 75.59,23.94 75.71,24.07 77.24,24.07 77.24,27.12 77.37,27.24 78.64,27.24 78.76,27.12
DGND on BOTTOM: 137.82,53.68 137.82,55.33 137.08,56.07 136.22,56.07 136.06,56.22 136.06,58.99 138.33,58.99 138.58,59.25 138.58,59.76 138.2,60.14 136.06,60.14 136.06,61.53 137.31,61.53 137.31,62.68 136.06,62.68 136.06,64.07 136.55,64.07 136.55,64.68 137.06,65.19 152.73,65.19 152.73,60.62 153.18,60.16 166.21,60.16 166.42,60.36 167.33,60.36 167.33,59.6 169.49,57.44 171.95,57.44 172.39,57.01 172.39,55.49 172.34,55.43 171.52,55.43 171.52,56.15 171.29,56.37 169.95,56.37 169.8,56.22 169.8,55.56 169.67,55.43 169.03,55.43 169.03,56.22 168.83,56.42 167.28,56.42 167.18,56.32 167.18,55.97 166.67,55.97 166.67,56.37 166.52,56.53 164.87,56.53 164.77,56.42 164.77,55.43 145.44,55.43 145.08,55.08 145.08,53.68
DGND on BOTTOM: 282.77,79.34 283.41,79.34 283.66,79.59 283.66,80.58 283.41,80.84 282.77,80.84 282.52,80.58 282.52,79.59
DGND on BOTTOM: 170.08,2.99 169.95,2.86 169.95,2.35 169.57,1.97 169.57,1.59 169.67,1.49 174.29,1.49 174.34,1.54 174.34,2.91 174.27,2.99
DGND on BOTTOM: 187.35,85.16 191.92,85.16 192.17,85.41 192.17,86.17 191.92,86.43 183.92,86.43 183.92,85.28 184.93,84.27 186.46,84.27
DGND on BOTTOM: 151.03,108.9 149.37,108.9 149.25,108.78 149.25,106.36 149.37,106.24 152.55,106.24 152.68,106.36 152.68,107.25
DGND on BOTTOM: 205.86,4.13 203.32,4.13 203.2,4 203.2,3.37 203.32,3.24 205.86,3.24 205.99,3.37 205.99,4
DGND on BOTTOM: 238.15,72.84 238.15,76.65 238.02,76.77 238.02,80.08 238.15,80.2 239.04,80.2 239.16,80.08 241.2,80.08 241.32,79.95 241.83,79.95 241.96,80.08 241.96,81.73 241.45,82.23 239.29,82.23 239.16,82.36 239.16,85.41 243.1,85.41 243.23,85.28 243.23,78.42 243.1,78.3 241.32,78.3 241.32,77.79 240.69,77.15 239.8,77.15 239.67,77.03 239.67,76.7 239.01,76.04 239.01,72.84
DGND on BOTTOM: 175.41,68.77 175.41,71.66 169.95,71.66 169.72,71.44 169.72,70.7 169.9,70.52 172.03,70.52 172.36,70.85 172.97,70.85 173.76,70.06 173.76,69.48 174.04,69.48 174.75,68.77
DGND on BOTTOM: 173.63,27.5 172.36,26.23 146.2,26.23 145.56,26.86 139.34,26.86 139.09,27.12 137.18,27.12 136.55,27.75 105.56,27.75 104.67,28.64 104.67,29.28 104.8,29.4 157.12,29.4 159.03,31.31 211.6,31.31 213.13,29.78 213.89,29.78 215.29,31.18 218.97,31.18 219.1,31.05 219.1,30.67 215.92,27.5
DGND on BOTTOM: 233.7,28.51 230.15,28.51 224.3,22.67 224.3,22.16 224.43,22.04 235.48,22.04 235.61,22.16 235.61,22.42 234.59,23.43 234.59,23.81 234.46,23.94 232.94,23.94 231.16,25.72 231.16,26.1 231.29,26.23 232.18,26.23 233.07,25.34 234.21,25.34 234.46,25.59 234.46,27.75
DGND on BOTTOM: 189.25,35.75 186.71,33.21 186.71,32.83 186.84,32.7 218.97,32.7 222.91,36.64 222.91,36.9 222.78,37.02 219.61,37.02 218.59,36.01 216.18,36.01 214.65,34.48 214.14,34.48 213.64,34.99 213.64,35.63 213.51,35.75
DGND on BOTTOM: 142.14,110.3 144.55,110.3 144.68,110.43 144.68,116.91 144.55,117.03 143.15,117.03 141.88,115.76 140.48,115.76 139.98,115.25 139.98,112.46
DGND on BOTTOM: 269.24,104.21 274.48,108.84 274.85,109.34 274.98,109.95 274.98,116.27 289.71,116.27 289.71,104.21
DGND on BOTTOM: 228.62,80.58 228.24,80.58 228.11,80.71 228.11,87.06 228.24,87.19 228.75,87.19 229.51,86.43 229.51,85.41 230.15,84.77 230.15,81.98 229.64,81.47 228.88,81.47 228.75,81.35 228.75,80.71
DGND on BOTTOM: 137.18,97.6 137.06,97.73 137.06,105.22 141.63,109.79 144.29,109.79 144.42,109.67 144.42,106.24 145.18,105.48 145.18,103.95 145.06,103.82 142.9,103.82 142.77,103.7 142.77,101.92 142.64,101.79 141.88,101.79 141.37,101.28 140.1,101.28 139.98,101.16 139.98,100.52 140.36,100.14 140.36,97.73 140.23,97.6
DGND on BOTTOM: 158.9,89.85 159.53,89.85 159.79,90.11 159.79,92.39 159.15,93.03 159.15,95.06 159.03,95.19 158.14,95.19 158.01,95.06 158.01,92.78 158.65,92.14 158.65,90.11
DGND on BOTTOM: 231.92,85.03 230.53,85.03 230.4,84.9 230.4,84.14 230.91,83.63 230.91,83.25 231.04,83.12 232.05,83.12 232.18,83.25 232.18,84.77
DGND on BOTTOM: 176.68,114.75 180.49,114.75 183.92,111.32 183.92,109.54 183.66,109.29 182.78,109.29 182.27,109.79 179.09,109.79 178.71,109.41 178.71,108.4 178.58,108.27 177.31,108.27 177.19,108.4 177.19,109.16 177.31,109.29 177.44,109.29 178.46,110.3 178.46,111.06 178.2,111.32 176.68,111.32 176.55,111.44 176.55,114.62
DGND on BOTTOM: 227.1,90.24 227.1,89.73 226.97,89.6 226.21,89.6 225.96,89.35 225.96,87.16 225.83,87.03 225.19,87.03 225.07,87.16 225.07,90.08 225.35,90.36 226.97,90.36
DGND on BOTTOM: 96.67,27.5 96.67,33.72 96.54,33.85 95.78,33.85 90.95,29.02 90.95,16.58 91.21,16.32 91.21,11.11 91.34,10.99 94.89,10.99 95.02,11.11 95.02,14.8 95.4,15.18 95.4,18.23 94.64,18.99 94.64,21.91 94.76,22.04 121.69,22.04 121.82,22.16 121.82,23.31 121.69,23.43 102.26,23.43 99.97,25.72 98.19,25.72 97.43,26.48 97.43,26.74
DGND on BOTTOM: 197.38,91.51 195.86,91.51 195.73,91.38 195.73,90.87 195.86,90.74 196.11,90.74 196.24,90.62 197.38,90.62 197.51,90.74 197.51,91.38
DGND on L2: 268.5,-0.95 23.9,-0.95 -1.63,24.58 -1.63,46.42 0.4,48.45 38.25,48.45 47.14,39.56 67.46,39.56 69.68,41.78 69.68,48.52 92.1,70.93 92.1,118.94 93.11,119.95 285.14,119.95 290.34,114.75 290.34,20.89 ; 1 cut-out
DGND on L3: 236.88,73.34 236.75,73.47 236.75,77.92 237.26,78.42 238.4,78.42 238.53,78.55 238.53,79.95 238.66,80.08 241.2,80.08 241.32,79.95 241.32,77.15 240.31,76.14 240.31,74.11 239.54,73.34
DGND on L3: 266.09,57.9 267.71,57.9 267.87,58.05 267.87,67.5 267.43,67.93 266.26,67.93 265.88,67.55 265.88,58.1
DGND on L3: 286.03,74.11 286.03,84.52 274.85,84.52 274.85,74.11
DGND on L3: 285.65,60.14 285.65,69.15 273.2,69.15 273.2,60.14 279.17,60.14 280.82,58.49 282.85,58.49 284.5,60.14
DGND on L4: 139.72,65.72 128.17,65.72 126.13,63.69 120.42,63.69 120.42,12.38 230.78,12.38 230.78,24.45 210.97,44.26 177.95,44.26 175.92,46.29 175.92,47.44 170.84,52.52 170.84,60.77 170.33,61.28 163.73,61.28 163.73,60.14 155.6,60.14 154.45,61.28 144.17,61.28
DGND on L5: 134.77,62.55 129.18,62.55 120.42,53.78 120.42,47.94 95.53,23.05 95.53,14.16 96.29,13.4 235.48,13.4 235.99,13.91 235.99,19.49 233.19,22.29 232.43,22.29 229.51,25.21 213.26,25.21 212.62,25.84 199.67,25.84 187.73,37.78 178.2,37.78 172.23,43.75 172.23,47.94 170.71,49.47 170.71,51.12 168.55,53.28 168.55,54.93 166.52,56.96 166.52,60.13 134.77,60.13
DGND on L5: 184.81,78.68 177.95,78.68 176.55,77.28 176.55,75.76 177.31,75 179.6,75 181.12,76.52 183.79,76.52 185.57,74.74 186.71,74.74 187.09,75.12 187.09,76.39
DGND on L5, L6: 240.94,77.79 238.66,77.79 238.53,77.92 238.53,79.95 238.66,80.08 241.2,80.08 241.32,79.95 241.32,78.17
DGND on L5, L6: 239.54,75.88 238.15,75.88 238.02,75.76 238.02,73.6 238.27,73.34 239.54,73.34 239.67,73.47 239.67,75.76
DGND on L6: 274.6,61.28 276.88,61.28 277.14,61.53 277.14,63.95 277.01,64.07 274.6,64.07 274.47,63.95 274.47,61.41
DGND on L6: 276.93,79.69 279.3,79.69 279.3,82.56 275.49,82.56 275.49,81.14
DGND on L6: 275.61,74.61 278.91,74.61 278.91,77.33 275.61,77.33
DGND on L6: 273.96,66.74 276.37,66.74 276.5,66.87 276.5,69.03 276.37,69.15 273.96,69.15 273.83,69.03 273.83,66.87
DGND on L7: 268.5,-0.95 23.9,-0.95 -1.63,24.58 -1.63,46.42 0.4,48.45 38.25,48.45 47.14,39.56 67.46,39.56 69.68,41.78 69.68,48.52 92.1,70.93 92.1,118.94 93.11,119.95 285.14,119.95 290.34,114.75 290.34,20.89 ; 1 cut-out
DGND_2ALS_H on BOTTOM (solid shape): outline of 437 points within 72.48,77.48 82.12,82.02
DGND_2ALS_H on L2, L3, L5, L6, L7: 72.29,82.21 72.29,77.28 82.27,77.28 82.27,82.21
DGND_ALS on BOTTOM (solid shape): outline of 1027 points within 76.08,91.98 80.12,111.02
DGND_ALS on TOP: 75.08,90.75 75.08,112.07 81.3,112.07 81.3,107.63 81.3,107.63 79.4,107.63 79.14,107.38 79.14,106.75 79.4,106.49 81.3,106.49 81.3,90.75
DGND_ALS on L2: 75,90.8 75,112.27 80.97,112.27 80.97,90.8
DGND_ALS on L3: 75.24,91.06 75.24,112.04 80.96,112.04 80.96,91.06
DGND_ALS on L4: 74.94,91.02 74.94,111.99 81.16,111.99 81.16,91.02
DGND_DMIC_FRONT on TOP (solid shape): 61.62,111.8 58.9,111.8 58.9,113.53 61.62,113.53
DGND_DMIC_FRONT on TOP (solid shape): 60.47,47.05 62.15,47.05 62.15,46.78 58.88,46.78 58.88,47.05 59.11,47.05 59.47,47.41 60.11,47.41
DGND_DMIC_FRONT on TOP (solid shape): 61.66,96.65 61.83,95.97 62.46,95.25 62.52,95.01 62.52,69.41 58.9,69.41 58.9,104.08 61.66,104.08
DGND_DMIC_FRONT on BOTTOM (solid shape): outline of 1084 points within 58.48,42.38 62.52,118.42
DGND_DMIC_FRONT on L2, L5, L6, L7: 59,42.38 58.63,42.53 58.48,42.9 58.48,71.11 57.3,71.11 57.3,71.13 58.48,71.13 58.48,117.9 58.63,118.27 59,118.42 61.64,118.42 62.01,118.27 62.16,117.9 62.16,113.2 61.79,112.83 61.66,112.33 61.66,96.65 61.83,95.97 62.46,95.25 62.52,95.01 62.52,79.29 63.65,79.29 63.65,79.26 62.52,79.26 62.52,65.79 62.46,65.55 61.83,64.84 61.66,64.15 61.66,56.17 61.79,55.68 62.16,55.3 62.16,42.9 62.01,42.53 61.64,42.38
DGND_USB on TOP (solid shape): 38,109.15 40.86,109.62 42.44,107.2 42.35,106.53 42.1,105.9 39.3,105.9 39.3,105.05 38.25,105.05 38.25,105.05 37.9,105.05 37.9,106.26 37.89,106.26 37.31,106.26 37.15,107.34 37.43,108.4 38,108.4 38,108.4
DGND_USB on BOTTOM (solid shape): 33.42,67.25 31.14,67.25 31.14,67.88 33.42,67.88
DGND_USB on BOTTOM (solid shape): 38.4,76.46 35.71,76.46 35.71,83.04 38.4,83.04
DGND_USB on BOTTOM (solid shape): 31.52,64.34 30.76,62.44 29.59,62.44 29.59,64.16 29.76,64.95 29.28,65.61 29.28,67.97 31.52,67.97
DGND_USB on BOTTOM (solid shape): 40.59,96.75 41.37,93.34 40.27,90.02 36.47,90.02 36.6,90.18 36.78,90.39 36.96,90.56 38.57,93.13 37.73,96.04 37.59,96.33 37.49,96.56 37.41,96.75
DGND_USB on BOTTOM (solid shape): 20.3,62.3 20.91,62.07 21.53,62.27 27.99,62.27 27.99,53.98 23.07,53.98 22.97,54.06 23.02,54.17 22.39,56.78 21.75,54.17 21.8,54.06 21.7,53.98 19.99,53.98 19.99,62.3
DGND_USB on BOTTOM (solid shape): 19.69,115.32 19.78,115.31 19.87,115.28 20.2,115.12 20.49,114.91 20.49,114.9 20.83,114.52 21.06,114.06 21.13,113.88 21.23,113.71 21.76,113.24 22.46,113.07 33.47,113.07 33.73,113.09 33.99,113.16 34.07,113.15 34.11,113.07 34.11,109.08 33.93,108.9 30.28,108.9 30.28,110.13 30.09,110.63 29.6,110.83 21.23,110.83 19.86,110.83 19.6,110.9 19.42,111.08 19.07,111.47 18.61,111.72 17.72,112.36 17.38,113.4 17.38,114.8 17.53,115.17 17.9,115.32
DGND_USB on TOP: 36.09,89.85 34.06,89.85 33.93,89.73 33.93,88.97 34.06,88.84 35.07,88.84 35.46,88.46 36.09,88.46 36.22,88.58 36.22,89.73
DGND_USB on TOP: 34.57,112.08 34.57,108.9 35.96,108.9 36.09,109.03 36.09,112.08 35.96,112.21 34.69,112.21
DGND_USB on TOP: 20.34,108.9 20.34,110.3 15.52,110.3 15.52,116.27 20.34,116.27 20.34,118.02 33.62,118.02 33.62,115.57 34.31,114.87 34.31,109.03 34.19,108.9
DGND_USB on TOP: 34.31,97.47 33.8,97.98 20.85,97.98 19.83,96.97 19.83,90.49 21.1,89.22 33.3,89.22 33.42,89.35 33.42,89.98 34.31,90.87
DGND_USB on TOP: 33.55,70.17 32.15,70.17 32.03,70.04 32.03,68.26 32.15,68.14 33.42,68.14 33.68,68.39 33.68,70.04
DGND_USB on TOP: 19.45,78.3 34.19,78.3 34.31,78.17 34.31,77.03 32.15,74.87 19.83,74.87 19.07,75.63 19.07,77.92
DGND_USB on BOTTOM: 19.45,78.3 34.19,78.3 34.31,78.17 34.31,77.03 32.15,74.87 19.83,74.87 19.07,75.63 19.07,77.92
DGND_USB on BOTTOM: 39.03,114.13 39.03,110.17 39.52,109.69 39.52,109.03 40.79,107.76 40.79,106.36 40.92,106.24 43.08,106.24 43.08,114.13
DGND_USB on BOTTOM: 42.82,87.44 42.82,84.52 42.69,84.39 39.39,84.39 39.27,84.52 39.27,85.66 38.88,86.04 38.88,87.44 39.01,87.57 42.69,87.57
DGND_USB on BOTTOM: 34.31,97.47 33.8,97.98 20.85,97.98 19.83,96.97 19.83,90.49 21.1,89.22 33.68,89.22 34.31,89.85
DGND_USB on L2: 13.56,52.47 13.56,74.74 28.85,74.74 28.85,79.95 13.56,79.95 13.56,88.84 21.49,88.84 21.74,89.09 21.74,98.24 13.56,98.24 13.56,125.34 51.15,125.34 51.15,52.47
DGND_USB on L7: 16.91,52.26 16.91,88.46 22.12,88.46 22.12,97.6 16.91,97.6 16.91,124.91 50.44,124.91 50.44,52.26
