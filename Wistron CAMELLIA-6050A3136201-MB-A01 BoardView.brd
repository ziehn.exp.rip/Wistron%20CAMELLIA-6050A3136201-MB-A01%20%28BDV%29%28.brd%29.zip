# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ<28>: length 70.2
  L3 w0.097: v1(139.68,15.89) 139.17,15.89 138.56,16.5 138.56,17.41 136.39,19.57 135.87,19.57 134.51,20.93 134.37,20.93 134.28,20.85 134.15,20.85 134.01,20.98 134.01,21.12 134.1,21.2 134.1,21.34 133.91,21.52 133,21.52 124.82,29.7 124.82,61.57 128.43,65.17 131.01,65.17 v2(131.44,64.75)
  BOTTOM w0.076: U4555.A22 135.75,64.03 134.81,64.03 133.42,64.03 133.35,64.1 132.08,64.1 v2(131.44,64.75)
  BOTTOM w0.13: v1(139.68,15.89) 140.38,15.2 CN4100.174
M_A_DQ<29>: length 70.7
  L3 w0.097: v1(132.81,64.75) 132.38,64.31 128.42,64.31 125.42,61.31 125.42,30.95 125.43,30.93 125.43,30.85 126.11,30.16 126.11,30.03 125.86,29.77 125.86,29.64 125.99,29.5 126.13,29.5 126.39,29.75 126.52,29.75 126.66,29.62 126.66,29.48 126.4,29.23 126.4,29.09 126.54,28.95 126.68,28.95 126.93,29.21 127.07,29.21 127.21,29.07 127.21,28.93 126.95,28.68 126.95,28.54 127.09,28.41 127.22,28.41 127.48,28.66 127.62,28.66 127.75,28.53 127.75,28.39 127.5,28.13 127.5,28 127.63,27.86 127.77,27.86 128.03,28.12 128.16,28.12 128.3,27.98 128.3,27.84 128.04,27.59 128.04,27.45 128.18,27.31 128.32,27.31 128.57,27.57 128.71,27.57 128.84,27.43 128.84,27.3 128.59,27.04 128.59,26.9 128.73,26.77 128.86,26.77 129.12,27.02 129.25,27.02 129.39,26.89 129.39,26.75 129.14,26.5 129.14,26.36 129.27,26.22 129.41,26.22 129.66,26.48 129.8,26.48 129.94,26.34 129.94,26.2 129.68,25.95 129.68,25.81 129.82,25.68 129.95,25.68 130.21,25.93 130.35,25.93 136.06,20.21 136.73,20.21 137.91,19.03 v1(139.07,19.03)
  BOTTOM w0.076: U4555.B22 136.42,63.97 135.94,64.23 135.67,64.23 135.64,64.2 133.49,64.2 133.42,64.27 133.29,64.27 v1(132.81,64.75)
  BOTTOM w0.13: v1(139.07,19.03) 139.13,19.08 CN4100.169
M_A_DQ<30>: length 70.4
  L3 w0.097: v2(130.97,63.31) 130.4,62.74 129.81,62.74 127.24,60.18 127.24,32.26 127.43,32.08 127.56,32.08 127.8,32.31 127.93,32.31 128.07,32.17 128.07,32.04 127.84,31.81 127.84,31.67 127.97,31.53 128.11,31.53 128.34,31.76 128.48,31.76 128.61,31.63 128.61,31.49 128.38,31.26 128.38,31.12 128.52,30.99 128.66,30.99 128.89,31.22 129.02,31.22 129.16,31.08 129.16,30.95 128.93,30.71 128.93,30.58 129.07,30.44 129.2,30.44 129.43,30.67 129.57,30.67 129.71,30.54 129.71,30.4 129.48,30.17 129.48,30.03 129.61,29.9 129.75,29.9 129.98,30.13 130.12,30.13 130.25,29.99 130.25,29.85 130.02,29.62 130.02,29.49 130.16,29.35 130.3,29.35 130.53,29.58 130.66,29.58 130.8,29.44 130.8,29.31 130.57,29.08 130.57,28.94 130.7,28.8 130.84,28.8 131.07,29.03 131.21,29.03 131.34,28.9 131.34,28.76 131.11,28.53 131.11,28.39 135.77,23.74 135.77,23.12 136.84,22.05 137.56,22.05 138.48,21.12 139.54,21.12 141.07,19.6 141.64,19.6 142.43,18.8 142.43,18.56 142.43,17.84 v1(142.92,17.35)
  BOTTOM w0.076: U4555.A24 135.72,62.77 134.93,62.77 134.72,62.56 133.55,62.56 133.45,62.66
  BOTTOM w0.089: 133.45,62.66 133.27,62.85 132.83,62.85 132.76,62.93 132.5,62.93 131.82,62.93 131.36,62.93 v2(130.97,63.31)
  BOTTOM w0.13: v1(142.92,17.35) 142.54,17.72 142.54,20.75 CN4100.183
M_A_DQ<31>: length 71.5
  L3 w0.097: v2(129.6,63.31) 129.6,62.96 126.95,60.3 126.95,32.14 127.54,31.54 127.54,31.41 127.4,31.26 127.4,31.12 127.53,30.99 127.67,30.99 127.82,31.13 127.95,31.13 128.09,31 128.09,30.86 127.94,30.71 127.94,30.58 128.08,30.44 128.22,30.44 128.36,30.59 128.5,30.59 128.64,30.45 128.64,30.31 128.49,30.17 128.49,30.03 128.63,29.89 128.76,29.89 128.91,30.04 129.05,30.04 129.18,29.9 129.18,29.77 129.04,29.62 129.04,29.48 129.17,29.35 129.31,29.35 129.46,29.49 129.59,29.49 129.73,29.36 129.73,29.22 129.58,29.07 129.58,28.94 129.72,28.8 129.86,28.8 130,28.95 130.14,28.95 130.28,28.81 130.28,28.68 130.13,28.53 130.13,28.39 130.26,28.26 130.4,28.26 130.55,28.4 130.68,28.4 130.82,28.27 130.82,28.13 130.77,28.08 130.77,27.94 131.04,27.66 131.42,27.66 135.39,23.7 135.39,23.03 136.69,21.73 137.36,21.73 138.26,20.83 139.42,20.83 140.95,19.3 141.52,19.3 142.13,18.68 142.13,16.69 v1(142.95,15.87)
  BOTTOM w0.076: 133.18,62.67 133.45,62.4 134.79,62.4 134.99,62.6 135.47,62.6 135.67,62.4 135.93,62.4 136.12,62.5 136.31,62.5 U4555.B24
  BOTTOM w0.089: 133.18,62.67 132.76,62.67 132.72,62.71 130.93,62.71 130.89,62.75
  BOTTOM w0.13: 130.89,62.75 130.75,62.89 130.02,62.89 v2(129.6,63.31) ; CN4100.182 142.38,15.29 v1(142.95,15.87)
M_A_DQ<32>: length 58.1
  L6 w0.097: v1(134.29,51.27) 133.36,50.34 133.36,49.2 129.21,45.05 129.21,43.81 128.31,42.92 128.31,42.89 107,21.58 107,17.58 107.23,17.35 107.23,16.31 v1(106.98,16.06)
  BOTTOM w0.076: 135.94,52.57 136.07,52.7 136.98,52.7 137.45,53.17 137.92,53.17 138.07,53.31 139.52,53.31 139.91,53.7 139.91,54.49 U4555.H37
  BOTTOM w0.13: 135.94,52.57 134.64,51.27 v1(134.29,51.27) ; CN4100.46 106.38,15.45 v1(106.98,16.06)
M_A_DQ<33>: length 59.5
  L6 w0.097: v1(106.08,18.81) 106.08,21.53 107.31,22.76 107.31,22.89 107.17,23.03 107.17,23.17 107.3,23.31 107.44,23.31 107.58,23.17 107.72,23.17 107.85,23.3 107.85,23.44 107.71,23.58 107.71,23.72 107.85,23.85 107.99,23.85 108.13,23.71 108.26,23.71 108.4,23.85 108.4,23.99 108.26,24.13 108.26,24.26 108.4,24.4 108.53,24.4 108.67,24.26 108.81,24.26 108.95,24.4 108.95,24.53 108.81,24.67 108.81,24.81 108.94,24.94 109.08,24.94 109.22,24.81 109.36,24.81 109.49,24.94 109.49,25.08 109.35,25.22 109.35,25.35 109.49,25.49 109.63,25.49 109.77,25.35 109.9,25.35 110.04,25.49 110.04,25.62 109.9,25.76 109.9,25.9 110.04,26.04 110.17,26.04 110.27,25.94 110.49,25.94 110.63,26.08 110.64,26.08 128.61,44.06 128.61,45.29 132.76,49.44 132.76,51.27 134.46,52.97 v1(134.97,52.97)
  BOTTOM w0.076: U4555.H34 139.57,55.88 139.57,54.94 139.44,54.69 139.44,54.31 139.49,54.26 139.58,54.17 139.58,53.84 139.38,53.64 137.93,53.64 137.85,53.56 137.08,53.56 136.67,53.16 135.16,53.16 v1(134.97,52.97)
  BOTTOM w0.13: v1(106.08,18.81) 106.13,18.85 CN4100.45
M_A_DQ<34>: length 61.1
  L6 w0.097: v1(109.51,14.46) 108.93,15.04 108.93,15.36 109.12,15.56 109.12,21.54 111.07,23.49 111.45,23.49 118.34,30.37 118.47,30.37 118.56,30.29 118.7,30.29 118.84,30.42 118.84,30.56 118.75,30.65 118.75,30.78 132.55,44.59 132.55,45.71 135.45,48.61 136.61,48.61 136.76,48.76 136.76,51.24 v1(136.34,51.66)
  BOTTOM w0.076: U4555.K34 140.42,56.48 140.23,56.29 140.23,55.5 140.27,55.39 140.3,55.3 140.3,55.07 140.25,54.95 140.25,54.77 140.3,54.63 140.3,53.6 139.68,52.98 138.2,52.98 138.06,52.84 137.84,52.84 137.12,52.12
  BOTTOM w0.13: v1(109.51,14.46) 109.38,14.33 CN4100.58 ; v1(136.34,51.66) 136.81,52.12 137.12,52.12
M_A_DQ<35>: length 60.3
  L6 w0.097: v1(137.84,49.04) 137.84,49.02 136.15,47.34 135.54,47.34 133.5,45.3 133.5,43.45 113.47,23.42 113.13,23.42 112.3,22.59 111.44,22.59 110.6,21.75 110.6,16.03 110.41,15.84 109.68,15.84 v1(109.53,15.99)
  BOTTOM w0.076: U4555.K35 141.5,55.5 141.5,54.87 141.6,54.69 141.6,54.31 141.4,54.1 141.4,53.79 141.57,53.61 141.57,52.69 140.91,52.03 139.01,52.03 138.76,51.78 138.76,49.96 v1(137.84,49.04)
  BOTTOM w0.13: CN4100.62 110.38,15.15 v1(109.53,15.99)
M_A_DQ<36>: length 58.9
  L6 w0.097: v1(106.32,17.46) 106.61,17.46 106.7,17.55 106.7,19.31 106.61,19.4 106.49,19.4 106.39,19.5 106.39,19.69 106.49,19.79 106.61,19.79 106.7,19.88 106.7,20.08 106.61,20.17 106.49,20.17 106.39,20.27 106.39,20.46 106.49,20.56 106.61,20.56 106.7,20.66 106.7,20.85 106.61,20.95 106.49,20.95 106.39,21.04 106.39,21.24 106.49,21.33 106.61,21.33 106.7,21.43 106.7,21.73 110.04,25.07 110.04,25.07 128.91,43.94 128.91,45.17 133.06,49.32 133.06,50.64 v1(134.29,51.88)
  BOTTOM w0.076: 134.67,51.88 135.76,52.96 136.82,52.96 137.26,53.4 137.92,53.4 138,53.47 139.45,53.47 139.74,53.77 139.74,54.24 139.65,54.33 139.65,54.33 139.6,54.38 139.6,54.65 139.87,55.13 139.87,55.18
  BOTTOM w0.13: v1(106.32,17.46) 107.13,18.26 CN4100.49 ; 134.67,51.88 v1(134.29,51.88)
M_A_DQ<37>: length 59.8
  L6 w0.097: v1(134.29,50.02) 134.29,49.71 129.51,44.92 129.51,43.69 128.64,42.83 128.64,42.8 107.3,21.45 107.3,17.7 107.78,17.22 107.78,14.58 107.68,14.48 v1(106.96,14.48)
  BOTTOM w0.076: U4555.H35 140.05,55.65 140.05,55.49 140.13,55.28 140.13,55.09 140.09,54.98 140.09,54.74 140.13,54.61 140.13,53.68 139.6,53.14 138.13,53.14 137.99,53 137.59,53 137.01,52.42 136.38,52.42 135.66,51.7
  BOTTOM w0.13: CN4100.50 107.38,14.07 v1(106.96,14.48) ; 135.66,51.7 135.66,51.44 v1(134.29,50.02)
M_A_DQ<38>: length 60
  L6 w0.097: v2(137.83,50.29) 137.16,49.61 137.16,48.6 136.23,47.67 135.39,47.67 133.15,45.43 133.15,44.34 129.73,40.93 129.73,40.44 114.72,25.43 114.72,25.18 114.57,25.03 114.32,25.03 114.17,24.88 114.17,24.63 114.03,24.48 113.77,24.48 113.63,24.34 113.63,24.08 113.48,23.94 113.23,23.94 112.18,22.89 111.31,22.89 110.3,21.87 110.3,16.55 110.11,16.36 109.71,16.36 109.53,16.54 v1(109.53,17)
  BOTTOM w0.076: v2(137.83,50.29) 137.91,50.29 138.58,50.96 138.58,51.86 138.93,52.2 140.84,52.2 141.41,52.77 141.41,53.54 141.23,53.72 141.23,54.17 141.43,54.38 141.43,54.65 141.33,54.83 141.33,55.02 141.17,55.18
  BOTTOM w0.13: CN4100.63 110.63,18.1 v1(109.53,17)
M_A_DQ<39>: length 59
  L6 w0.097: v1(109.53,18.51) 109.53,21.52 111.19,23.19 111.96,23.19 112.07,23.3 112.07,23.44 112.02,23.49 112.02,23.63 112.16,23.76 112.29,23.76 112.4,23.66 112.53,23.66 112.67,23.8 112.67,23.93 112.57,24.04 112.57,24.17 112.7,24.31 112.84,24.31 112.94,24.21 113.08,24.21 113.21,24.34 113.21,24.48 113.11,24.58 113.11,24.72 113.25,24.86 113.39,24.86 113.49,24.75 113.62,24.75 113.76,24.89 113.76,25.03 113.66,25.13 113.66,25.27 113.79,25.4 113.93,25.4 114.03,25.3 114.17,25.3 114.31,25.44 114.31,25.57 114.2,25.67 114.2,25.81 114.34,25.95 114.48,25.95 114.58,25.85 114.72,25.85 114.85,25.98 114.85,26.12 114.75,26.22 114.75,26.36 114.89,26.49 115.02,26.49 115.13,26.39 115.26,26.39 115.4,26.53 115.4,26.66 115.3,26.77 115.3,26.9 115.43,27.04 115.57,27.04 115.67,26.94 115.81,26.94 115.94,27.07 115.94,27.21 115.84,27.31 115.84,27.45 115.98,27.59 116.12,27.59 116.22,27.48 116.35,27.48 116.49,27.62 116.49,27.76 116.39,27.86 116.39,28 116.53,28.13 116.66,28.13 116.76,28.03 116.9,28.03 117.04,28.17 117.04,28.3 116.93,28.41 116.93,28.54 117.07,28.68 117.21,28.68 117.31,28.58 117.45,28.58 117.58,28.71 117.58,28.85 117.48,28.95 117.48,29.09 117.62,29.22 117.75,29.22 117.86,29.12 117.99,29.12 118.11,29.24 118.11,29.55 118.37,29.8 118.68,29.8 129.44,40.56 129.44,41.05 132.85,44.46 132.85,45.58 135.29,48.02 136.3,48.02 136.96,48.69 136.96,50.66 v2(137.92,51.62)
  BOTTOM w0.076: U4555.K37 141.17,54.36 141.07,54.26 141.07,53.65 141.24,53.47 141.24,52.87 140.73,52.36 138.67,52.36 v2(137.92,51.62)
  BOTTOM w0.13: CN4100.59 109.63,18.61 v1(109.53,18.51)
M_A_DQ<40>: length 59.4
  L6 w0.097: v1(112.02,17.67) 112.02,18.09 112.13,18.2 112.51,18.2 112.63,18.31 112.63,18.47 112.51,18.59 112.13,18.59 112.02,18.7 112.02,18.86 112.13,18.97 112.51,18.97 112.63,19.08 112.63,19.24 112.51,19.36 112.13,19.36 112.02,19.47 112.02,19.63 112.13,19.74 112.51,19.74 112.63,19.86 112.63,20.02 112.51,20.13 112.13,20.13 112.02,20.24 112.02,20.45 112.11,20.54 112.24,20.54 112.34,20.64 112.34,20.83 112.24,20.93 112.11,20.93 112.02,21.03 112.02,21.18 112.62,21.78 112.78,21.78 113.33,21.23 113.49,21.23 113.6,21.35 113.6,21.51 113.14,21.97 113.14,22.31 113.46,22.62 113.79,22.62 134.51,43.33 134.51,45.06 135.91,46.46 136.14,46.46 138.49,48.81 138.49,49.7 v1(139.15,50.35)
  BOTTOM w0.076: 142.38,55.18 142.38,55.13 142.12,54.65 142.12,54.38 142.34,54.16 142.34,53.71 142.14,53.51 142.14,52.73 141.1,51.69 140.1,51.69 139.76,51.35
  BOTTOM w0.089: 139.76,51.35 139.58,51.17 139.58,50.79 v1(139.15,50.35)
  BOTTOM w0.13: CN4100.67 111.63,18.06 v1(112.02,17.67)
M_A_DQ<41>: length 59.2
  L6 w0.097: v1(139.16,51.62) 138.24,50.7 138.24,48.83 136.24,46.83 135.83,46.83 134.14,45.14 134.14,43.39 113.67,22.92 113.33,22.92 111.61,21.2 111.61,17.64 111.46,17.48 111.46,17.25 111.61,17.1 111.61,16.86 111.46,16.71 111.46,16.48 111.84,16.1 v1(112.02,16.1)
  BOTTOM w0.076: 139.76,51.83 139.79,51.86 141.02,51.86 141.97,52.81 141.97,53.58 142.17,53.78 142.17,54.09 141.96,54.31 141.96,54.69 142.09,54.94 142.09,55.92 142.36,56.47 U4555.N34
  BOTTOM w0.13: 139.76,51.83 139.55,51.62 v1(139.16,51.62) ; CN4100.66 111.38,12.38 111.38,15.47 v1(112.02,16.1)
M_A_DQ<42>: length 59.3
  L6 w0.097: v1(141.77,50.37) 141.13,49.73 141.13,48.31 139.92,47.11 139.77,47.11 137.54,44.88 137.54,42.9 117.95,23.31 117.79,23.15 117.5,23.15 117.38,23.04 117.38,22.88 117.5,22.76 117.72,22.76 117.84,22.65 117.84,22.49 117.72,22.38 117.5,22.38 117.38,22.26 117.38,22.1 117.5,21.99 117.72,21.99 117.84,21.88 117.84,21.72 117.72,21.61 117.5,21.61 117.38,21.49 117.38,21.33 117.5,21.22 117.72,21.22 117.84,21.11 117.84,20.95 117.72,20.83 117.5,20.83 117.38,20.72 117.38,20.56 117.5,20.45 117.72,20.45 117.84,20.33 117.84,20.17 117.72,20.06 117.4,20.06 117.28,19.94 117.28,19.78 117.38,19.68 117.72,19.68 117.84,19.56 117.84,19.4 117.72,19.29 117.4,19.29 117.27,19.16 117.27,19 117.37,18.9 117.72,18.9 117.84,18.79 117.84,18.63 117.72,18.52 117.3,18.52 117.18,18.39 117.18,18.23 117.28,18.13 117.72,18.13 117.84,18.02 117.84,17.86 117.72,17.74 117.34,17.74 117.25,17.65 117.25,17.28 117.15,17.19 116.53,17.19 v2(116.46,17.25)
  BOTTOM w0.076: v1(141.77,50.37) 141.77,50.65 143.76,52.64 143.76,53.47 143.58,53.65 143.58,54.26 143.69,54.36 U4555.R37
  BOTTOM w0.13: v2(116.46,17.25) 114.63,19.09 CN4100.79
M_A_DQ<43>: length 59.1
  L6 w0.097: v1(140.46,50.96) 140.88,50.55 140.88,48.32 139.98,47.43 139.66,47.43 137.24,45.01 137.24,43.02 117.67,23.45 117.37,23.45 117.05,23.13 117.05,21.87 116.94,21.75 116.06,21.75 115.95,21.64 115.95,21.48 116.06,21.37 116.94,21.37 117.05,21.25 117.05,21.09 116.94,20.98 116.06,20.98 115.95,20.87 115.95,20.71 116.06,20.6 116.94,20.6 117.05,20.48 117.05,20.32 116.94,20.21 116.06,20.21 115.95,20.1 115.95,19.94 116.06,19.82 116.84,19.82 116.94,19.73 116.94,18.79 116.84,18.69 v2(116.46,18.69)
  BOTTOM w0.076: U4555.R34 142.93,56.48 142.74,56.29 142.74,55.5 142.81,55.3 142.81,55.07 142.77,54.95 142.77,54.77 142.85,54.55 142.85,53.52 142.65,53.32 142.65,52.46 141.15,50.96 v1(140.46,50.96)
  BOTTOM w0.13: CN4100.83 115.63,19.53 v2(116.46,18.69)
M_A_DQ<44>: length 59
  L6 w0.097: v1(112.02,14.58) 112.35,14.25 112.83,14.25 113.03,14.44 113.03,14.83 112.91,14.94 112.68,14.94 112.56,15.06 112.56,15.22 112.68,15.33 112.91,15.33 113.03,15.44 113.03,15.6 112.91,15.71 112.68,15.71 112.56,15.83 112.56,15.99 112.68,16.1 112.91,16.1 113.03,16.21 113.03,16.37 112.91,16.49 112.68,16.49 112.56,16.6 112.56,16.76 112.68,16.87 112.91,16.87 113.03,16.99 113.03,17.25 112.93,17.34 112.82,17.34 112.72,17.44 112.72,17.63 112.82,17.73 112.93,17.73 113.03,17.83 113.03,19.89 114.33,21.19 114.33,22.74 135.04,43.45 135.04,45.17 136.02,46.14 136.09,46.14 138.72,48.78 138.72,49.25 v1(139.16,49.69)
  BOTTOM w0.076: U4555.N37 142.51,54.41 142.51,53.64 142.31,53.44 142.31,52.63 141.2,51.53 140.19,51.53 140.02,51.36
  BOTTOM w0.089: 140.02,51.36 139.89,51.23 139.8,51.14 139.8,50.33 v1(139.16,49.69)
  BOTTOM w0.13: CN4100.70 112.38,14.27 v1(112.02,14.58)
M_A_DQ<45>: length 58.7
  L6 w0.097: v1(139.19,48.46) 138.76,48.46 135.34,45.05 135.34,43.32 114.63,22.61 114.63,20.74 114.52,20.63 114.24,20.63 114.13,20.51 114.13,20.35 114.24,20.24 114.52,20.24 114.63,20.13 114.63,19.97 114.52,19.86 114.24,19.86 114.13,19.74 114.13,19.58 114.24,19.47 114.52,19.47 114.63,19.36 114.63,19.2 114.52,19.08 114.24,19.08 114.13,18.97 114.13,18.81 114.24,18.7 114.52,18.7 114.63,18.58 114.63,17.15 114.45,16.97 114.1,16.97 113.98,17.09 113.98,18.15 v1(113.56,18.56)
  BOTTOM w0.076: U4555.N35 142.57,55.65 142.57,55.49 142.65,55.28 142.65,55.09 142.61,54.98 142.61,54.74 142.68,54.54 142.68,53.58 142.47,53.38 142.47,52.57 141.29,51.38 141.29,51.38 141.27,51.36 140.28,51.36 140.04,51.13
  BOTTOM w0.089: v1(139.19,48.46) 139.19,48.49 139.82,49.12 v3(139.82,49.39) 140.04,49.61 140.04,51.13
  BOTTOM w0.13: v1(113.56,18.56) 113.36,18.56 112.63,19.3 CN4100.71
M_A_DQ<46>: length 59.8
  L6 w0.097: v1(141.78,49.03) 141.36,48.6 141.36,48.2 139.95,46.79 139.87,46.79 137.84,44.76 137.84,42.77 118.14,23.07 118.14,21.49 118.14,21.48 118.14,16.86 118.04,16.77 116.46,16.77 116.35,16.66 116.35,16.5 116.47,16.38 118.04,16.38 118.14,16.29 118.14,15.71 118.04,15.62 116.72,15.62 v2(116.42,15.91)
  BOTTOM w0.076: v1(141.78,49.03) 142.24,49.49 142.24,50.75 143.92,52.43 143.92,53.54 143.75,53.72 143.75,54.17 143.95,54.38 143.95,54.65 143.85,54.83 143.85,55.02 U4555.R36
  BOTTOM w0.13: CN4100.80 114.88,12.49 114.88,13.33 115.06,13.51 115.06,14.55 v2(116.42,15.91)
M_A_DQ<47>: length 59
  L6 w0.097: v2(116.46,14.59) 116.46,14.38 116.56,14.29 116.84,14.29 116.95,14.39 116.95,15.15 117.04,15.25 117.25,15.25 117.34,15.15 117.34,14.25 117.44,14.15 117.63,14.15 117.73,14.25 117.73,15.15 117.83,15.25 118.37,15.25 118.46,15.34 118.46,22.97 138.14,42.65 138.14,44.63 139.96,46.45 141.81,48.3 v1(141.81,48.41)
  BOTTOM w0.076: v1(141.81,48.41) 142.49,49.09 142.49,50.76 144.09,52.36 144.09,53.61 143.91,53.79 143.91,54.1 144.12,54.31 144.12,54.69 144.02,54.87 144.02,55.5 U4555.R35
  BOTTOM w0.13: CN4100.84 115.88,14.03 v2(116.46,14.59)
M_A_DQ<48>: length 57.5
  L3 w0.097: v2(150.13,18.77) 149.92,18.77 149.83,18.87 149.83,19.18 149.72,19.29 149.72,20.06 149.62,20.16 149.48,20.16 149.26,19.93 149.12,19.93 148.98,20.06 148.98,20.2 149.21,20.43 149.21,20.57 149.08,20.7 148.94,20.7 148.71,20.47 148.57,20.47 148.44,20.61 148.44,20.75 148.67,20.98 148.67,21.11 148.53,21.25 148.39,21.25 148.16,21.02 148.03,21.02 147.89,21.16 147.89,21.29 148.12,21.52 148.12,21.66 147.98,21.79 147.85,21.79 147.62,21.57 147.48,21.57 147.34,21.7 147.34,21.84 147.57,22.07 147.57,22.2 147.44,22.34 147.3,22.34 147.07,22.11 146.93,22.11 146.8,22.25 146.8,22.38 147.03,22.61 147.03,22.75 146.89,22.89 146.75,22.89 146.53,22.66 146.39,22.66 146.25,22.79 146.25,22.93 146.48,23.16 146.48,23.3 146.34,23.43 146.21,23.43 145.98,23.2 145.84,23.2 145.71,23.34 145.71,23.48 145.93,23.71 145.93,23.84 145.8,23.98 145.66,23.98 145.43,23.75 145.3,23.75 145.16,23.89 145.16,24.02 145.39,24.25 145.39,24.39 133.58,36.19 133.58,52.76 137.41,56.59 137.64,56.59 137.91,56.86 138.26,57.66 v1(138.54,57.95)
  BOTTOM w0.076: U4555.G31 139,58.18 138.54,57.95 v1(138.54,57.95)
  BOTTOM w0.13: CN4100.211 149.63,19.28 150.13,18.77 v2(150.13,18.77)
M_A_DQ<49>: length 59.6
  L3 w0.097: v2(150.36,14.46) 150.47,14.57 151.4,14.57 151.49,14.66 151.49,14.86 151.4,14.95 150.89,14.95 150.79,15.05 150.79,15.24 150.89,15.34 151.4,15.34 151.49,15.44 151.49,15.63 151.4,15.73 150.89,15.73 150.79,15.82 150.79,16.02 150.89,16.11 151.4,16.11 151.49,16.21 151.49,16.4 151.4,16.5 150.89,16.5 150.79,16.59 150.79,16.79 150.89,16.88 151.4,16.88 151.49,16.98 151.49,17.17 151.4,17.27 151.31,17.27 150.78,17.8 150.78,19.42 133.88,36.32 133.88,52.64 137.57,56.32 137.79,56.32 138.54,57.07 v1(138.54,57.31)
  BOTTOM w0.076: v1(138.54,57.31) U4555.G32
  BOTTOM w0.13: CN4100.216 150.88,13.94 v2(150.36,14.46)
M_A_DQ<50>: length 58.6
  L3 w0.076: 139.77,56.13 139.77,56.83 140.02,57.08 140.02,57.52 139.83,57.71 139.83,58.84 v1(139.45,59.22)
  L3 w0.097: v2(153.58,18.65) 153.32,18.65 153.27,18.69 153.27,18.9 153.2,18.98 153.2,19.38 153.2,19.63 136.59,36.24 136.59,36.37 136.86,36.65 136.86,36.79 136.73,36.92 136.59,36.92 136.32,36.65 136.18,36.65 136.08,36.75 136.08,45.78 136.26,45.97 136.26,46.17 136.08,46.35 136.08,46.49 136.17,46.59 136.55,46.59 136.65,46.68 136.65,46.88 136.55,46.97 136.17,46.97 136.08,47.07 136.08,47.26 136.17,47.36 136.55,47.36 136.65,47.45 136.65,47.65 136.55,47.74 136.17,47.74 136.08,47.84 136.08,48.03 136.17,48.13 136.55,48.13 136.65,48.23 136.65,48.42 136.55,48.52 136.17,48.52 136.08,48.61 136.08,48.75 135.94,48.88 135.94,51.81 135.97,51.84 135.97,51.86 136.65,52.54 136.65,52.95 136.78,53.08 136.91,53.08 137.15,52.84 137.28,52.84 137.42,52.98 137.42,53.11 137.19,53.35 137.19,53.49 137.32,53.62 137.46,53.62 137.69,53.39 137.83,53.39 137.97,53.52 137.97,53.66 137.73,53.89 137.73,54.03 138.67,54.97 138.95,54.97 139.77,55.79 139.77,56.13
  BOTTOM w0.076: v1(139.45,59.22) U4555.H29
  BOTTOM w0.13: CN4100.229 154.13,19.15 153.63,18.65 v2(153.58,18.65)
M_A_DQ<51>: length 58.8
  L3 w0.076: v1(139.45,59.85) 139.9,59.26 139.9,59.01 139.99,58.91 139.99,57.79 140.2,57.58 140.2,57 139.97,56.78 139.97,56.11
  L3 w0.097: v2(153.57,17.32) 153.57,16.78 153.73,16.61 154.21,16.61 154.33,16.73 154.33,18.99 154.19,19.13 154.19,19.57 153.91,19.86 153.38,19.86 137.26,35.99 137.26,36.82 136.49,37.59 136.49,45.68 136.88,46.07 136.88,51.96 138.42,53.5 138.42,54.46 138.75,54.78 139.11,54.78 139.97,55.65 139.97,56.11
  BOTTOM w0.076: v1(139.45,59.85) U4555.H28
  BOTTOM w0.13: v2(153.57,17.32) 153.56,17.32 153.44,17.32 152.85,17.91 152.85,19.41 153.13,19.69 CN4100.225
M_A_DQ<52>: length 57.3
  L3 w0.097: v2(150.36,15.88) 149.9,17.22 149.59,17.53 149.16,18.24 149.16,19.02 149.11,19.09 141.77,26.44 139.43,29.34 132.97,35.81 132.97,52.94 134.09,54.81 134.93,55.65 135.15,55.65 137.34,57.85 137.72,59.03 v1(138.54,59.85)
  BOTTOM w0.076: v1(138.54,59.85) U4555.G28
  BOTTOM w0.13: CN4100.212 149.88,15.39 v2(150.36,15.88)
M_A_DQ<53>: length 59
  L3 w0.097: v2(150.27,17.41) 150.24,17.41 149.72,17.93 149.72,18.45 149.51,18.66 149.51,19.08 149.42,19.17 149.42,19.2 144.62,24 144.62,24.14 144.82,24.35 144.82,24.48 144.69,24.62 144.55,24.62 144.35,24.41 144.21,24.41 144.07,24.55 144.07,24.69 144.28,24.89 144.28,25.03 144.14,25.16 144,25.16 143.8,24.96 143.66,24.96 143.53,25.1 143.53,25.23 143.73,25.44 143.73,25.57 143.59,25.71 143.46,25.71 143.25,25.51 143.12,25.51 142.98,25.64 142.98,25.78 143.19,25.98 143.19,26.12 143.05,26.26 142.91,26.26 142.71,26.05 142.57,26.05 142.43,26.19 142.43,26.32 142.64,26.53 142.64,26.67 142.45,26.86 142.31,26.86 142.18,26.73 142.04,26.73 141.91,26.86 141.91,27 142.04,27.13 142.04,27.27 133.27,36.04 133.27,44.81 133.27,44.81 133.27,52.96 134.22,53.92 134.22,54.59 134.98,55.34 135.15,55.34 137.99,58.19 137.99,58.66 v1(138.54,59.22)
  BOTTOM w0.076: v1(138.54,59.22) U4555.G29
  BOTTOM w0.13: CN4100.215 150.63,19.47 150.74,19.36 150.74,17.97 150.27,17.5 v2(150.27,17.41)
M_A_DQ<54>: length 58.7
  L3 w0.076: v1(139.45,57.95) 139.45,57.84 139.83,57.46 139.83,57.16 139.57,56.89 139.57,56.11
  L3 w0.097: v2(153.53,15.73) 153.53,15.55 153.26,15.28 152.4,15.28 152.26,15.42 152.26,15.62 152.37,15.73 152.79,15.73 152.97,15.92 152.97,16.1 153.07,16.2 153.31,16.2 153.4,16.29 153.4,16.49 153.31,16.58 153.07,16.58 152.97,16.68 152.97,18.78 152.9,18.86 152.9,19.5 135.78,36.63 135.78,48.71 135.58,48.91 135.58,51.78 136.46,52.67 136.46,53.03 138.6,55.16 138.81,55.16 139.57,55.93 139.57,56.11
  BOTTOM w0.076: U4555.H31 v1(139.45,57.95)
  BOTTOM w0.13: CN4100.224 152.88,15.08 v2(153.53,15.73)
M_A_DQ<55>: length 60
  L3 w0.076: v1(139.46,57.31) 139.38,57.24 139.38,56.11
  L3 w0.097: 139.38,56.11 139.38,56.07 138.67,55.36 138.5,55.36 136.2,53.06 136.2,52.7 135.39,51.89 135.39,48.69 135.48,48.6 135.48,36.44 152.57,19.35 152.57,18.77 152.68,18.66 152.68,16.14 152.58,16.04 151.99,16.04 151.89,15.94 151.89,15.07 151.99,14.97 153.05,14.97 153.15,14.88 153.15,14.67 153.04,14.56 151.84,14.56 151.74,14.47 151.74,14.27 151.84,14.18 152.61,14.18 152.7,14.08 152.7,14.04 152.83,13.91 153.57,13.91 153.67,14.01 v2(153.67,14.29)
  BOTTOM w0.076: v1(139.46,57.31) U4555.H32
  BOTTOM w0.13: v2(153.67,14.29) 153.88,14.09 CN4100.228
M_A_DQ<56>: length 59.9
  L3 w0.076: 140.62,56.6 140.89,56.87 140.89,57.45 141.28,57.83 v1(141.28,57.92)
  L3 w0.097: 140.62,56.6 140.62,54.85 140.1,54.33 140.1,53.9 138.43,52.23 138.43,48.06 137.73,47.36 137.73,39.57 138.35,38.94 138.35,36.44 153.84,20.95 154.36,20.95 155.62,19.69 155.62,16.74 155.1,16.22 154.52,16.22 154.15,15.86 154.15,14.53 154.25,14.43 154.51,14.43 154.61,14.53 154.61,15.58 154.71,15.68 v2(154.92,15.68)
  BOTTOM w0.076: U4555.L31 v1(141.28,57.92)
  BOTTOM w0.13: v2(154.92,15.68) 155.2,15.68 155.74,15.13 155.74,13.77 155.88,13.64 CN4100.236
M_A_DQ<57>: length 60.7
  L3 w0.097: v2(155.14,14.22) 156.51,14.22 156.61,14.31 156.61,14.35 156.61,14.35 156.61,14.51 156.51,14.61 155.83,14.61 155.73,14.7 155.73,14.92 155.83,15.01 156.51,15.01 156.61,15.11 156.61,15.28 156.49,15.4 155.83,15.4 155.73,15.5 155.73,15.69 155.83,15.79 156.51,15.79 156.61,15.88 156.61,16.1 156.51,16.19 155.9,16.19 155.8,16.29 155.8,16.49 155.9,16.59 156.51,16.59 156.61,16.69 156.61,17.12 155.92,17.81 155.92,19.81 154.48,21.25 153.96,21.25 138.65,36.56 138.65,39.07 138.03,39.69 138.03,47.4 138.61,47.98 138.61,52.05 140.32,53.76 140.32,54.28 140.8,54.77 140.8,54.92 140.8,56.52 141.28,56.99 v1(141.28,57.31)
  BOTTOM w0.076: U4555.L32 v1(141.28,57.31)
  BOTTOM w0.13: v2(155.14,14.22) 154.88,13.95 CN4100.232
M_A_DQ<58>: length 58.6
  L3 w0.076: v1(142.19,59.13) 142.56,58.85 142.56,57.72 142.75,57.53 142.75,56.88
  L3 w0.097: 142.75,56.88 142.71,56.84 142.71,53.61 142.22,53.12 142.22,52.84 141.11,51.73 141.11,47.82 140.13,46.84 140.13,45.22 140.69,44.65 140.69,37.08 154.71,23.06 155.73,23.06 159.2,19.6 159.2,18.58 159.84,17.94 159.84,17.86 159.74,17.76 159.44,17.76 159.35,17.67 159.35,17.47 159.44,17.38 159.74,17.38 159.84,17.28 v1(159.84,16.75)
  BOTTOM w0.076: v1(142.19,59.13) U4555.N29
  BOTTOM w0.13: v1(159.84,16.75) 158.12,18.46 CN4100.245
M_A_DQ<59>: length 58.7
  L3 w0.076: 142.97,56.72 142.97,57.55 142.72,57.8 142.72,59.07 142.6,59.2 142.6,59.44 v2(142.19,59.8)
  L3 w0.097: v1(160.08,14.58) 160.08,15.8 160.39,16.11 160.39,18.83 155.86,23.36 154.84,23.36 140.99,37.21 140.99,44.74 140.38,45.35 140.38,46.7 141.34,47.67 141.34,51.65 142.46,52.77 142.46,53.06 142.97,53.57 142.97,56.72
  BOTTOM w0.076: v2(142.19,59.8) U4555.N28
  BOTTOM w0.13: v1(160.08,14.58) 159.38,13.88 CN4100.250
M_A_DQ<60>: length 56.1
  L3 w0.076: 140.23,56.11 140.23,56.71 140.52,57.01 140.52,57.57 140.74,57.78 140.74,59.31 v1(141.28,59.85)
  L3 w0.097: v2(154.85,18.69) 155.03,18.87 155.03,19.44 154.11,20.36 153.59,20.36 137.76,36.19 137.76,38.57 137.63,38.7 137.47,38.7 137.37,38.6 137.37,37.79 137.27,37.7 137.08,37.7 136.99,37.79 136.99,45.38 137.17,45.57 137.17,51.91 138.75,53.48 138.75,54.19 138.98,54.42 139.25,54.42 140.23,55.4 140.23,56.11
  BOTTOM w0.076: v1(141.28,59.85) U4555.L28
  BOTTOM w0.13: CN4100.233 155.26,20.7 155.26,19.74 155.31,19.69 155.31,19.18 154.85,18.71 v2(154.85,18.69)
M_A_DQ<61>: length 57.5
  L3 w0.076: 140.41,56.64 140.71,56.94 140.71,57.51 140.91,57.7 140.91,58.85 v1(141.28,59.24)
  L3 w0.097: 140.41,56.64 140.41,55.07 139.75,54.41 139.75,54.03 137.42,51.7 137.42,39.34 138.05,38.71 138.05,36.32 153.71,20.65 154.24,20.65 155.33,19.56 155.33,16.86 155.07,16.6 154.93,16.6 154.83,16.7 v2(154.83,17.24)
  BOTTOM w0.076: v1(141.28,59.24) U4555.L29
  BOTTOM w0.13: CN4100.237 156.12,18.53 v2(154.83,17.24)
M_A_DQ<62>: length 59
  L3 w0.076: v1(142.19,57.95) 142.19,57.85 142.57,57.47 142.57,57.02
  L3 w0.097: v2(158.7,18.79) 158.9,18.59 158.9,17.73 158.8,17.64 158.47,17.64 158,18.11 158,19.67 158,20.38 155.61,22.76 154.59,22.76 140.4,36.96 140.38,36.97 140.38,41.4 140.29,41.5 139.77,41.5 139.68,41.6 139.68,41.79 139.77,41.88 140.29,41.88 140.38,41.98 140.38,42.17 140.29,42.27 139.77,42.27 139.68,42.37 139.68,42.56 139.77,42.66 140.29,42.66 140.38,42.75 140.38,42.95 140.29,43.04 139.77,43.04 139.68,43.14 139.68,43.33 139.77,43.43 140.29,43.43 140.38,43.53 140.38,43.72 140.29,43.82 139.77,43.82 139.68,43.91 139.68,44.1 139.77,44.2 140.29,44.2 140.38,44.3 140.38,44.47 139.83,45.03 139.83,46.99 140.88,48.04 140.88,51.86 141.94,52.91 141.94,53.16 142.44,53.66 142.44,56.9 142.57,57.02
  BOTTOM w0.076: U4555.N31 v1(142.19,57.95)
  BOTTOM w0.13: CN4100.249 159.13,19.21 v2(158.7,18.79)
M_A_DQ<63>: length 60.2
  L3 w0.097: v1(142.19,57.31) 142.19,54.96 141.35,54.12 141.35,52.67 140.05,51.37 140.05,47.63 139.29,46.87 139.29,41.06 139.39,40.96 139.98,40.96 140.08,40.87 140.08,40.67 139.98,40.58 139.39,40.58 139.29,40.48 139.29,40.29 139.39,40.19 139.98,40.19 140.08,40.09 140.08,36.86 154.47,22.47 154.99,22.47 157.7,19.76 157.7,17.98 158.38,17.3 158.9,17.3 159.26,16.93 159.26,16.19 159.17,16.09 158.97,16.09 158.88,16.19 158.88,16.71 158.78,16.81 158.59,16.81 158.49,16.71 158.49,15.8 158.59,15.7 159.17,15.7 v1(159.26,15.61)
  BOTTOM w0.076: U4555.N32 v1(142.19,57.31)
  BOTTOM w0.13: v1(159.26,15.61) 159.26,15.19 158.38,14.3 CN4100.246
M_A_DQS0_DN: length 71.6
  L6 w0.109: v1(97.89,17.07) 97.89,17.23 98,17.35 98.31,17.35 98.6,17.65 98.6,18.99 98.3,19.3 98.19,19.3 98.08,19.41 98.08,19.73 98.19,19.84 98.37,19.84 98.6,20.08 98.6,20.58 98.37,20.81 98.19,20.81 98.08,20.92 98.08,21.25 98.19,21.36 98.37,21.36 98.6,21.59 98.6,23.31 99.3,24 99.77,24 122.43,46.66 122.43,47.21 122.66,47.44 122.66,47.46 126.67,51.47 126.67,52.56 126.67,57.66 127.9,58.89 128.3,58.89 129.45,60.05 129.45,60.36 v1(129.68,60.58)
  BOTTOM w0.076: U4555.C27 136.96,60.8 137.04,60.87 137.04,60.98 136.99,61.02 136.88,61.06 136.71,61.06 136.59,61.02 136.35,61.02 136.24,61.06 136.06,61.06 135.83,60.98 134.81,60.98 134.6,61.19 133.96,61.19 133.85,61.08 130.69,61.08 130.67,61.06 130.65,61.06
  BOTTOM w0.119: v1(97.89,17.07) 97.89,17.19 97.71,17.36 97.46,17.36 97.21,17.61 97.21,19.07 97.63,19.48 CN4100.11 ; 130.65,61.06 129.57,61.06 129.45,60.94 129.45,60.82 v1(129.68,60.58)
M_A_DQS0_DP: length 71.7
  L6 w0.109: v1(128.99,60.58) 129.24,60.33 129.24,60.14 128.21,59.11 127.82,59.11 126.46,57.75 126.46,52.47 126.46,51.56 122.45,47.55 122.45,47.52 122.22,47.3 122.22,46.75 99.68,24.21 99.21,24.21 98.39,23.39 98.39,21.68 98.28,21.57 98.1,21.57 97.87,21.33 97.87,20.83 98.1,20.6 98.28,20.6 98.39,20.49 98.39,20.16 98.28,20.05 98.1,20.05 97.87,19.82 97.87,19.32 98.1,19.09 98.21,19.09 98.39,18.9 98.39,17.74 98.22,17.56 98.03,17.56 97.89,17.71 v1(97.89,17.85)
  BOTTOM w0.076: 130.65,61.28 130.66,61.28 130.69,61.25 130.73,61.25 130.73,61.25 133.78,61.25 133.89,61.36 134.66,61.36 134.88,61.15 135.8,61.15 136.03,61.23 136.26,61.23 136.38,61.18 136.56,61.18 136.69,61.23 136.9,61.23 137.09,61.16 137.2,61.05 137.2,60.87 137.28,60.8 U4555.D27
  BOTTOM w0.119: v1(97.89,17.85) 97.89,17.7 97.77,17.58 97.56,17.58 97.44,17.7 97.44,18.98 98.13,19.67 CN4100.13 ; v1(128.99,60.58) 129.23,60.81 129.23,61.04 129.47,61.28 130.65,61.28
M_A_DQS1_DN: length 66.2
  L6 w0.109: v1(103.34,15.41) 103.15,15.6 102.94,15.6 102.59,15.95 102.59,21.7 125.72,44.83 125.72,45.51 130.1,49.89 130.1,55.12 130.31,55.33 130.31,55.8 130.1,56.01 130.1,56.58 130.72,57.2 132.04,57.2 132.11,57.27 v1(132.11,57.68)
  BOTTOM w0.076: U4555.D31 137.28,58.28 137.2,58.36 137.2,58.53 137.09,58.65 136.9,58.72 136.69,58.72 136.56,58.67 136.38,58.67 136.26,58.71 136.03,58.71 135.79,58.62 134.67,58.62 134.63,58.66 133.78,58.66 133.39,58.27 132.53,58.27 132.5,58.24
  BOTTOM w0.119: CN4100.32 102.88,13.53 103.15,13.81 103.15,13.92 103.84,14.61 103.84,15.48 103.69,15.63 103.58,15.63 103.36,15.41 v1(103.34,15.41) ; 132.5,58.24 132.43,58.18 132.43,58 v1(132.11,57.68)
M_A_DQS1_DP: length 66.2
  L6 w0.109: v1(103.34,16.21) 103.35,16.2 103.35,15.96 103.2,15.81 103.03,15.81 102.8,16.04 102.8,21.61 125.93,44.74 125.93,45.42 130.31,49.8 130.31,55.03 130.52,55.24 130.52,55.89 130.31,56.1 130.31,56.49 130.81,56.99 132.13,56.99 132.32,57.18 132.32,57.27 132.43,57.38 132.48,57.38 132.78,57.68 v2(132.85,57.68)
  BOTTOM w0.076: U4555.C31 136.96,58.28 137.04,58.36 137.04,58.46 136.99,58.51 136.88,58.55 136.71,58.55 136.59,58.5 136.36,58.5 136.24,58.55 136.06,58.55 135.82,58.46 134.6,58.46 134.56,58.5 133.85,58.5 133.46,58.11 132.73,58.11 132.65,58.03
  BOTTOM w0.119: CN4100.34 103.38,13.83 104.07,14.52 104.07,15.57 103.78,15.85 103.47,15.85 103.34,15.98 v1(103.34,16.21) ; 132.65,58.03 132.65,57.8 132.77,57.68 132.85,57.68 v2(132.85,57.68)
M_A_DQS2_DN: length 67.2
  L3 w0.109: v1(139.97,62.21) 139.76,62.42 139.76,62.65 139.53,62.87 137.8,62.87 135.92,60.99 135.92,59.48 133.61,57.17 131.11,57.17 129.47,55.54 129.47,35.07 142.93,21.62 143.2,21.62 145.7,19.12 145.7,17.84 146.82,16.72 146.82,15.73 146.71,15.62 146.54,15.62 v2(146.39,15.77)
  BOTTOM w0.076: v1(139.97,62.21) U4555.H24
  BOTTOM w0.119: CN4100.198 146.38,13.32 145.68,14.02 145.68,15.31 145.93,15.56 146.18,15.56 v2(146.39,15.77)
M_A_DQS2_DP: length 67.2
  L3 w0.109: v1(146.39,14.96) 146.39,15.2 146.6,15.41 146.8,15.41 147.03,15.64 147.03,16.81 145.91,17.93 145.91,19.21 143.29,21.83 143.02,21.83 129.68,35.16 129.68,55.45 131.19,56.96 133.7,56.96 136.13,59.4 136.13,60.9 137.89,62.66 139.45,62.66 139.55,62.56 139.55,62.42 v1(139.34,62.21)
  BOTTOM w0.076: v1(139.34,62.21) U4555.G24
  BOTTOM w0.119: CN4100.200 146.88,13.39 146.7,13.56 146.44,13.56 145.9,14.11 145.9,15.22 146.02,15.33 146.23,15.33 146.39,15.17 v1(146.39,14.96)
M_A_DQS3_DN: length 70.6
  L3 w0.109: v2(133.71,63.31) 133.53,63.5 133.53,63.7 133.23,63.99 128.72,63.99 127.81,63.07 127.81,62.87 125.94,61 125.94,31.06 136.27,20.72 136.94,20.72 137.84,19.81 139,19.81 139.7,19.12 139.7,18.77 139.81,18.66 139.81,18.24 139.61,18.04 139.61,17.57 139.98,17.2 141.1,17.2 v1(141.31,16.98)
  BOTTOM w0.076: v2(133.71,63.31) 133.67,63.18 133.67,63 133.75,62.92 134.57,62.92 134.77,63.12 135.85,63.12 136.06,63.05 136.24,63.05 136.35,63.09 136.59,63.09 136.72,63.05 136.88,63.05 136.99,63.09 137.04,63.13 137.04,63.24 136.96,63.31 U4555.C23
  BOTTOM w0.119: CN4100.177 141.13,19.57 140.73,19.18 140.73,18.19 140.6,18.06 140.6,17.4 140.85,17.16 141.14,17.16 v1(141.31,16.98)
M_A_DQS3_DP: length 70.6
  L3 w0.109: v1(141.31,17.73) 141.31,17.52 141.2,17.41 140.07,17.41 139.82,17.66 139.82,17.95 140.02,18.15 140.02,18.75 139.91,18.86 139.91,19.21 139.09,20.03 137.93,20.03 137.03,20.93 136.36,20.93 126.15,31.14 126.15,60.91 128.02,62.78 128.02,62.98 128.81,63.78 133.15,63.78 133.32,63.61 133.32,63.49 133.15,63.32 v1(133.03,63.31)
  BOTTOM w0.076: v1(133.03,63.31) 133.17,63.31 133.5,62.99 133.5,62.93 133.68,62.75 134.64,62.75 134.84,62.95 135.83,62.95 136.03,62.89 136.27,62.89 136.38,62.93 136.56,62.93 136.64,62.9 136.66,62.89 136.66,62.89 136.68,62.88 136.92,62.88 136.93,62.89 137.09,62.95 137.2,63.07 137.2,63.24 137.28,63.31 U4555.D23
  BOTTOM w0.119: CN4100.179 141.63,19.73 141.38,19.48 141.35,19.48 141.28,19.42 140.95,19.09 140.95,18.1 140.82,17.96 140.82,17.5 140.94,17.38 141.18,17.38 141.31,17.51 v1(141.31,17.73)
M_A_DQS4_DN: length 60
  L6 w0.109: v1(108.58,17.51) 108.42,17.67 108.04,17.67 107.8,17.91 107.8,19.33 108.27,19.8 108.27,20.17 107.8,20.64 107.8,21.25 110.77,24.21 111.17,24.21 131.76,44.8 131.76,46.34 135.55,50.14 136.09,50.14 v1(136.34,50.39)
  BOTTOM w0.076: U4555.J35 140.52,55.67 140.59,55.75 140.7,55.75 140.74,55.71 140.78,55.59 140.78,55.43 140.74,55.31 140.74,55.06 140.78,54.95 140.78,54.77 140.72,54.57 140.72,53.46 140.84,53.33 140.84,52.99 140.58,52.73 138.19,52.73 137.09,51.63 137.09,50.22 137.02,50.15 136.58,50.15 v1(136.34,50.39)
  BOTTOM w0.119: v1(108.58,17.51) 108.41,17.68 108.05,17.68 107.8,17.93 107.8,19.26 108.13,19.58 CN4100.53
M_A_DQS4_DP: length 60
  L6 w0.109: v1(108.58,18.26) 108.58,18.09 108.37,17.88 108.13,17.88 108.01,18 108.01,19.24 108.48,19.71 108.48,20.26 108.01,20.73 108.01,21.16 110.86,24 111.25,24 131.97,44.72 131.97,46.25 135.64,49.93 136.12,49.93 v1(136.34,49.7)
  BOTTOM w0.076: v1(136.34,49.7) 136.62,49.98 137.09,49.98 137.26,50.16 137.26,51.57 138.26,52.57 140.65,52.57 141,52.92 141,53.4 140.88,53.53 140.88,54.54 140.95,54.74 140.95,54.98 140.91,55.09 140.91,55.28 140.93,55.35 140.94,55.37 140.95,55.4 140.95,55.64 140.94,55.65 140.89,55.8 140.77,55.92 140.59,55.92 140.52,55.99 U4555.J34
  BOTTOM w0.119: CN4100.55 108.63,19.77 108.02,19.17 108.02,18.02 108.14,17.9 108.45,17.9 108.58,18.03 v1(108.58,18.26)
M_A_DQS5_DN: length 59.1
  L6 w0.089: 138.55,47.14 138.56,47.16 138.56,47.18 139.12,47.74 139.33,47.74 139.9,48.31 139.9,49.19 139.99,49.28 140.22,49.28 v1(140.45,49.04)
  L6 w0.109: v1(113.56,15.02) 113.82,15.27 114.25,15.27 115.35,16.38 115.35,22.31 117,23.96 117.46,23.96 136.54,43.05 136.54,45.14 138.55,47.14
  BOTTOM w0.076: v1(140.45,49.04) 140.76,49.35 140.96,49.35 141.14,49.52 141.14,50.36 143.58,52.81 143.58,53.38 143.4,53.56 143.4,54.57 143.46,54.74 143.46,54.98 143.42,55.09 143.42,55.28 143.45,55.35 143.46,55.37 143.46,55.37 143.47,55.4 143.47,55.64 143.46,55.65 143.4,55.8 143.28,55.92 143.11,55.92 143.04,55.99 U4555.P34
  BOTTOM w0.119: v1(113.56,15.02) 113.82,15.27 114.04,15.27 114.16,15.15 114.16,14.32 113.65,13.82 113.65,13.67 113.38,13.39 CN4100.74
M_A_DQS5_DP: length 59.2
  L6 w0.089: v2(140.46,49.71) 140.46,49.61 140.31,49.46 139.91,49.46 139.72,49.26 139.72,48.38 139.25,47.92 139.05,47.92 138.44,47.31 138.42,47.31 138.4,47.29
  L6 w0.109: 138.4,47.29 136.33,45.22 136.33,43.13 117.37,24.17 116.91,24.17 115.14,22.4 115.14,16.47 114.16,15.48 113.73,15.48 113.56,15.65 v1(113.56,15.87)
  BOTTOM w0.076: v2(140.46,49.71) 140.65,49.52 140.9,49.52 140.97,49.59 140.97,50.43 143.42,52.88 143.42,53.31 143.24,53.49 143.24,54.59 143.3,54.77 143.3,54.95 143.26,55.06 143.26,55.31 143.3,55.43 143.3,55.59 143.26,55.71 143.21,55.75 143.11,55.75 143.04,55.67 U4555.P35
  BOTTOM w0.119: CN4100.76 113.88,13.73 114.38,14.23 114.38,15.24 114.13,15.49 113.73,15.49 113.56,15.66 v1(113.56,15.87)
M_A_DQS6_DN: length 58.8
  L3 w0.076: 138.89,56.55 138.89,56.57 138.92,56.59 138.92,58.21 v1(138.54,58.58)
  L3 w0.109: 138.89,56.55 138.89,56.26 138.47,55.84 138.24,55.84 137.68,55.28 137.43,55.28 135.66,53.52 135.66,53.03 134.71,52.08 134.71,49.71 134.39,49.38 134.39,48.5 134.62,48.27 134.66,48.27 134.77,48.16 134.77,47.83 134.66,47.72 134.62,47.72 134.39,47.49 134.39,46.99 134.62,46.75 134.66,46.75 134.77,46.64 134.77,46.32 134.66,46.21 134.62,46.21 134.39,45.97 134.39,45.47 134.62,45.24 134.66,45.24 134.77,45.13 134.77,44.93 134.66,44.82 134.62,44.82 134.39,44.59 134.39,44.09 134.62,43.86 134.66,43.86 134.77,43.75 134.77,43.42 134.66,43.31 134.62,43.31 134.39,43.08 134.39,42.57 134.62,42.34 134.66,42.34 134.77,42.23 134.77,41.91 134.66,41.8 134.62,41.8 134.39,41.56 134.39,41.06 134.62,40.83 134.66,40.83 134.77,40.72 134.77,40.39 134.66,40.28 134.62,40.28 134.39,40.05 134.39,39.55 134.62,39.31 134.66,39.31 134.77,39.21 134.77,38.88 134.66,38.77 134.62,38.77 134.39,38.54 134.39,38.03 134.62,37.8 134.66,37.8 134.77,37.69 134.77,37.36 134.66,37.25 134.62,37.25 134.39,37.02 134.39,36.53 151.29,19.63 151.29,18.09 151.68,17.69 151.9,17.69 152.17,17.41 v2(152.17,17.18)
  BOTTOM w0.076: v1(138.54,58.58) U4555.G30
  BOTTOM w0.119: CN4100.219 151.63,19.59 151.48,19.45 151.48,17.94 151.77,17.66 152.07,17.66 152.17,17.55 v2(152.17,17.18)
M_A_DQS6_DP: length 58.8
  L3 w0.076: 139.1,56.55 139.1,56.57 139.08,56.59 139.08,58.65 139.16,58.72 139.31,58.72 v1(139.45,58.58)
  L3 w0.109: 139.1,56.55 139.1,56.17 138.56,55.62 138.32,55.62 137.77,55.07 137.51,55.07 135.88,53.43 135.88,52.94 134.92,51.99 134.92,49.62 134.6,49.29 134.6,48.59 134.71,48.48 134.74,48.48 134.98,48.25 134.98,47.74 134.74,47.51 134.71,47.51 134.6,47.4 134.6,47.07 134.71,46.96 134.74,46.96 134.98,46.73 134.98,46.23 134.74,46 134.71,46 134.6,45.89 134.6,45.56 134.71,45.45 134.74,45.45 134.98,45.22 134.98,44.85 134.74,44.61 134.71,44.61 134.6,44.5 134.6,44.18 134.71,44.07 134.74,44.07 134.98,43.83 134.98,43.33 134.74,43.1 134.71,43.1 134.6,42.99 134.6,42.66 134.71,42.55 134.74,42.55 134.98,42.32 134.98,41.82 134.74,41.59 134.71,41.59 134.6,41.48 134.6,41.15 134.71,41.04 134.74,41.04 134.98,40.81 134.98,40.3 134.74,40.07 134.71,40.07 134.6,39.96 134.6,39.63 134.71,39.53 134.74,39.53 134.98,39.29 134.98,38.79 134.74,38.56 134.71,38.56 134.6,38.45 134.6,38.12 134.71,38.01 134.74,38.01 134.98,37.78 134.98,37.28 134.74,37.04 134.71,37.04 134.6,36.93 134.6,36.61 151.5,19.71 151.5,18.17 151.77,17.9 152.06,17.9 152.17,18.01 v2(152.17,18.45)
  BOTTOM w0.076: v1(139.45,58.58) U4555.H30
  BOTTOM w0.119: v2(152.17,18.45) 152.17,18.02 152.03,17.88 151.86,17.88 151.7,18.04 151.7,19.36 152.13,19.78 CN4100.221
M_A_DQS7_DN: length 58.4
  L3 w0.076: 141.4,56.72 141.41,56.74 141.44,56.74 141.65,56.94 141.65,58.5 141.57,58.58 v2(141.28,58.58)
  L3 w0.109: 141.4,56.72 141.09,56.41 141.09,54.6 140.8,54.31 140.8,52.95 139.59,51.74 139.59,48.3 139.36,48.07 139.34,48.07 138.57,47.3 138.57,39.94 139.15,39.36 139.15,36.77 154.17,21.75 154.69,21.75 156.43,20.02 156.43,19.6 156.43,18.01 157.71,16.73 157.71,15.46 157.6,15.35 157.31,15.35 157.15,15.51 v1(157.15,15.71)
  BOTTOM w0.076: v2(141.28,58.58) U4555.L30
  BOTTOM w0.119: CN4100.240 156.88,13.58 156.41,14.04 156.41,15.08 156.66,15.33 156.92,15.33 157.15,15.56 v1(157.15,15.71)
M_A_DQS7_DP: length 58.4
  L3 w0.076: v1(142.19,58.55) 141.89,58.58 141.82,58.51 141.82,56.87 141.56,56.62 141.56,56.59 141.55,56.57
  L3 w0.109: 141.55,56.57 141.29,56.31 141.29,56.13 141.3,56.11 141.3,54.51 141.01,54.22 141.01,52.86 139.8,51.66 139.8,48.21 139.45,47.86 139.43,47.86 138.79,47.21 138.79,40.03 139.36,39.45 139.36,36.86 154.26,21.96 154.78,21.96 156.64,20.11 156.64,19.51 156.64,18.1 157.92,16.82 157.92,15.37 157.69,15.14 157.52,15.14 v1(157.15,14.77)
  BOTTOM w0.076: v1(142.19,58.55) U4555.N30
  BOTTOM w0.119: v1(157.15,14.77) 157.15,14.9 156.94,15.11 156.75,15.11 156.64,14.99 156.64,14.13 157.03,13.73 157.22,13.73 157.38,13.58 CN4100.242
M_A_PAR: length 53.7
  L6 w0.076: v1(145.83,57.95) 146.21,57.57 146.21,56.98
  L6 w0.089: 149.9,45.68 149.9,50.24 148.47,53.68 146.21,55.95 146.21,56.98
  L6 w0.117: 149.9,45.68 149.67,44.89 149.57,44.68 149.51,44.49 149.51,37.61 135.3,23.4 135.3,22.73 135.06,22.49 134.9,22.49 134.82,22.57 134.66,22.57 134.49,22.4 134.49,22.24 134.56,22.16 134.56,22 134.4,21.83 134.23,21.83 134.16,21.91 134,21.91 133.83,21.74 133.83,21.57 133.9,21.5 133.9,21.34 133.74,21.17 133.57,21.17 133.5,21.24 133.33,21.24 133.17,21.08 133.17,20.91 133.24,20.84 133.24,20.67 132.26,19.69 v2(132.26,18.03)
  BOTTOM w0.076: U4555.W31 v1(145.83,57.95)
  BOTTOM w0.16: v2(132.26,18.03) 132.26,18.56 130.63,20.19 CN4100.143
M_B_A_0: length 91.6
  L3 w0.089: 150.93,43.02 150.93,43.99 151.2,44.26 v1(151.2,45.86)
  L3 w0.117: v2(206.08,16.17) 206.08,16.04 206.31,15.81 206.78,15.81 207.04,16.07 207.04,23.17 201.59,28.62 164.19,28.62 160.06,32.74 158.73,32.74 158.72,32.75 158.72,32.75 150.42,41.06 150.42,42.52 150.93,43.02
  BOTTOM w0.076: U4555.AG36 151.4,55.02 151.4,54.83 151.5,54.65 151.5,54.38 151.3,54.17 151.3,53.72 151.48,53.54 151.48,51.19 150.77,50.48 150.77,46.28 v1(151.2,45.86)
  BOTTOM w0.16: CN4125.144 206.58,15.67 v2(206.08,16.17)
M_B_A_1: length 93.6
  L3 w0.089: 147.72,43.9 148.54,44.73 148.54,46.76 148.63,46.85 148.78,46.85 v1(148.87,46.76)
  L3 w0.117: v2(203.33,17.99) 203.22,17.88 203.22,17.6 203.09,17.46 202.84,17.46 202.38,17.92 202.38,21.5 202.06,21.82 202.06,21.99 202.32,22.25 202.32,22.41 202.15,22.58 201.99,22.58 201.73,22.32 201.56,22.32 201.4,22.49 201.4,22.65 201.66,22.91 201.66,23.07 201.49,23.24 201.32,23.24 201.07,22.98 200.9,22.98 200.74,23.15 200.74,23.31 200.99,23.57 200.99,23.73 200.83,23.9 200.66,23.9 200.31,23.54 200.05,23.54 199.93,23.66 199.93,23.83 200.33,24.23 200.33,24.39 200.17,24.56 200,24.56 199.43,23.99 199.27,23.99 197.67,25.59 165.13,25.59 162.62,25.59 158.49,29.72 157.47,29.72 147.39,39.8 147.39,43.58 147.72,43.9
  BOTTOM w0.076: U4555.AG35 151.02,55.61 151.02,55.4 150.97,55.28 150.97,55.09 151.01,54.98 151.01,54.74 150.97,54.6 150.97,53.58 151.15,53.41 151.15,51.32 150.44,50.62 150.44,47.48 149.73,46.77 148.87,46.77 v1(148.87,46.76)
  BOTTOM w0.16: v2(203.33,17.99) 203.83,18.49 CN4125.133
M_B_A_2: length 93.7
  L3 w0.089: 147.72,44.31 148.25,44.84 148.25,47.84 148.35,47.93 148.6,47.93 v1(148.88,47.66)
  L3 w0.117: 147.72,44.31 147.6,44.31 147.01,43.72 147.01,39.64 157.31,29.34 158.33,29.34 162.46,25.21 165.29,25.21 165.29,25.21 197.51,25.21 199.56,23.15 200.17,23.15 200.75,22.57 200.75,22.41 200.63,22.28 200.63,22.12 200.79,21.95 200.96,21.95 201.08,22.08 201.25,22.08 201.41,21.91 201.41,21.74 201.02,21.35 201.02,21.19 201.19,21.02 201.35,21.02 201.74,21.41 201.91,21.41 202,21.32 202,17.69 202.82,16.87 202.82,16.82 202.94,16.7 v2(203.35,16.7)
  BOTTOM w0.076: v1(148.88,47.66) 149.54,47.66 150.27,48.39 150.27,50.69 150.98,51.4 150.98,53.34 150.8,53.51 150.8,54.63 150.85,54.77 150.85,54.95 150.81,55.06 150.81,55.31 150.85,55.43 150.85,55.89 U4555.AF34
  BOTTOM w0.16: CN4125.132 203.58,15.4 203.35,16.58 v2(203.35,16.7)
M_B_A_3: length 92.9
  L3 w0.089: v1(148.93,45.75) 148.93,44.63 147.92,43.61
  L3 w0.117: v2(203.01,19.27) 202.88,19.27 202.77,19.39 202.77,19.61 202.88,19.72 203.14,19.72 203.25,19.84 203.25,20.07 203.14,20.19 202.88,20.19 202.77,20.31 202.77,20.54 202.88,20.66 203.14,20.66 203.25,20.78 203.25,21.01 203.14,21.13 202.88,21.13 202.77,21.24 202.77,21.68 202.88,21.8 203.04,21.8 203.16,21.92 203.16,22.26 203.25,22.36 203.25,22.94 203.16,23.04 203.16,23.16 202.89,23.42 202.73,23.42 202.36,23.05 202.19,23.05 202.02,23.22 202.02,23.38 202.4,23.76 202.4,23.92 202.23,24.09 202.07,24.09 201.69,23.71 201.53,23.71 201.36,23.88 201.36,24.04 201.74,24.42 201.74,24.58 201.57,24.75 201.41,24.75 201.03,24.37 200.87,24.37 200.7,24.54 200.7,24.7 201.08,25.08 201.08,25.24 200.91,25.41 200.75,25.41 200.37,25.04 200.21,25.04 200.04,25.2 200.04,25.37 200.41,25.74 200.41,25.9 200.35,25.97 199.42,25.97 199.3,25.86 199.3,25.18 199.19,25.07 198.95,25.07 198.84,25.18 198.84,25.86 198.72,25.97 164.97,25.97 164.97,25.97 162.78,25.97 158.65,30.1 157.63,30.1 147.78,39.96 147.78,43.47 147.92,43.61
  BOTTOM w0.076: U4555.AG37 151.24,54.35 151.13,54.24 151.13,53.65 151.31,53.47 151.31,51.25 150.61,50.55 150.61,46.9 150.48,46.77
  BOTTOM w0.16: v2(203.01,19.27) 203.17,19.27 203.33,19.43 CN4125.131 ; 150.48,46.77 149.45,45.75 v1(148.93,45.75)
M_B_A_4: length 92.4
  L3 w0.089: v1(148.87,49.14) 148.76,49.25 147.6,49.25 147.47,49.12 147.47,48.91 147.72,48.66 147.72,45.13
  L3 w0.117: 147.72,45.13 147.53,44.94 147.03,44.94 146.24,44.15 146.24,39.33 157,28.57 158.02,28.57 162.14,24.44 165.61,24.44 165.61,24.44 197.17,24.44 197.35,24.26 197.35,24.09 197.24,23.99 197.24,23.82 197.49,23.58 197.66,23.58 197.76,23.68 197.93,23.68 198.75,22.86 198.75,22.28 201.23,19.8 201.23,17.37 202.06,16.55 202.06,14.97 v1(202.7,14.32)
  BOTTOM w0.076: v1(148.87,49.14) 149.28,49.14 149.94,49.8 149.94,50.87 150.6,51.52 150.6,51.66 150.6,51.66 150.6,52.4 150.04,52.96 150.04,53.41 150.24,53.61 150.24,54.52 150.16,54.74 150.16,54.98 150.2,55.09 150.2,55.57 U4555.AE35
  BOTTOM w0.16: CN4125.128 202.58,14.19 v1(202.7,14.32)
M_B_A_5: length 91.2
  L3 w0.089: v1(148.88,48.24) 148.15,48.24 147.97,48.06 147.97,44.96 147.67,44.66 147.54,44.66
  L3 w0.117: v2(202.62,15.6) 202.44,15.78 202.44,16.71 201.62,17.53 201.62,20.02 200.24,21.39 200.24,22.53 200,22.77 199.38,22.77 197.33,24.82 165.45,24.82 162.3,24.82 158.17,28.95 157.15,28.95 146.63,39.49 146.63,44.12 147.17,44.66 147.54,44.66
  BOTTOM w0.076: U4555.AF35 150.36,55.29 150.36,55.07 150.32,54.95 150.32,54.77 150.4,54.55 150.4,53.54 150.21,53.35 150.21,53.03 150.77,52.47 150.77,51.73 150.77,51.42 150.11,50.76 150.11,48.98 149.37,48.24 v1(148.88,48.24)
  BOTTOM w0.16: CN4125.126 202.08,15.05 v2(202.62,15.6)
M_B_A_6: length 92.3
  L3 w0.117: v2(149.27,49.68) 149.15,49.56 148.43,49.56 148.28,49.71 148.28,49.98 148.16,50.1 147.88,50.1 147.76,49.98 147.76,49.7 147.64,49.57 147.43,49.57 147.27,49.73 147.27,50.24 147.15,50.35 146.92,50.35 146.8,50.24 146.8,45.25 145.86,44.31 145.86,39.17 156.84,28.19 157.86,28.19 161.99,24.06 165.76,24.06 196.28,24.06 199.16,21.17 199.44,21.05 200.85,19.64 200.85,17.17 v1(201.57,16.45)
  BOTTOM w0.076: v2(149.27,49.68) 149.78,50.18 149.78,51.05 150.43,51.71 150.43,52.33 149.87,52.89 149.87,53.49 150.04,53.65 150.04,54.43 U4555.AE37
  BOTTOM w0.16: CN4125.127 202.33,17.2 v1(201.57,16.45)
M_B_A_7: length 92.2
  L3 w0.076: v2(148.57,59.22) 148.2,58.85 148.2,56.55
  L3 w0.117: 148.2,56.55 148.13,56.11 147.89,54.68 146.05,50.24 146.05,46.98 145.19,44.89 145.09,44.8 145.09,38.85 156.52,27.42 157.54,27.42 161.67,23.29 166.08,23.29 194.98,23.29 195.74,22.53 195.74,21.86 195.92,21.68 199,20.4 200.02,19.39 200.02,17.42 v1(201.43,14.45)
  BOTTOM w0.076: v2(148.57,59.22) U4555.AC29
  BOTTOM w0.16: v1(201.43,14.45) 201.08,14.09 CN4125.122
M_B_A_8: length 92
  L3 w0.117: v1(200.43,18.35) 200.43,19.52 199.22,20.73 197.22,21.56 196.62,22.16 196.62,23.17 196.12,23.67 165.92,23.67 165.92,23.67 161.83,23.67 157.7,27.8 156.68,27.8 145.47,39.01 145.47,44.59 145.58,44.89 146.46,47.03 146.46,50.64 146.62,50.8 146.88,50.8 147,50.91 147,51.99 147.12,52.11 147.35,52.11 147.47,51.99 147.47,50.66 147.58,50.54 147.75,50.54 147.87,50.66 147.87,51.33 148.03,51.5 148.2,51.5 148.4,51.3 148.4,50.6 148.52,50.49 v1(149.07,50.49)
  BOTTOM w0.076: v1(149.07,50.49) 149.51,50.93 v3(149.51,51.43) 149.67,51.59 149.76,51.59 150.19,52.02 150.19,52.34 149.68,52.86 149.68,53.52 149.87,53.72 149.87,54.17 149.67,54.38 149.67,54.65 149.94,55.13 U4555.AE36
  BOTTOM w0.16: CN4125.125 201.83,19.74 v1(200.43,18.35)
M_B_A_9: length 89.4
  L3 w0.076: 147.29,56.97 147.29,58.75 v1(147.66,59.22)
  L3 w0.117: v1(199.22,17.96) 199.22,19.05 198.49,19.79 193.28,21.94 161.93,21.94 157.22,26.65 156.2,26.65 144.32,38.53 144.32,44.97 144.71,45.36 144.71,51.23 146.19,52.72 146.44,54.25 147.13,55.91 147.29,56.33 147.29,56.97
  BOTTOM w0.076: v1(147.66,59.22) U4555.AB29
  BOTTOM w0.16: v1(199.22,17.96) 200.83,19.56 CN4125.121
M_B_A_10: length 93.7
  L3 w0.089: 151.97,42.16 151.97,43.26 152.25,43.54 152.25,49.31 v1(151.2,50.36)
  L3 w0.117: v2(208.76,13.81) 209.59,14.64 209.59,14.82 209.45,14.95 209.32,14.95 209.18,15.09 209.18,15.28 209.32,15.42 209.69,15.42 209.83,15.57 209.83,15.76 209.7,15.89 209.32,15.89 209.18,16.02 209.18,16.22 209.32,16.36 209.45,16.36 209.59,16.49 209.59,19.93 208.57,20.95 208.57,23.81 202.23,30.15 164.83,30.15 160.7,34.28 160.38,34.28 159.37,34.28 152.15,41.5 151.97,41.67 151.97,42.16
  BOTTOM w0.076: v1(151.2,50.36) 151.64,50.8 151.64,53.61 151.46,53.79 151.46,54.11 151.67,54.31 151.67,54.69 151.57,54.87 151.57,55.5 151.51,55.56 151.51,56.01 151.24,56.28 U4555.AG34
  BOTTOM w0.16: CN4125.146 209.08,13.5 v2(208.76,13.81)
M_B_A_11: length 93.1
  L3 w0.076: 147.94,56.9 148.03,56.99 148.03,59.31 v1(148.57,59.88)
  L3 w0.117: 147.94,56.9 147.58,56.54 147.58,54.61 146.95,53.1 144.99,51.14 144.99,45.1 144.71,44.82 144.71,38.69 156.36,27.03 157.38,27.03 161.51,22.91 166.24,22.91 166.24,22.91 194.07,22.91 195.57,21.41 198.79,20.08 199.63,19.23 199.63,15.94 200.16,15.42 v1(200.16,14.43)
  BOTTOM w0.076: U4555.AC28 v1(148.57,59.88)
  BOTTOM w0.16: v1(200.16,14.43) 200.16,14.42 200.59,13.99 200.59,12.39 CN4125.120
