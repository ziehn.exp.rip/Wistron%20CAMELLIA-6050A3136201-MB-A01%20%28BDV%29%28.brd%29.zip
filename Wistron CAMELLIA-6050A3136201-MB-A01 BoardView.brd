# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A_12: length 93.2
  L3 w0.076: v1(147.66,59.85) 147.12,59.18 147.12,57.13 146.81,56.82
  L3 w0.117: 146.81,56.82 146.39,56.41 146.39,55.19 146.26,54.66 145.82,52.71 144.44,51.33 144.44,45.63 143.94,45.13 143.94,38.37 156.04,26.27 157.06,26.27 161.77,21.56 193.15,21.56 198.22,19.46 198.7,18.98 198.7,17.17 v1(199.22,16.65)
  BOTTOM w0.076: v1(147.66,59.85) U4555.AB28
  BOTTOM w0.16: v1(199.22,16.65) 198.78,17.09 198.78,18.31 198.79,18.31 200.33,19.85 CN4125.119
M_B_A_13: length 93.6
  L3 w0.089: v1(152.85,52.62) 153.8,51.67 153.8,49.03 154.13,48.7 154.13,45.75
  L3 w0.117: v2(212.8,16.28) 213.03,16.05 213.2,16.05 213.31,16.17 213.31,24.76 208.75,29.32 206.85,29.32 203.34,32.84 165.94,32.84 161.81,36.96 161.5,36.96 160.48,36.96 154.54,42.91 154.54,45.35 154.13,45.75
  BOTTOM w0.076: v1(152.85,52.62) 153.09,52.62 153.48,53.01 153.48,53.35 153.31,53.53 153.31,54.59 153.37,54.77 153.37,54.95 153.33,55.06 153.33,55.29 U4555.AK35
  BOTTOM w0.16: v2(212.8,16.28) 212.09,15.57 212.09,12.37 CN4125.158
M_B_A_14: length 92.6
  L3 w0.089: 152.67,43.24 152.67,45.1 152.76,45.19 152.88,45.19 152.97,45.27 152.97,45.54 152.88,45.63 152.76,45.63 152.67,45.71 152.67,45.98 152.76,46.07 152.95,46.07 153.03,46.16 153.03,46.42 152.95,46.51 152.76,46.51 152.67,46.6 152.67,46.78 v1(152.85,46.96)
  L3 w0.117: v2(210.39,19.2) 210.46,19.27 210.46,24.11 210.33,24.24 210.17,24.24 209.78,23.86 209.62,23.86 209.45,24.02 209.45,24.19 209.84,24.57 209.84,24.74 209.67,24.91 209.51,24.91 209.12,24.52 208.95,24.52 208.79,24.68 208.79,24.85 209.18,25.24 209.18,25.4 209.01,25.57 208.85,25.57 208.46,25.18 208.29,25.18 208.13,25.34 208.13,25.51 208.51,25.9 208.51,26.06 208.35,26.23 208.18,26.23 207.8,25.84 207.63,25.84 207.32,26.15 207.32,26.31 207.71,26.7 207.71,26.88 207.4,27.19 207.23,27.19 206.86,26.82 206.64,26.82 202.55,30.92 165.15,30.92 161.02,35.05 160.7,35.05 159.69,35.05 152.92,41.82 152.67,42.06 152.67,43.24
  BOTTOM w0.076: U4555.AJ35 152.67,55.61 152.67,55.39 152.72,55.27 152.72,55.09 152.67,54.98 152.67,54.74 152.76,54.52 152.76,53.6 152.3,53.15 152.3,47.5 v1(152.85,46.96)
  BOTTOM w0.16: v2(210.39,19.2) 210.33,19.26 CN4125.151
M_B_A_15: length 93.9
  L3 w0.089: v1(152.85,48.14) 153.25,47.73 153.25,45.26 153,45.01
  L3 w0.117: v2(210.39,15.73) 210.39,15.33 210.5,15.21 210.89,15.21 211.01,15.33 211.01,15.81 210.85,15.97 210.85,24.28 207.43,27.7 206.3,27.7 202.71,31.3 165.3,31.3 161.18,35.43 160.86,35.43 160.86,35.43 159.85,35.43 153.3,41.97 153,42.27 153,45.01
  BOTTOM w0.076: v1(152.85,48.14) 152.47,48.52 152.47,53.08 152.92,53.53 152.92,54.55 152.84,54.77 152.84,54.95 152.88,55.07 152.88,55.3 152.84,55.42 152.84,55.89 U4555.AK34
  BOTTOM w0.16: v2(210.39,15.73) 211.59,14.52 211.59,12.39 CN4125.156
M_B_A_16: length 92.9
  L3 w0.089: v1(151.2,49.1) 152.08,48.22 152.08,43.68 151.73,43.34 151.73,42.27 151.6,42.15
  L3 w0.117: v2(208.74,16.67) 208.81,16.61 208.97,16.61 209.21,16.84 209.21,19.77 208.19,20.79 208.19,23.65 202.07,29.77 164.67,29.77 160.54,33.9 160.22,33.9 160.22,33.9 159.21,33.9 151.77,41.34 151.59,41.52 151.59,42.13 151.6,42.15
  BOTTOM w0.076: U4555.AJ34 152.29,56.32 152.29,56.09 152.16,55.96 152.16,54.94 152.02,54.69 152.02,54.31 152.23,54.1 152.23,53.78 151.81,53.35 151.81,50.32 151.64,50.15
  BOTTOM w0.089: 151.64,50.15 151.64,49.52 v1(151.2,49.1)
  BOTTOM w0.16: v2(208.74,16.67) 210.59,14.04 210.59,12.37 CN4125.152
M_B_ACT#: length 92.1
  L3 w0.076: v1(145.83,59.85) 145.55,59.57 145.3,58.95 145.3,57.13 145.16,57 145.1,56.88
  L3 w0.117: 145.1,56.88 144.72,56.11 144.6,55.88 144.51,55.77 143.88,54.02 143.88,52.57 142.76,51.45 142.76,48.06 142.66,47.38 142.44,44.89 142.41,44.69 142.4,44.52 142.4,37.75 155.4,24.73 156.43,24.73 161.13,20.02 192.11,20.02 196.38,18.01 196.88,17.67 197.16,17 197.3,16.26 197.58,15.6 v1(197.75,15.43)
  BOTTOM w0.076: U4555.W28 146.21,60.08 v1(145.83,59.85)
  BOTTOM w0.16: CN4125.114 199.09,12.37 199.09,13.9 197.75,15.24 v1(197.75,15.43)
M_B_ALERT#: length 92.9
  L3 w0.076: v2(146.74,59.21) 146.37,58.85 146.37,56.88
  L3 w0.117: v1(198.91,14.81) 198.85,14.75 198.44,14.75 198.31,14.88 198.31,18.73 198.25,18.89 198,19.13 193.07,21.17 161.61,21.17 156.9,25.88 155.88,25.88 143.55,38.22 143.55,51.15 144.65,52.26 144.65,53.08 145.44,53.88 145.44,54.42 146.03,55 146.03,55.16 145.89,55.3 145.81,55.3 145.68,55.43 145.68,55.63 145.81,55.77 145.89,55.77 146.03,55.9 146.03,56.53 146.37,56.88
  BOTTOM w0.076: v2(146.74,59.21) U4555.Y29
  BOTTOM w0.16: v1(198.91,14.81) 199.54,14.18 199.54,12.41 CN4125.116
M_B_BG0: length 91.1
  L3 w0.076: 145.46,56.97 145.46,57.07 145.46,58.85 v1(145.83,59.22)
  L3 w0.117: 145.46,56.97 145.46,56.34 144.72,55.6 144.72,53.8 144.2,53.28 144.2,52.5 142.99,51.29 142.99,44.74 142.78,44.52 142.78,37.91 155.56,25.12 156.58,25.12 161.29,20.41 192.2,20.41 195.28,18.95 197.07,18.1 197.8,17.01 v1(197.8,16.92)
  BOTTOM w0.076: U4555.W29 v1(145.83,59.22)
  BOTTOM w0.16: v1(197.8,16.92) 198.25,17.36 198.25,18.38 199.33,19.46 CN4125.115
M_B_BG1: length 90.9
  L3 w0.076: v1(146.74,59.87) 146.48,59.85 146.21,59.57 146.21,57.05 146.12,56.96
  L3 w0.117: v2(197.8,18.7) 197.52,18.42 197.36,18.39 197.16,18.49 197.1,18.64 197.17,18.79 197.12,18.95 196.91,19.05 196.75,18.99 196.68,18.84 196.52,18.79 196.31,18.89 196.26,19.04 196.33,19.19 196.27,19.35 196.06,19.45 195.91,19.39 195.83,19.24 195.68,19.19 195.47,19.29 195.41,19.44 195.48,19.59 195.43,19.75 195.22,19.85 195.06,19.79 194.99,19.64 194.83,19.59 193.79,20.08 192.29,20.79 161.45,20.79 156.74,25.5 155.72,25.5 143.16,38.06 143.16,44.53 143.24,44.61 143.24,51.14 144.44,52.34 144.44,53.21 145.09,53.85 145.09,54.57 145.22,54.71 145.32,54.71 145.45,54.84 145.45,55.04 145.32,55.17 145.22,55.17 145.09,55.31 145.09,55.48 145.75,56.14 145.75,56.59 146.12,56.96
  BOTTOM w0.076: v1(146.74,59.87) U4555.Y28
  BOTTOM w0.16: v2(197.8,18.7) 198.45,19.36 198.83,19.74 CN4125.113
M_B_BS0: length 92.4
  L3 w0.089: v1(151.2,47.13) 151.59,46.74 151.59,44.14 151.22,43.78 151.22,42.78 150.8,42.36
  L3 w0.117: v2(208.74,15.37) 208.32,14.96 207.67,14.96 207.55,15.08 207.55,15.33 207.67,15.44 207.88,15.44 208,15.56 208,15.79 207.88,15.91 207.56,15.91 207.42,16.05 207.42,23.33 201.75,29 164.35,29 160.22,33.13 158.89,33.13 151,41.02 150.82,41.2 150.82,41.2 150.8,41.22 150.8,42.36
  BOTTOM w0.076: U4555.AJ37 152.56,54.43 152.56,53.64 152.14,53.22 152.14,48.07 v1(151.2,47.13)
  BOTTOM w0.16: CN4125.150 210.08,12.38 210.08,14.03 v2(208.74,15.37)
M_B_BS1: length 92.5
  L3 w0.089: 151.48,42.52 151.48,43.49 151.84,43.85 151.84,47.74 151.2,48.37 v1(151.2,48.4)
  L3 w0.117: 151.48,42.52 151.21,42.25 151.21,41.36 151.38,41.18 159.05,33.51 160.06,33.51 160.38,33.51 164.51,29.38 201.91,29.38 207.81,23.49 207.81,20.39 207.94,20.25 208.19,20.25 208.3,20.13 208.3,19.9 208.19,19.78 207.94,19.78 207.81,19.64 207.81,19.45 207.94,19.31 208.66,19.31 208.8,19.18 208.8,18.98 208.66,18.85 207.94,18.85 207.81,18.71 207.81,17.16 207.99,16.97 208.16,16.97 208.28,17.08 208.28,18.08 208.39,18.19 v2(208.74,18.19)
  BOTTOM w0.076: 151.9,49.1 151.97,49.17 151.97,53.29 152.39,53.71 152.39,54.17 152.19,54.38 152.19,54.65 152.45,55.13 U4555.AJ36
  BOTTOM w0.089: 151.9,49.1 v1(151.2,48.4)
  BOTTOM w0.16: CN4125.145 208.83,18.26 208.78,18.2 v2(208.74,18.19)
M_B_DQ<0>: length 55.6
  L6 w0.097: v2(171.77,16.23) 171.73,16.27 171.73,16.88 171.35,17.26 171.35,17.52 170.85,18.03 170.85,18.94 170,19.79 164.42,19.79 162.98,21.23 162.98,21.37 163.06,21.45 163.06,21.59 162.92,21.73 162.79,21.73 162.7,21.64 162.57,21.64 162.43,21.78 162.43,21.92 162.51,22 162.51,22.14 162.38,22.27 162.24,22.27 162.16,22.19 162.02,22.19 154.89,29.32 154.89,51.52 v1(154.21,52.21)
  BOTTOM w0.076: U4555.AN35 154.68,55.54 154.68,54.94 154.54,54.69 154.54,54.31 154.74,54.1 154.74,53.79 154.52,53.57 154.52,52.52 v1(154.21,52.21)
  BOTTOM w0.13: v2(171.77,16.23) 172.58,15.43 CN4125.8
M_B_DQ<1>: length 53.5
  L6 w0.097: v2(171.66,18.03) 171.14,18.55 171.14,19.06 170.12,20.08 165.08,20.08 164.74,20.42 164.21,20.42 164.03,20.6 164.03,20.73 164.16,20.86 164.16,21 164.03,21.14 163.89,21.14 163.76,21.01 163.62,21.01 163.49,21.14 163.49,21.28 163.62,21.41 163.62,21.55 155.19,29.97 155.19,52.15 v1(155.61,52.57)
  BOTTOM w0.076: v1(155.61,52.57) 155.61,52.6 156,52.99 156,53.31 155.82,53.49 155.82,54.59 155.88,54.77 155.88,54.95 155.84,55.06 155.84,55.31 155.89,55.43 155.89,55.93 155.94,55.99 155.94,56.25 155.7,56.48 U4555.AN34
  BOTTOM w0.13: v2(171.66,18.03) 172.33,18.7 CN4125.7
M_B_DQ<2>: length 55.7
  L6 w0.089: 156.63,50.93 156.63,48.26 157.26,47.64 157.26,44.37 157.65,43.98 157.65,43.97
  L6 w0.097: 157.65,43.97 157.65,36.71 157.65,30.54 165.13,23.06 171.14,23.06 174.75,19.45 174.75,15.84 v2(174.86,15.74) ; v1(155.61,51.95) 156.63,50.93
  BOTTOM w0.076: U4555.AR35 156.05,55.61 156.05,55.4 156.01,55.28 156.01,55.09 156.05,54.98 156.05,54.74 155.99,54.56 155.99,53.56 156.18,53.37 156.18,52.93 156.02,52.77 156.02,52.37 v1(155.61,51.95)
  BOTTOM w0.13: v2(174.86,15.74) 174.86,15.04 175.58,14.32 CN4125.20
M_B_DQ<3>: length 56.1
  L6 w0.089: 156.54,45.58 156.54,47.54 156.01,48.07 156.01,49.01 v1(155.61,49.41)
  L6 w0.097: v2(173.54,15.49) 173.49,15.54 173.49,15.98 173.65,16.14 173.65,16.43 173.49,16.59 173.49,18.6 170.79,21.3 165.58,21.3 156.76,30.13 156.76,37.08 156.76,43.75 156.4,44.1 156.4,45.44 156.54,45.58
  BOTTOM w0.076: U4555.AR34 156.27,56.29 156.54,56.02 156.54,55.45 156.61,55.38 156.61,54.85 156.7,54.69 156.7,54.31 156.51,54.12 156.51,53.75 156.77,53.49 156.77,52.82 156.52,52.57 156.52,51.39
  BOTTOM w0.089: 156.52,51.39 156.52,50.32 v1(155.61,49.41)
  BOTTOM w0.13: CN4125.16 174.58,13.52 174.61,13.55 174.61,14.43 v2(173.54,15.49)
M_B_DQ<4>: length 55
  L6 w0.097: v1(154.2,49.73) 154.19,49.72 154.19,29.13 164.13,19.19 164.35,19.19 164.44,19.1 164.44,18.77 164.54,18.68 164.73,18.68 164.83,18.77 164.83,19.1 164.93,19.19 165.12,19.19 165.21,19.1 165.21,18.65 165.31,18.55 165.5,18.55 165.6,18.65 165.6,19.1 165.7,19.19 165.89,19.19 165.99,19.1 165.99,18.65 166.08,18.55 166.28,18.55 166.37,18.65 166.37,19.1 166.47,19.19 166.66,19.19 166.76,19.1 166.76,18.65 166.86,18.55 167.05,18.55 167.15,18.65 167.15,19.1 167.24,19.19 167.43,19.19 167.53,19.1 167.53,18.65 167.63,18.55 167.82,18.55 167.92,18.65 167.92,19.1 168.01,19.19 168.21,19.19 168.3,19.1 168.3,18.65 168.4,18.55 168.59,18.55 168.69,18.65 168.69,19.1 168.79,19.19 169.56,19.19 v2(169.96,18.79)
  BOTTOM w0.076: v1(154.2,49.73) 154.72,50.25 154.72,50.56 154.87,50.71 154.87,53.44 155.07,53.65 155.07,54.43 U4555.AN37
  BOTTOM w0.13: v2(169.96,18.79) 170.7,18.79 171.34,19.43 171.34,20.81 CN4125.3
M_B_DQ<5>: length 55.3
  L6 w0.097: v2(171.77,14.7) 171.61,14.55 171.61,14.22 171.51,14.11 171.16,14.11 171.06,14.22 171.06,17.39 170.55,17.9 170.55,18.82 169.87,19.49 164.25,19.49 154.6,29.15 154.6,50.22 154.6,50.23 154.6,50.55 154.6,50.56 154.6,50.62 v1(154.21,51.01)
  BOTTOM w0.076: v1(154.21,51.01) 154.7,51.49 154.7,53.51 154.91,53.72 154.91,54.17 154.71,54.38 154.71,54.65 154.97,55.13 U4555.AN36
  BOTTOM w0.13: v2(171.77,14.7) 171.58,14.51 CN4125.4
M_B_DQ<6>: length 56.1
  L6 w0.089: 156.74,45.5 156.74,47.61 156.2,48.16 156.2,49.46 v1(155.61,50.05)
  L6 w0.097: v2(174.33,17.34) 173.91,17.77 173.91,18.62 170.92,21.6 170.48,21.6 170.39,21.7 170.39,21.85 170.29,21.95 170.1,21.95 170,21.85 170,21.7 169.9,21.6 169.71,21.6 169.61,21.7 169.61,21.85 169.52,21.95 169.32,21.95 169.23,21.85 169.23,21.7 169.13,21.6 168.94,21.6 168.84,21.7 168.84,21.85 168.74,21.95 168.55,21.95 168.45,21.85 168.45,21.7 168.36,21.6 168.17,21.6 168.07,21.7 168.07,21.77 167.97,21.86 167.78,21.86 167.68,21.77 167.68,21.7 167.59,21.6 167.39,21.6 167.3,21.7 167.3,21.85 167.2,21.95 167.01,21.95 166.91,21.85 166.91,21.7 166.81,21.6 166.62,21.6 166.52,21.7 166.52,21.85 166.43,21.95 166.23,21.95 166.14,21.85 166.14,21.7 166.04,21.6 165.71,21.6 157.06,30.25 157.06,36.95 157.06,43.73 156.59,44.19 156.59,45.35 156.74,45.5
  BOTTOM w0.076: 156.35,51.47 156.35,51.48 156.35,52.64 156.56,52.84 156.56,53.47 156.34,53.69 156.34,54.19 156.53,54.38 156.53,54.65 156.27,55.13 U4555.AR36
  BOTTOM w0.089: v1(155.61,50.05) 156.34,50.78 156.34,51.46 156.35,51.47
  BOTTOM w0.13: CN4125.21 175.83,18.84 v2(174.33,17.34)
M_B_DQ<7>: length 56.1
  L6 w0.089: 156.98,44.28 156.98,47.65 156.41,48.22 156.41,50.51
  L6 w0.097: v2(174.31,18.84) 174.31,19.47 174.17,19.61 174.04,19.61 173.77,19.34 173.64,19.34 173.5,19.48 173.5,19.61 173.76,19.88 173.76,20.02 173.63,20.15 173.49,20.15 173.23,19.89 173.09,19.89 172.95,20.02 172.95,20.16 173.22,20.42 173.22,20.56 173.08,20.7 172.94,20.7 172.68,20.43 172.54,20.43 172.41,20.57 172.41,20.71 172.67,20.97 172.67,21.11 172.54,21.24 172.4,21.24 172.13,20.98 172,20.98 171.86,21.12 171.86,21.25 172.13,21.52 172.13,21.65 171.99,21.79 171.85,21.79 171.59,21.53 171.45,21.53 171.32,21.66 171.32,21.8 171.58,22.06 171.58,22.2 171.02,22.76 170.38,22.76 170.28,22.66 170.28,22.57 170.18,22.47 169.99,22.47 169.89,22.57 169.89,22.66 169.8,22.76 169.6,22.76 169.51,22.66 169.51,22.57 169.41,22.47 169.22,22.47 169.12,22.57 169.12,22.66 169.02,22.76 168.83,22.76 168.73,22.66 168.73,22.57 168.64,22.47 168.45,22.47 168.35,22.57 168.35,22.66 168.25,22.76 168.06,22.76 167.96,22.66 167.96,22.57 167.87,22.47 167.67,22.47 167.58,22.57 167.58,22.66 167.48,22.76 167.29,22.76 167.19,22.66 167.19,22.57 167.09,22.47 166.9,22.47 166.8,22.57 166.8,22.66 166.71,22.76 166.52,22.76 166.34,22.58 166.02,22.58 165.94,22.66 165.07,22.66 157.35,30.38 157.35,36.83 157.35,36.83 157.35,43.9 156.98,44.28 ; v1(155.61,51.32) 156.41,50.51
  BOTTOM w0.076: U4555.AR37 156.27,54.39 156.17,54.29 156.17,53.67 156.17,53.62 156.39,53.4 156.39,52.91 156.19,52.71 156.19,51.9 v1(155.61,51.32)
  BOTTOM w0.13: v2(174.31,18.84) 174.83,19.36 CN4125.17
M_B_DQ<8>: length 56.6
  L6 w0.097: v1(157.27,51.68) 158.1,50.85 158.1,45 159.04,44.06 159.04,37.66 163.89,32.81 163.89,32.68 163.82,32.6 163.82,32.47 163.95,32.33 164.09,32.33 164.16,32.4 164.3,32.4 164.44,32.27 164.44,32.13 164.36,32.06 164.36,31.92 164.5,31.78 164.64,31.78 164.71,31.86 164.85,31.86 164.98,31.72 164.98,31.58 164.91,31.51 164.91,31.37 165.05,31.24 165.18,31.24 165.26,31.31 165.39,31.31 165.53,31.17 165.53,31.04 165.46,30.96 165.46,30.83 165.59,30.69 165.73,30.69 165.8,30.77 165.94,30.77 166.08,30.63 166.08,30.49 166,30.42 166,30.28 166.14,30.15 166.27,30.15 166.35,30.22 166.48,30.22 166.62,30.08 166.62,29.95 166.55,29.87 166.55,29.74 166.68,29.6 166.82,29.6 166.89,29.67 167.03,29.67 167.17,29.54 167.17,29.4 167.09,29.33 167.09,29.19 167.23,29.05 167.37,29.05 167.44,29.13 167.58,29.13 167.71,28.99 167.71,28.85 167.64,28.78 167.64,28.64 167.78,28.51 167.91,28.51 167.99,28.58 168.12,28.58 168.26,28.44 168.26,28.31 168.19,28.23 168.19,28.1 168.32,27.96 168.46,27.96 168.53,28.04 168.67,28.04 168.81,27.9 168.81,27.76 168.73,27.69 168.73,27.55 168.87,27.41 169,27.41 169.08,27.49 169.22,27.49 169.35,27.35 169.35,27.22 169.28,27.14 169.28,27.01 169.41,26.87 169.55,26.87 169.63,26.94 169.76,26.94 169.9,26.81 169.9,26.67 169.82,26.6 169.82,26.46 169.96,26.32 170.1,26.32 170.17,26.4 170.31,26.4 170.44,26.26 170.44,26.12 170.37,26.05 170.37,25.91 170.51,25.78 170.64,25.78 170.72,25.85 170.85,25.85 170.99,25.71 170.99,25.58 170.92,25.5 170.92,25.37 171.05,25.23 171.47,25.23 172.26,24.45 172.82,24.45 176.82,20.45 176.82,17.75 v2(176.44,17.37)
  BOTTOM w0.076: U4555.AU35 157.67,55.65 157.67,55.49 157.75,55.28 157.75,55.09 157.71,54.98 157.71,54.74 157.78,54.54 157.78,53.58 157.58,53.38 157.58,52.67 157.65,52.59 157.65,52.06 v1(157.27,51.68)
  BOTTOM w0.13: v2(176.44,17.37) 177.83,18.75 CN4125.29
M_B_DQ<9>: length 56.4
  L6 w0.097: v1(177.08,15.67) 177.04,15.67 175.57,17.14 175.57,19.75 170.67,24.66 170.12,24.66 170.04,24.58 169.9,24.58 169.77,24.72 169.77,24.86 169.84,24.93 169.84,25.07 169.71,25.2 169.57,25.2 169.49,25.13 169.36,25.13 169.22,25.27 169.22,25.4 169.3,25.48 169.3,25.61 169.16,25.75 169.02,25.75 168.95,25.68 168.81,25.68 168.68,25.81 168.68,25.95 168.75,26.02 168.75,26.16 168.62,26.3 168.48,26.3 168.4,26.22 168.27,26.22 168.13,26.36 168.13,26.49 168.21,26.57 168.21,26.71 168.07,26.84 167.93,26.84 167.86,26.77 167.72,26.77 167.58,26.9 167.58,27.04 167.66,27.12 167.66,27.25 167.52,27.39 167.39,27.39 167.31,27.31 167.17,27.31 167.04,27.45 167.04,27.59 167.11,27.66 167.11,27.8 166.98,27.94 166.84,27.94 166.76,27.86 166.63,27.86 166.49,28 166.49,28.13 166.57,28.21 166.57,28.34 166.43,28.48 166.29,28.48 166.22,28.41 166.08,28.41 165.95,28.54 165.95,28.68 166.02,28.75 166.02,28.89 158.45,36.47 158.45,44.05 157.7,44.79 157.7,48.1 v1(157.27,48.53)
  BOTTOM w0.076: 156.7,52.04 156.7,52.51 156.71,52.53 157.07,52.89 157.07,53.58 157.28,53.78 157.28,54.09 157.06,54.31 157.06,54.69 157.19,54.94 157.19,55.88 U4555.AU34
  BOTTOM w0.089: v1(157.27,48.53) 156.7,49.1 156.7,52.04
  BOTTOM w0.13: CN4125.28 177.58,13.58 177.51,13.64 177.51,15.24 v1(177.08,15.67)
M_B_DQ<10>: length 58.1
  L6 w0.089: 160.28,43.76 160.28,43.97 159.32,44.94 159.32,49.56 v2(158.58,50.3)
  L6 w0.097: v1(179.62,15.69) 179.62,16.53 178.29,17.87 178.29,22.03 177.8,22.51 177.8,22.65 178.03,22.87 178.03,23.01 177.89,23.15 177.75,23.15 177.53,22.92 177.39,22.92 177.25,23.06 177.25,23.2 177.48,23.42 177.48,23.56 177.34,23.69 177.21,23.69 176.98,23.47 176.84,23.47 176.71,23.61 176.71,23.74 176.93,23.97 176.93,24.1 176.8,24.24 176.66,24.24 176.43,24.01 176.3,24.01 176.16,24.15 176.16,24.29 176.39,24.51 176.39,24.65 176.25,24.79 176.11,24.79 175.89,24.56 175.75,24.56 175.62,24.7 175.62,24.83 175.84,25.06 175.84,25.2 175.7,25.33 175.57,25.33 175.34,25.11 175.21,25.11 174.32,25.99 172.44,25.99 160.28,38.15 160.28,43.76
  BOTTOM w0.076: v2(158.58,50.3) 159.29,51.02 159.29,53.5 159.02,53.77 159.02,54.12 159.22,54.31 159.22,54.69 159.12,54.87 159.12,55.5 U4555.AW35
  BOTTOM w0.13: CN4125.38 180.08,15.24 v1(179.62,15.69)
M_B_DQ<11>: length 56.6
  L6 w0.097: v1(157.27,50.41) 157.89,49.79 157.89,44.9 158.74,44.05 158.74,37 159.07,36.67 159.21,36.67 159.33,36.8 159.47,36.8 159.6,36.66 159.6,36.52 159.48,36.4 159.48,36.26 159.62,36.13 159.75,36.13 159.88,36.25 160.01,36.25 160.15,36.11 160.15,35.98 160.03,35.85 160.03,35.72 160.16,35.58 160.3,35.58 160.42,35.7 160.56,35.7 160.69,35.57 160.69,35.43 160.57,35.31 160.57,35.17 160.71,35.04 160.85,35.04 160.97,35.16 161.1,35.16 161.24,35.02 161.24,34.88 161.12,34.76 161.12,34.63 161.26,34.49 161.39,34.49 161.51,34.61 161.65,34.61 161.79,34.47 161.79,34.34 161.67,34.22 161.67,34.08 161.8,33.94 161.94,33.94 162.06,34.06 162.2,34.06 162.33,33.93 162.33,33.79 162.21,33.67 162.21,33.53 162.35,33.4 162.48,33.4 162.61,33.52 162.74,33.52 162.88,33.38 162.88,33.25 162.76,33.12 162.76,32.99 162.89,32.85 163.03,32.85 163.15,32.97 163.29,32.97 163.42,32.84 163.42,32.7 163.3,32.58 163.3,32.44 163.53,32.22 163.53,32.08 163.46,32.01 163.46,31.88 163.59,31.74 163.73,31.74 163.8,31.81 163.93,31.81 164.07,31.67 164.07,31.54 164,31.47 164,31.33 164.14,31.19 164.27,31.19 164.34,31.26 164.48,31.26 164.62,31.13 164.62,30.99 164.55,30.92 164.55,30.78 164.68,30.65 164.82,30.65 164.89,30.72 165.03,30.72 165.16,30.58 165.16,30.44 165.09,30.38 165.09,30.24 165.23,30.1 165.37,30.1 165.44,30.17 165.57,30.17 165.71,30.04 165.71,29.9 165.64,29.83 165.64,29.69 165.78,29.56 165.91,29.56 165.98,29.63 166.12,29.63 166.26,29.49 166.26,29.35 166.19,29.28 166.19,29.15 166.32,29.01 166.46,29.01 166.53,29.08 166.67,29.08 166.8,28.94 166.8,28.81 166.73,28.74 166.73,28.6 166.87,28.46 167.01,28.46 167.07,28.53 167.21,28.53 167.35,28.4 167.35,28.26 167.28,28.19 167.28,28.05 167.41,27.92 167.55,27.92 167.62,27.99 167.76,27.99 167.89,27.85 167.89,27.71 167.82,27.64 167.82,27.51 167.96,27.37 168.1,27.37 168.17,27.44 168.3,27.44 168.44,27.3 168.44,27.17 168.37,27.1 168.37,26.96 168.54,26.79 168.96,26.79 175.87,19.88 175.87,19.31 v2(176.41,18.76)
  BOTTOM w0.076: v1(157.27,50.41) 157.65,50.79 157.65,51.71 157.82,51.88 157.82,52.73 157.75,52.81 157.75,53.32 157.95,53.52 157.95,54.55 157.87,54.77 157.87,54.95 157.92,55.07 157.92,55.3 157.84,55.5 157.84,56.29 158.04,56.48 U4555.AW34
  BOTTOM w0.13: CN4125.25 176.83,19.17 v2(176.41,18.76)
M_B_DQ<12>: length 56.5
  L6 w0.089: v1(157.27,52.31) 158.36,52.59 158.73,52.59 159.33,51.99 159.85,51.17 159.85,45.17 161.18,43.84 161.18,43.62
  L6 w0.097: v2(180.43,18.81) 180.43,18.63 180.26,18.47 179.95,18.47 179.84,18.58 179.84,19.26 179.93,19.36 180.09,19.36 180.19,19.46 180.19,19.65 180.09,19.74 179.93,19.74 179.84,19.84 179.84,20.03 179.93,20.13 180.09,20.13 180.19,20.23 180.19,20.42 180.09,20.52 179.93,20.52 179.84,20.61 179.84,20.81 179.93,20.9 180.09,20.9 180.19,21 180.19,21.19 180.09,21.29 179.93,21.29 179.84,21.39 179.84,21.58 179.93,21.68 180.09,21.68 180.19,21.77 180.19,21.96 180.09,22.06 179.93,22.06 179.84,22.16 179.84,22.74 179.93,22.84 180.24,22.84 180.34,22.93 180.34,23.13 180.24,23.22 179.93,23.22 179.84,23.32 179.84,23.44 179.72,23.56 179.72,23.69 179.81,23.78 179.81,23.91 179.67,24.05 179.53,24.05 179.45,23.96 179.31,23.96 179.17,24.1 179.17,24.24 179.26,24.32 179.26,24.46 179.12,24.6 178.99,24.6 178.9,24.51 178.76,24.51 178.63,24.65 178.63,24.78 178.71,24.87 178.71,25.01 178.58,25.14 178.44,25.14 178.35,25.06 178.22,25.06 178.08,25.19 178.08,25.33 178.17,25.42 178.17,25.55 178.03,25.69 177.89,25.69 177.81,25.6 177.67,25.6 177.53,25.74 177.53,25.88 177.62,25.96 177.62,26.1 177.48,26.24 177.35,26.24 177.26,26.15 177.12,26.15 176.39,26.88 172.81,26.88 161.18,38.51 161.18,43.62
  BOTTOM w0.076: v1(157.27,52.31) 157.41,52.45 157.41,53.44 157.61,53.64 157.61,54.41 U4555.AU37
  BOTTOM w0.13: v2(180.43,18.81) 180.83,19.21 CN4125.41
M_B_DQ<13>: length 56.2
  L6 w0.089: 157.51,47.73 156.87,48.37 156.87,49.38 v1(157.27,49.77)
  L6 w0.097: v2(176.1,14.78) 176.1,15.47 175.25,16.32 175.25,19.65 170.62,24.29 169.76,24.29 165.35,28.7 165.35,28.83 165.42,28.91 165.42,29.04 165.28,29.18 165.15,29.18 165.07,29.11 164.94,29.11 164.8,29.24 164.8,29.38 164.88,29.45 164.88,29.59 164.74,29.73 164.6,29.73 164.53,29.65 164.39,29.65 164.25,29.79 164.25,29.93 164.33,30 164.33,30.14 164.19,30.27 164.06,30.27 163.98,30.2 163.85,30.2 163.71,30.33 163.71,30.47 163.78,30.55 163.78,30.68 163.65,30.82 163.51,30.82 163.44,30.74 163.3,30.74 163.16,30.88 163.16,31.02 163.24,31.09 163.24,31.23 163.1,31.36 162.96,31.36 162.89,31.29 162.75,31.29 162.62,31.43 162.62,31.56 162.69,31.64 162.69,31.77 162.55,31.91 162.42,31.91 162.34,31.84 162.21,31.84 162.07,31.97 162.07,32.11 162.15,32.18 162.15,32.32 162.01,32.46 161.87,32.46 161.8,32.38 161.66,32.38 161.52,32.52 161.52,32.66 161.6,32.73 161.6,32.87 161.46,33 161.33,33 161.25,32.93 161.11,32.93 160.98,33.07 160.98,33.2 161.05,33.28 161.05,33.41 160.92,33.55 160.78,33.55 160.71,33.47 160.57,33.47 160.43,33.61 160.43,33.75 160.51,33.82 160.51,33.96 160.37,34.1 160.23,34.1 160.16,34.02 160.02,34.02 159.79,34.26 159.79,34.39 159.84,34.45 159.84,34.59 159.7,34.72 159.57,34.72 159.51,34.67 159.38,34.67 158.15,35.9 158.15,43.95 157.51,44.59 157.51,47.73
  BOTTOM w0.076: U4555.AU36 157.49,55.13 157.22,54.65 157.22,54.38 157.44,54.16 157.44,53.71 157.24,53.51 157.24,52.82 156.88,52.46 156.88,52.42
  BOTTOM w0.089: v1(157.27,49.77) 156.88,50.17 156.88,52.42
  BOTTOM w0.13: v2(176.1,14.78) 176.58,14.3 CN4125.24
M_B_DQ<14>: length 57.1
  L6 w0.089: v1(158.58,51.57) 159.5,50.65 159.5,45.02 160.58,43.93 160.58,43.73
  L6 w0.097: v1(180.55,14.57) 180.55,16.41 179.2,17.77 179.2,19.09 179.1,19.19 178.84,19.19 178.74,19.29 178.74,19.48 178.84,19.58 179.1,19.58 179.2,19.67 179.2,19.87 179.1,19.96 178.84,19.96 178.74,20.06 178.74,20.25 178.84,20.35 179.1,20.35 179.2,20.44 179.2,20.64 179.1,20.73 178.84,20.73 178.74,20.83 178.74,21.02 178.84,21.12 179.1,21.12 179.2,21.22 179.2,21.41 179.1,21.51 178.84,21.51 178.74,21.6 178.74,21.8 178.84,21.89 179.1,21.89 179.2,21.99 179.2,22.57 175.48,26.29 172.56,26.29 160.58,38.26 160.58,43.73
  BOTTOM w0.076: v1(158.58,51.57) 159.13,52.12 159.13,53.43 158.86,53.7 158.86,54.19 159.05,54.38 159.05,54.65 158.95,54.83 158.95,55.02 U4555.AW36
  BOTTOM w0.13: CN4125.42 181.08,14.05 v1(180.55,14.57)
M_B_DQ<15>: length 56.4
  L6 w0.089: v1(158.57,52.2) 159.67,51.1 159.67,45.1 160.88,43.89 160.88,43.63
  L6 w0.097: v1(180.45,17.37) 180.07,17.37 179.52,17.92 179.52,22.67 179.36,22.83 179.36,22.97 179.53,23.15 179.53,23.29 179.4,23.42 179.26,23.42 179.08,23.24 178.95,23.24 178.81,23.38 178.81,23.52 179.01,23.71 179.01,23.85 178.87,23.98 178.73,23.98 178.54,23.79 178.4,23.79 178.26,23.92 178.26,24.06 178.46,24.26 178.46,24.39 178.32,24.53 178.19,24.53 177.99,24.33 177.85,24.33 177.72,24.47 177.72,24.61 177.91,24.8 177.91,24.94 177.78,25.08 177.64,25.08 177.44,24.88 177.31,24.88 177.17,25.02 177.17,25.15 177.37,25.35 177.37,25.49 177.23,25.62 177.09,25.62 176.9,25.43 176.76,25.43 176.62,25.56 176.62,25.7 176.82,25.9 176.82,26.03 176.68,26.17 176.55,26.17 176.35,25.97 176.22,25.97 175.6,26.59 172.68,26.59 160.88,38.39 160.88,43.63
  BOTTOM w0.076: U4555.AW37 158.69,54.44 158.69,53.62 158.96,53.35 158.96,52.59 v1(158.57,52.2)
  BOTTOM w0.13: CN4125.37 179.83,17.99 v1(180.45,17.37)
M_B_DQ<16>: length 98.2
  L3 w0.076: 153.11,56.11 153.11,56.66 152.75,57.02 152.75,58.68 v2(152.21,59.22)
  L3 w0.097: v1(215.7,15.63) 215.8,15.73 215.95,15.73 216.05,15.83 216.05,16.02 215.95,16.12 215.8,16.12 215.7,16.21 215.7,24.51 209.39,30.82 207.61,30.82 204.1,34.33 166.56,34.33 162.43,38.46 162.12,38.46 162.12,38.46 161.1,38.46 156.05,43.51 156.05,45.88 155.19,46.74 155.19,53.7 153.11,55.78 153.11,56.11
  BOTTOM w0.076: v2(152.21,59.22) 152.56,59.41 U4555.AJ29
  BOTTOM w0.13: v1(215.7,15.63) 215.7,15.62 216.24,15.08 216.24,13.63 216.08,13.47 CN4125.174
M_B_DQ<17>: length 98.1
  L3 w0.076: v1(152.21,58.56) 152.59,58.18 152.59,56.65 152.85,56.39 152.85,56.19
  L3 w0.097: 152.85,56.19 152.85,54.91 155.01,52.75 155.01,46.61 155.75,45.86 155.75,43.39 160.98,38.17 161.99,38.17 161.99,38.16 162.31,38.16 166.44,34.04 203.98,34.04 207.49,30.53 209.24,30.53 215.03,24.74 215.03,24.15 214.94,24.05 214.88,24.05 214.78,23.95 214.78,23.76 214.88,23.66 215.08,23.66 215.18,23.57 215.18,21.83 214.52,21.17 214.52,20.83 214.61,20.73 215.31,20.73 215.41,20.64 215.41,20.44 215.31,20.35 214.61,20.35 214.52,20.25 214.52,20.06 214.61,19.96 215.31,19.96 215.41,19.86 215.41,19.67 215.31,19.58 214.61,19.58 214.52,19.48 214.52,18.42 214.61,18.32 v2(215.26,18.32)
  BOTTOM w0.076: v1(152.21,58.56) 152.56,58.77 U4555.AJ30
  BOTTOM w0.13: v2(215.26,18.32) 215.69,18.32 215.83,18.46 CN4125.173
M_B_DQ<18>: length 98.8
  L3 w0.076: v1(154.04,57.31) 153.96,57.23 153.96,56.15
  L3 w0.097: 153.96,56.15 153.96,56.04 156.46,53.54 156.46,47.14 157.29,46.31 157.29,44 161.61,39.68 162.62,39.68 162.62,39.68 162.94,39.68 166.96,35.66 204.67,35.66 208.24,32.09 209.93,32.09 216.94,25.08 216.94,23.57 217.7,22.81 217.7,22.13 217.12,21.55 217.12,20.14 217.22,20.05 217.81,20.05 217.91,19.95 217.91,19.76 217.81,19.66 217.22,19.66 217.12,19.56 217.12,19.37 217.22,19.27 217.81,19.27 217.91,19.18 217.91,14.97 218.4,14.48 v1(218.72,14.48)
  BOTTOM w0.076: U4555.AM32 v1(154.04,57.31)
  BOTTOM w0.13: CN4125.182 218.08,13.83 v1(218.72,14.48)
M_B_DQ<19>: length 99.1
  L3 w0.076: 154.88,56.35 154.88,57 154.04,57.84 v1(154.04,57.95)
  L3 w0.097: v1(219.18,15.74) 218.2,16.71 218.2,20.26 218.11,20.36 217.53,20.36 217.44,20.45 217.44,20.65 217.53,20.74 218.11,20.74 218.2,20.84 218.2,21.03 218.11,21.13 217.53,21.13 217.44,21.23 217.44,21.44 218,22 218,22.93 217.23,23.69 217.23,25.2 210.05,32.38 208.48,32.38 208.48,32.38 208.36,32.38 204.79,35.96 167.08,35.96 163.06,39.98 162.75,39.98 162.74,39.98 161.73,39.98 157.59,44.12 157.59,46.35 156.66,47.28 156.66,53.61 156.5,53.77 156.5,54.3 154.88,55.92 154.88,56.35
  BOTTOM w0.076: U4555.AM31 v1(154.04,57.95)
  BOTTOM w0.13: CN4125.186 219.08,13.95 219.18,14.05 v1(219.18,15.74)
M_B_DQ<20>: length 99.7
  L3 w0.076: v1(154.04,58.58) 154.44,58.17 154.44,57.68 155.19,56.94 155.19,56.51
  L3 w0.097: v1(219.13,17.27) 219.13,17.11 218.93,16.91 218.6,16.91 218.5,17.01 218.5,24.2 218.41,24.3 218.21,24.3 218.12,24.2 218.12,23.63 218.02,23.53 217.83,23.53 217.73,23.63 217.73,25.37 210.42,32.68 208.49,32.68 204.91,36.25 167.21,36.25 163.19,40.28 162.87,40.28 162.87,40.28 161.85,40.28 157.89,44.24 157.89,46.4 156.88,47.41 156.88,52.47 157.28,52.88 157.28,54.1 155.19,56.19 155.19,56.51
  BOTTOM w0.076: U4555.AM30 v1(154.04,58.58)
  BOTTOM w0.13: v1(219.13,17.27) 218.33,18.07 CN4125.183
M_B_DQ<21>: length 99.7
  L3 w0.076: v1(154.04,59.22) 154.62,58.63 154.62,57.73 155.53,56.83 155.53,56.68
  L3 w0.097: v2(219.12,18.72) 218.86,18.98 218.86,19.17 218.96,19.27 219.08,19.27 219.17,19.36 219.17,19.56 219.08,19.65 218.96,19.65 218.86,19.75 218.86,19.94 218.96,20.04 219.17,20.04 219.27,20.14 219.27,20.33 219.17,20.43 218.96,20.43 218.86,20.52 218.86,20.72 218.96,20.81 219.17,20.81 219.27,20.91 219.27,21.1 219.17,21.2 218.96,21.2 218.86,21.3 218.86,21.49 218.96,21.58 219.17,21.58 219.27,21.68 219.27,21.87 219.17,21.97 218.96,21.97 218.86,22.07 218.86,22.74 218.96,22.84 219.21,22.84 219.31,22.93 219.31,23.18 219.21,23.28 218.91,23.28 218.81,23.38 218.81,23.57 218.91,23.67 219.21,23.67 219.31,23.76 219.31,23.96 219.21,24.05 218.91,24.05 218.81,24.15 218.81,24.34 218.91,24.44 219.21,24.44 219.31,24.53 219.31,24.68 219.01,24.98 218.88,24.98 218.49,24.6 218.16,24.6 218.03,24.72 218.03,24.96 218.24,25.17 218.24,25.31 210.58,32.98 208.61,32.98 205.04,36.55 167.33,36.55 163.31,40.57 162.99,40.57 162.99,40.57 161.98,40.57 158.18,44.37 158.18,46.65 157.71,47.12 157.71,52.43 157.5,52.64 157.5,54.14 155.53,56.11 155.53,56.68
  BOTTOM w0.076: U4555.AM29 v1(154.04,59.22)
  BOTTOM w0.13: v2(219.12,18.72) 219.2,18.72 219.33,18.85 CN4125.187
M_B_DQ<22>: length 96.5
  L3 w0.076: v1(152.21,57.94) 152.2,57.94 151.84,57.58 151.84,56.75 152.3,56.29 152.3,56.12
  L3 w0.097: 152.3,56.12 152.3,54.72 154.63,52.38 154.63,46.09 155.15,45.57 155.15,43.15 160.73,37.57 161.75,37.57 161.75,37.57 162.06,37.57 166.19,33.44 203.63,33.44 207.14,29.93 209,29.93 213.92,25.01 213.92,15.89 v1(215.45,14.36)
  BOTTOM w0.076: v1(152.21,57.94) 152.21,57.95 U4555.AJ31
  BOTTOM w0.13: CN4125.170 215.08,13.99 v1(215.45,14.36)
M_B_DQ<23>: length 96.9
  L3 w0.076: 152.62,56.11 152.62,56.27 152.21,56.68 152.21,57.29 v1(152.21,57.31)
  L3 w0.097: 152.62,56.11 152.62,54.76 154.82,52.56 154.82,46.38 155.45,45.74 155.45,43.27 160.86,37.87 161.87,37.87 161.87,37.87 162.19,37.87 166.32,33.74 203.75,33.74 207.27,30.23 209.12,30.23 214.22,25.13 214.22,23.68 214.83,23.07 214.83,21.95 214.22,21.34 214.22,16.67 214.44,16.45 215.02,16.45 215.25,16.67 v1(215.25,16.84)
  BOTTOM w0.076: v1(152.21,57.31) 152.22,57.31 U4555.AJ32
  BOTTOM w0.13: v1(215.25,16.84) 214.94,16.84 214.74,17.03 214.74,20.74 CN4125.169
M_B_DQ<24>: length 99
  L3 w0.076: 155.74,56.9 155.47,57.17 155.47,57.56 v1(155.86,57.95)
  L3 w0.097: v1(220.4,14.54) 219.79,14.54 219.69,14.64 219.69,14.85 219.81,14.96 219.97,14.96 220.09,15.07 220.09,15.23 219.97,15.35 219.81,15.35 219.69,15.46 219.69,19.86 219.83,20 219.83,24.87 213.42,31.28 213.02,31.28 210.77,33.53 208.76,33.53 205.24,37.05 167.54,37.05 163.51,41.07 163.2,41.07 163.2,41.07 162.18,41.07 161.95,41.3 158.48,44.78 158.48,46.74 157.96,47.25 157.96,52.67 157.75,52.88 157.75,54.25 155.77,56.22 155.77,56.88 155.74,56.9
  BOTTOM w0.076: U4555.AR31 v1(155.86,57.95)
  BOTTOM w0.13: v1(220.4,14.54) 220.93,14.54 221.08,14.4 CN4125.194
M_B_DQ<25>: length 98.5
  L3 w0.097: v1(220.56,15.89) 220.29,15.62 220.16,15.62 219.99,15.78 219.99,15.97 220.09,16.06 220.14,16.06 220.24,16.16 220.24,16.35 220.14,16.45 220.09,16.45 219.99,16.54 219.99,16.74 220.12,16.87 220.12,17.13 219.99,17.26 219.99,19.74 220.12,19.87 220.12,24.99 213.54,31.58 213.14,31.58 210.84,33.88 208.83,33.88 205.37,37.35 167.66,37.35 163.64,41.37 163.32,41.37 162.31,41.37 158.78,44.9 158.78,46.78 158.15,47.41 158.15,52.42 158.54,52.81 158.54,53.76 156,56.3 156,57.17 v1(155.86,57.31)
  BOTTOM w0.076: U4555.AR32 v1(155.86,57.31)
  BOTTOM w0.13: v1(220.56,15.89) 220.25,15.89 219.9,15.54 219.9,14.12 220.08,13.95 CN4125.190
M_B_DQ<26>: length 101.6
  L3 w0.076: 158.67,56.11 158.64,56.15 158.64,57.15 158.06,57.73 158.06,58.51 157.98,58.58 v1(157.68,58.58)
  L3 w0.097: v2(223.89,17.94) 223.89,17.74 223.79,17.64 223.28,17.64 223.18,17.74 223.18,18.12 223.28,18.21 223.36,18.21 223.46,18.31 223.46,18.5 223.36,18.6 223.28,18.6 223.18,18.69 223.18,18.89 223.28,18.98 223.36,18.98 223.46,19.08 223.46,19.27 223.36,19.37 223.28,19.37 223.18,19.47 223.18,19.66 223.28,19.76 223.72,19.76 223.81,19.85 223.81,20.05 223.72,20.14 223.28,20.14 223.18,20.24 223.18,20.44 223.27,20.53 223.74,20.53 223.84,20.63 223.84,20.82 223.74,20.92 223.27,20.92 223.18,21.02 223.18,21.21 223.27,21.31 223.85,21.31 223.95,21.4 223.95,21.59 223.84,21.69 223.27,21.69 223.18,21.79 223.18,25.35 214.54,33.98 214.14,33.98 211.81,36.31 210.59,36.31 207.15,39.75 168.66,39.75 164.64,43.78 163.3,43.78 161.2,45.87 161.2,51.89 161.64,52.33 161.64,53.4 159.52,55.52 159.27,55.52 158.67,56.11
  BOTTOM w0.089: U4555.AV30 v1(157.68,58.58)
  BOTTOM w0.13: CN4125.207 224.33,18.37 v2(223.89,17.94)
M_B_DQ<27>: length 101.8
  L3 w0.076: v1(157.68,59.22) 158.08,59.22 158.26,59.04 158.26,57.76 158.82,57.2 158.82,56.23
  L3 w0.097: 158.82,56.23 159.3,55.74 159.56,55.74 161.99,53.31 161.99,52.22 161.51,51.73 161.51,46 161.98,45.53 162.12,45.53 162.35,45.76 162.49,45.76 162.63,45.62 162.63,45.49 162.39,45.25 162.39,45.12 162.53,44.98 162.66,44.98 162.9,45.21 163.04,45.21 163.17,45.08 163.17,44.94 163,44.77 163,44.64 163.57,44.07 164.77,44.07 168.78,40.05 207.45,40.05 210.89,36.61 211.93,36.61 214.26,34.28 214.77,34.28 223.7,25.35 223.7,25.21 223.54,25.05 223.54,24.91 223.68,24.78 223.81,24.78 223.98,24.94 224.11,24.94 224.51,24.55 224.51,24.49 224.41,24.39 223.6,24.39 223.5,24.29 223.5,24.1 223.6,24 224.41,24 224.51,23.91 224.51,23.71 224.41,23.62 223.6,23.62 223.5,23.52 223.5,23.33 223.6,23.23 224.41,23.23 224.51,23.13 224.51,22.87 224.41,22.77 224.23,22.77 224.14,22.67 224.14,22.48 224.23,22.38 224.41,22.38 224.51,22.29 224.51,22.09 224.41,22 224.29,22 224.19,21.9 224.19,21.76 224.34,21.61 224.41,21.61 224.51,21.52 224.51,21.23 224.19,19.7 v2(223.85,19.37)
  BOTTOM w0.089: U4555.AV29 v1(157.68,59.22)
  BOTTOM w0.13: CN4125.203 223.33,19.63 223.59,19.37 v2(223.85,19.37)
M_B_DQ<28>: length 100.2
  L3 w0.076: 156.23,56.33 156.23,58.21 v1(155.86,58.58)
  L3 w0.097: v2(220.73,17.2) 220.47,17.2 220.29,17.38 220.29,19.61 220.42,19.75 220.42,19.85 220.52,19.94 220.69,19.94 220.79,20.04 220.79,20.23 220.69,20.33 220.52,20.33 220.42,20.42 220.42,20.62 220.52,20.71 220.69,20.71 220.79,20.81 220.79,21 220.69,21.1 220.52,21.1 220.42,21.2 220.42,21.39 220.52,21.49 220.69,21.49 220.79,21.58 220.79,21.78 220.69,21.87 220.52,21.87 220.42,21.97 220.42,22.16 220.52,22.26 220.69,22.26 220.79,22.35 220.79,22.55 220.69,22.64 220.52,22.64 220.42,22.74 220.42,22.93 220.52,23.03 220.69,23.03 220.79,23.13 220.79,23.32 220.69,23.42 220.52,23.42 220.42,23.51 220.42,23.71 220.52,23.8 220.69,23.8 220.79,23.9 220.79,24.09 220.69,24.19 220.52,24.19 220.42,24.29 220.42,25.12 213.66,31.87 213.27,31.87 210.96,34.17 208.96,34.17 205.49,37.64 167.78,37.64 163.76,41.66 163.44,41.66 163.44,41.67 162.43,41.67 159.08,45.02 159.08,47.81 158.97,47.92 158.97,52.55 158.72,52.8 158.72,53.84 156.23,56.33
  BOTTOM w0.076: U4555.AR30 v1(155.86,58.58)
  BOTTOM w0.13: v2(220.73,17.2) 220.33,17.61 CN4125.191
M_B_DQ<29>: length 100.5
  L3 w0.076: 157.37,56.11 157.37,56.28 156.79,56.87 156.66,56.87 156.4,57.13 156.4,58.68 v1(155.86,59.22)
  L3 w0.097: v2(220.83,18.62) 220.83,18.55 221.07,18.32 221.23,18.32 221.35,18.44 221.35,19.97 221.09,20.23 221.09,20.45 221.26,20.62 221.26,20.84 221.09,21.01 221.09,21.22 221.26,21.39 221.26,21.61 221.09,21.78 221.09,21.99 221.26,22.16 221.26,22.38 221.09,22.55 221.09,22.77 221.26,22.94 221.26,23.15 221.09,23.32 221.09,23.54 221.26,23.71 221.26,23.92 221.09,24.09 221.09,24.31 221.26,24.48 221.26,24.7 213.79,32.17 213.39,32.17 211.09,34.47 209.08,34.47 209,34.56 209,34.69 209.23,34.92 209.23,35.06 209.09,35.2 208.95,35.2 208.72,34.97 208.59,34.97 208.45,35.1 208.45,35.24 208.68,35.47 208.68,35.61 208.54,35.74 208.41,35.74 208.18,35.51 208.04,35.51 207.9,35.65 207.9,35.78 207.93,35.81 207.93,35.95 207.79,36.08 207.66,36.08 207.63,36.06 207.49,36.06 207.36,36.19 207.36,36.33 207.59,36.56 207.59,36.7 207.45,36.83 207.32,36.83 207.08,36.6 206.95,36.6 206.81,36.74 206.81,36.88 207.04,37.11 207.04,37.24 206.91,37.38 206.77,37.38 206.54,37.15 206.4,37.15 205.61,37.94 167.91,37.94 163.88,41.96 163.57,41.96 162.55,41.96 159.38,45.14 159.38,48.31 159.15,48.53 159.15,52.89 159.01,53.04 159.01,53.98 157.37,55.62 157.37,56.11
  BOTTOM w0.076: U4555.AR29 v1(155.86,59.22)
  BOTTOM w0.13: v2(220.83,18.62) 221.15,18.62 221.33,18.79 CN4125.195
M_B_DQ<30>: length 100
  L3 w0.097: v2(223.98,14.44) 223.8,14.26 223.54,14.26 223.42,14.38 223.42,15.92 223.32,16.02 222.84,16.02 222.57,16.29 222.57,16.4 222.67,16.49 223.2,16.49 223.29,16.59 223.29,16.78 223.2,16.88 222.67,16.88 222.57,16.98 222.57,25.11 214.29,33.39 213.89,33.39 211.56,35.72 210.34,35.72 206.91,39.16 168.41,39.16 164.39,43.18 162.98,43.18 160.63,45.53 160.63,52.34 161.06,52.77 161.06,53.46 159.37,55.15 159.08,55.15 158.21,56.02 158.21,56.78 v1(157.68,57.31)
  BOTTOM w0.089: U4555.AV32 v1(157.68,57.31)
  BOTTOM w0.13: CN4125.204 223.58,14.19 223.82,14.44 v2(223.98,14.44)
M_B_DQ<31>: length 100.4
  L3 w0.076: 158.43,57.03 158.43,57.11 157.68,57.85 v1(157.68,57.95)
  L3 w0.097: v2(224.19,15.74) 224.04,15.59 223.84,15.59 223.75,15.69 223.75,16.85 223.81,16.91 224.05,16.91 224.14,17.01 224.14,17.24 224.05,17.34 223.43,17.34 223.27,17.18 222.98,17.18 222.88,17.27 222.88,25.22 214.42,33.69 214.02,33.69 211.69,36.02 210.47,36.02 207.03,39.46 168.54,39.46 164.51,43.48 163.14,43.48 160.91,45.71 160.91,52.13 161.35,52.57 161.35,53.43 159.45,55.33 159.16,55.33 158.43,56.06 158.43,57.03
  BOTTOM w0.089: U4555.AV31 v1(157.68,57.95)
  BOTTOM w0.13: v2(224.19,15.74) 224.58,15.35 CN4125.208
M_B_DQ<32>: length 57.9
  L6 w0.089: v1(160.24,52.32) 161.01,51.54 161.01,45.25 162.58,43.69
  L6 w0.097: v2(182.36,18.74) 182.05,19.04 182.05,19.36 182.15,19.45 182.81,19.45 182.91,19.55 182.91,19.74 182.81,19.84 182.15,19.84 182.05,19.94 182.05,20.13 182.15,20.23 182.86,20.23 182.95,20.32 182.95,20.52 182.86,20.61 182.15,20.61 182.05,20.71 182.05,20.9 182.15,21 182.89,21 182.99,21.09 182.99,21.29 182.89,21.38 182.15,21.38 182.05,21.48 182.05,21.67 182.15,21.77 182.54,21.77 182.64,21.87 182.64,22.06 182.54,22.16 182.15,22.16 182.05,22.25 182.05,22.45 182.15,22.54 182.54,22.54 182.64,22.64 182.64,22.83 182.54,22.93 182.15,22.93 182.05,23.03 182.05,23.63 181.16,24.53 177.41,28.27 173.38,28.27 162.58,39.08 162.58,43.69
  BOTTOM w0.076: U4555.BA35 160.19,55.65 160.19,55.49 160.27,55.28 160.27,55.09 160.22,54.98 160.22,54.74 160.3,54.54 160.3,53.58 159.96,53.24 159.96,52.6 v1(160.24,52.32)
  BOTTOM w0.13: CN4125.45 181.83,19.27 v2(182.36,18.74)
M_B_DQ<33>: length 58.2
  L6 w0.097: v1(182.57,14.45) 181.69,14.45 181.16,14.98 181.16,20.14 181.06,20.23 180.86,20.23 180.77,20.33 180.77,20.52 180.86,20.62 181.06,20.62 181.16,20.72 181.16,20.91 181.06,21.01 180.86,21.01 180.77,21.1 180.77,21.3 180.86,21.39 181.06,21.39 181.16,21.49 181.16,23.26 177.04,27.38 173.01,27.38 161.68,38.72 161.68,43.74 160.39,45.03 160.39,48.99 v2(160.24,49.15)
  BOTTOM w0.076: U4555.BA34 159.71,55.88 159.71,54.94 159.58,54.69 159.58,54.31 159.79,54.09 159.79,53.78 159.46,53.45 159.46,49.93 v2(160.24,49.15)
  BOTTOM w0.13: v1(182.57,14.45) 182.08,13.95 CN4125.46
M_B_DQ<34>: length 58.2
  L6 w0.097: v2(186.08,14.59) 186.27,14.79 186.27,15.04 186.18,15.14 185.71,15.14 185.62,15.24 185.62,15.43 185.71,15.52 186.18,15.52 186.27,15.62 186.27,15.85 186.18,15.95 186.08,15.95 185.98,16.04 185.98,16.24 186.08,16.33 186.18,16.33 186.27,16.43 186.27,23.01 178.9,30.38 174.26,30.38 164.71,39.93 164.71,44.26 163.69,45.29 163.69,47.44 v1(163.45,47.68)
  BOTTOM w0.076: 162.68,48.45 162.68,50.88 162.61,50.94 162.61,50.97 161.91,51.67 161.91,53.38 161.54,53.75 161.54,54.12 161.73,54.31 161.73,54.69 161.64,54.85 161.64,55.49 U4555.BC35
  BOTTOM w0.089: 162.68,48.45 v1(163.45,47.68)
  BOTTOM w0.13: CN4125.62 v2(186.08,14.59)
M_B_DQ<35>: length 58.4
  L6 w0.097: v2(184.7,14.87) 185.97,16.98 185.97,22.23 185.43,23.43 178.78,30.09 174.14,30.09 164.41,39.81 164.41,44.22 163.35,45.29 162.49,47.52 v1(161.9,48.11)
  BOTTOM w0.076: 160.74,51.86 160.58,52.52 160.27,52.84 160.27,53.32 160.47,53.52 160.47,54.55 160.39,54.77 160.39,54.95 160.43,55.07 160.43,55.3 160.36,55.5 160.36,56.29 160.55,56.48 U4555.BC34
  BOTTOM w0.089: v1(161.9,48.11) 161.62,48.39 160.96,49.5 160.74,49.98 160.74,51.86
  BOTTOM w0.13: v2(184.7,14.87) 185.08,14.33 CN4125.58
M_B_DQ<36>: length 56.7
  L6 w0.089: v1(160.24,51.13) 160.8,50.49 160.8,45.15 162.28,43.68
  L6 w0.097: v1(182.38,17.32) 182.27,17.21 182.27,16.9 182.37,16.8 182.95,16.8 183.05,16.71 183.05,16.52 182.95,16.42 182.37,16.42 182.27,16.32 182.27,16.27 182.15,16.15 181.87,16.15 181.75,16.26 181.75,23.51 177.29,27.97 173.26,27.97 162.28,38.96 162.28,43.68
  BOTTOM w0.076: v1(160.24,51.13) 159.79,51.5 159.79,53.3 160.13,53.64 160.13,54.41 U4555.BA37
  BOTTOM w0.13: v1(182.38,17.32) 182.83,17.77 CN4125.49
M_B_DQ<37>: length 57.3
  L6 w0.089: v2(160.24,50.47) 160.63,50.03 160.63,45.05 161.98,43.7
  L6 w0.097: 161.98,43.7 161.98,38.84 173.14,27.68 177.17,27.68 181.46,23.39 181.46,15.14 181.55,15.04 181.98,15.04 182.14,15.21 182.14,15.73 182.3,15.89 v1(182.56,15.89)
  BOTTOM w0.076: v2(160.24,50.47) 159.62,51.03 159.62,53.38 159.96,53.71 159.96,54.16 159.74,54.38 159.74,54.65 160,55.13 U4555.BA36
  BOTTOM w0.13: v1(182.56,15.89) 183.08,15.38 CN4125.50
M_B_DQ<38>: length 56.9
  L6 w0.097: v1(161.9,46.25) 161.9,45.95 163.8,44.06 163.8,39.58 173.89,29.49 178.07,29.49 185.15,22.41 185.15,21.65 185.04,21.54 184.78,21.54 184.66,21.43 184.66,21.27 184.78,21.16 185.04,21.16 185.15,21.04 185.15,20.88 185.04,20.77 184.78,20.77 184.66,20.66 184.66,20.5 184.78,20.38 185.04,20.38 185.15,20.27 185.15,20.11 185.04,20 184.78,20 184.68,19.9 184.68,19.71 184.78,19.61 185.04,19.61 185.15,19.5 185.15,17.72 v2(185.56,17.32)
  BOTTOM w0.076: U4555.BC36 161.47,55.02 161.47,54.83 161.57,54.65 161.57,54.38 161.37,54.19 161.37,53.69 161.75,53.31 161.75,51.6 162.45,50.9 162.45,50.88 162.47,50.85 162.47,46.83 v1(161.9,46.25)
  BOTTOM w0.13: CN4125.63 186.33,18.08 v2(185.56,17.32)
M_B_DQ<39>: length 56.1
  L6 w0.097: v1(161.9,47.47) 162.13,47.47 162.31,47.3 162.31,45.92 164.09,44.14 164.09,39.71 174.01,29.79 178.19,29.79 178.3,29.68 178.56,29.68 178.7,29.54 178.7,29.28 178.81,29.17 178.95,29.17 179.04,29.26 179.18,29.26 179.32,29.13 179.32,28.99 179.22,28.89 179.22,28.76 179.36,28.62 179.5,28.62 179.59,28.72 179.73,28.72 179.86,28.58 179.86,28.44 179.77,28.35 179.77,28.21 179.9,28.08 180.04,28.08 180.14,28.17 180.27,28.17 180.41,28.03 180.41,27.9 180.31,27.8 180.31,27.67 180.45,27.53 180.59,27.53 180.68,27.62 180.82,27.62 180.96,27.49 180.96,27.35 180.86,27.26 180.86,27.12 181,26.98 181.13,26.98 181.23,27.08 181.36,27.08 181.5,26.94 181.5,26.8 181.41,26.71 181.41,26.57 181.54,26.44 181.68,26.44 181.77,26.53 181.91,26.53 182.05,26.4 182.05,26.26 181.95,26.16 181.95,26.03 182.09,25.89 182.23,25.89 182.32,25.99 182.46,25.99 182.59,25.85 182.59,25.71 182.5,25.62 182.5,25.48 182.64,25.34 182.77,25.34 182.87,25.44 183,25.44 183.14,25.3 183.14,25.17 183.05,25.07 183.05,24.94 183.18,24.8 183.32,24.8 183.41,24.89 183.55,24.89 183.69,24.76 183.69,24.62 183.59,24.53 183.59,24.39 183.73,24.25 183.86,24.25 183.96,24.35 184.1,24.35 184.23,24.21 184.23,24.07 184.14,23.98 184.14,23.84 184.27,23.71 184.41,23.71 184.5,23.8 184.64,23.8 184.78,23.66 184.78,23.53 184.68,23.43 184.68,23.3 185.45,22.53 185.45,21.62 185.58,21.48 185.58,21.17 185.45,21.04 185.45,18.82 v2(185.56,18.71)
  BOTTOM w0.076: v1(161.9,47.47) 162.31,47.86 162.31,50.78 162.28,50.81 162.28,50.83 161.58,51.53 161.58,51.64 161.58,53.24 161.21,53.62 161.21,54.29 161.3,54.39 U4555.BC37
  BOTTOM w0.13: v2(185.56,18.71) 185.56,19.32 185.33,19.56 CN4125.59
M_B_DQ<40>: length 60.2
  L6 w0.097: v1(163.45,52.03) 164.12,52.03 166.32,49.83 166.32,47.62 167.94,46 167.94,41.23 175.57,33.6 181.56,33.6 183.75,31.41 183.75,31.27 183.65,31.17 183.65,31.03 183.79,30.9 183.93,30.9 184.03,31 184.16,31 184.3,30.86 184.3,30.72 184.2,30.62 184.2,30.49 184.34,30.35 184.47,30.35 184.57,30.45 184.71,30.45 184.85,30.31 184.85,30.18 184.75,30.08 184.75,29.94 184.88,29.8 185.02,29.8 185.12,29.9 185.26,29.9 185.39,29.77 185.39,29.63 185.29,29.53 185.29,29.39 185.43,29.26 185.57,29.26 185.67,29.36 185.8,29.36 185.94,29.22 185.94,29.08 185.84,28.98 185.84,28.85 185.98,28.71 186.11,28.71 186.21,28.81 186.35,28.81 186.49,28.67 186.49,28.54 186.38,28.44 186.38,28.3 186.52,28.16 186.66,28.16 186.76,28.26 186.89,28.26 187.03,28.13 187.03,27.99 186.93,27.89 186.93,27.76 187.07,27.62 187.2,27.62 187.3,27.72 187.44,27.72 187.58,27.58 187.58,27.45 187.48,27.35 187.48,27.21 187.61,27.07 187.75,27.07 187.85,27.17 187.99,27.17 188.12,27.04 188.12,26.9 188.02,26.8 188.02,26.66 188.16,26.53 188.3,26.53 188.4,26.63 188.53,26.63 188.67,26.49 188.67,26.35 188.57,26.25 188.57,26.12 188.71,25.98 188.84,25.98 188.94,26.08 189.08,26.08 191.15,24.01 191.15,18.76 191.32,18.58 v2(191.32,18.51)
  BOTTOM w0.076: U4555.BE35 162.71,55.65 162.71,55.49 162.78,55.28 162.78,55.09 162.74,54.98 162.74,54.74 162.82,54.54 162.82,53.57 162.61,53.36 162.61,52.68 163.25,52.03 v1(163.45,52.03)
  BOTTOM w0.13: v2(191.32,18.51) 191.33,18.51 CN4125.83
M_B_DQ<41>: length 60.4
  L6 w0.089: 165.19,44.28 164.63,44.83 164.52,44.83 164.02,45.33 164.02,48.4 v1(163.45,48.97)
  L6 w0.097: 165.19,44.28 165.22,44.25 165.22,40.13 174.45,30.9 179.09,30.9 186.77,23.22 186.77,17.58 186.87,17.49 187.05,17.49 187.14,17.39 187.14,17.2 187.05,17.1 186.87,17.1 186.77,17 186.77,16.81 186.87,16.71 187.05,16.71 187.14,16.62 187.14,16.42 187.05,16.33 186.87,16.33 186.77,16.23 186.77,16.04 186.87,15.94 187.05,15.94 187.14,15.85 187.14,15.65 187.05,15.56 186.87,15.56 186.77,15.46 186.77,14.29 186.87,14.19 187.39,14.19 187.5,14.3 v2(187.5,14.51)
  BOTTOM w0.076: U4555.BE34 162.23,55.88 162.23,54.94 162.09,54.69 162.09,54.31 162.31,54.09 162.31,53.78 162.11,53.57 162.11,51.71 162.78,51.04 162.78,51.01 162.86,50.92 162.86,49.57 v1(163.45,48.97)
  BOTTOM w0.13: v2(187.5,14.51) 187.08,14.08 CN4125.66
M_B_DQ<42>: length 61
  L6 w0.089: v1(164.94,50.28) 165.01,50.28
  L6 w0.097: v2(190.52,15.07) 190.55,15.1 190.55,15.56 190.45,15.66 190.4,15.66 190.3,15.76 190.3,15.95 190.4,16.05 190.62,16.05 190.71,16.14 190.71,16.34 190.62,16.43 190.4,16.43 190.3,16.53 190.3,16.72 190.4,16.82 190.45,16.82 190.55,16.92 190.55,17.11 190.45,17.21 190.4,17.21 190.3,17.3 190.3,17.5 190.4,17.59 190.45,17.59 190.55,17.69 190.55,17.88 190.45,17.98 190.4,17.98 190.3,18.07 190.3,18.27 190.4,18.36 190.45,18.36 190.55,18.46 190.55,18.65 190.45,18.75 190.4,18.75 190.3,18.85 190.3,19.04 190.4,19.14 190.45,19.14 190.55,19.23 190.55,19.43 190.45,19.52 190.4,19.52 190.3,19.62 190.3,19.81 190.4,19.91 190.45,19.91 190.55,20 190.55,20.2 190.45,20.29 190.4,20.29 190.3,20.39 190.3,20.58 190.4,20.68 190.45,20.68 190.55,20.78 190.55,20.97 190.45,21.07 190.4,21.07 190.3,21.16 190.3,21.36 190.4,21.45 190.45,21.45 190.55,21.55 190.55,21.74 190.45,21.84 190.4,21.84 190.3,21.93 190.3,22.13 190.4,22.22 190.45,22.22 190.55,22.32 190.55,22.51 190.45,22.61 190.4,22.61 190.3,22.71 190.3,22.9 190.4,23 190.45,23 190.55,23.09 190.55,23.28 180.82,33.01 175.32,33.01 167.35,40.98 167.35,45.67 165.66,47.35 165.66,49.63 165.01,50.28
  BOTTOM w0.076: v1(164.94,50.28) 164.7,50.52 164.7,53.15 164.06,53.78 164.06,54.1 164.25,54.29 164.25,54.69 164.16,54.85 164.16,55.49 U4555.BG35
  BOTTOM w0.13: CN4125.80 190.58,15.01 v2(190.52,15.07)
M_B_DQ<43>: length 61.2
  L6 w0.097: v2(191.9,15.03) 191.98,15.1 191.98,23.6 181.68,33.9 175.69,33.9 168.24,41.35 168.24,46.23 166.62,47.86 166.62,49.8 163.78,52.63 v1(163.45,52.63)
  BOTTOM w0.076: v1(163.45,52.63) 163.1,52.63 162.78,52.95 162.78,53.3 162.99,53.5 162.99,54.55 162.91,54.77 162.91,54.95 162.95,55.07 162.95,55.3 162.88,55.49 162.88,56.28 163.09,56.48 U4555.BG34
  BOTTOM w0.13: v2(191.9,15.03) 191.58,14.7 CN4125.84
M_B_DQ<44>: length 59.2
  L6 w0.097: v1(163.45,50.82) 165.03,50.82 166.04,49.8 166.04,47.42 167.65,45.81 167.65,41.11 175.45,33.31 180.94,33.31 188.74,25.51 188.88,25.51 188.99,25.61 189.13,25.61 189.26,25.48 189.26,25.34 189.15,25.23 189.15,25.1 189.29,24.96 189.43,24.96 189.53,25.07 189.67,25.07 189.81,24.93 189.81,24.79 189.7,24.69 189.7,24.55 189.84,24.41 189.97,24.41 190.08,24.52 190.22,24.52 190.35,24.39 190.35,24.25 190.25,24.14 190.25,24 190.85,23.4 190.85,17.26 190.94,17.16 v2(191.23,17.16)
  BOTTOM w0.076: U4555.BE37 162.64,54.41 162.64,53.63 162.44,53.43 162.44,51.84 163.11,51.18 163.11,51.15 v1(163.45,50.82)
  BOTTOM w0.13: v2(191.23,17.16) 190.33,18.06 CN4125.79
M_B_DQ<45>: length 59.5
  L6 w0.089: 165.49,44.24 164.72,45.01 164.59,45.01 164.19,45.41 164.19,49.44 v1(163.45,50.19)
  L6 w0.097: v2(187.7,17.35) 187.6,17.35 187.11,17.84 187.11,19.2 187.2,19.29 187.56,19.29 187.66,19.39 187.66,19.58 187.56,19.68 187.2,19.68 187.11,19.78 187.11,19.97 187.2,20.07 187.69,20.07 187.79,20.16 187.79,20.36 187.69,20.45 187.2,20.45 187.11,20.55 187.11,20.74 187.2,20.84 187.69,20.84 187.79,20.94 187.79,21.13 187.69,21.22 187.2,21.22 187.11,21.32 187.11,21.51 187.2,21.61 187.69,21.61 187.79,21.71 187.79,21.9 187.69,22 187.2,22 187.11,22.09 187.11,23.3 179.21,31.2 174.57,31.2 165.52,40.25 165.52,44.22 165.49,44.24
  BOTTOM w0.076: v1(163.45,50.19) 163.03,50.6 163.03,50.86 163.03,50.86 163.03,50.99 162.94,51.08 162.94,51.11 162.27,51.78 162.27,53.5 162.47,53.71 162.47,54.16 162.26,54.38 162.26,54.65 162.52,55.13 U4555.BE36
  BOTTOM w0.13: CN4125.71 188.33,19.74 188.19,19.61 188.19,17.84 v2(187.7,17.35)
M_B_DQ<46>: length 60.2
  L6 w0.089: 165.79,44.2 164.8,45.19 164.67,45.19 164.37,45.49 164.37,48.46 v1(164.94,49.03)
  L6 w0.097: v2(187.67,18.76) 188.01,18.76 188.11,18.86 188.11,22.98 186.9,24.18 186.9,24.32 187.05,24.47 187.05,24.61 186.91,24.74 186.78,24.74 186.63,24.59 186.49,24.59 186.35,24.73 186.35,24.87 186.5,25.02 186.5,25.15 186.37,25.29 186.23,25.29 186.08,25.14 185.94,25.14 185.81,25.28 185.81,25.41 185.96,25.56 185.96,25.7 185.82,25.83 185.68,25.83 185.53,25.69 185.4,25.69 185.26,25.82 185.26,25.96 185.41,26.11 185.41,26.24 185.27,26.38 185.14,26.38 184.99,26.23 184.85,26.23 184.72,26.37 184.72,26.51 184.86,26.65 184.86,26.79 184.73,26.93 184.59,26.93 184.44,26.78 184.31,26.78 184.17,26.91 184.17,27.05 184.32,27.2 184.32,27.34 184.18,27.47 184.05,27.47 183.9,27.32 183.76,27.32 183.62,27.46 183.62,27.6 183.77,27.75 183.77,27.88 183.64,28.02 183.5,28.02 183.35,27.87 183.21,27.87 183.08,28.01 183.08,28.14 183.23,28.29 183.23,28.43 183.09,28.57 182.95,28.57 182.8,28.42 182.67,28.42 182.53,28.55 182.53,28.69 182.68,28.84 182.68,28.98 182.54,29.11 182.41,29.11 182.26,28.96 182.12,28.96 181.99,29.1 181.99,29.24 182.13,29.38 182.13,29.52 182,29.66 181.86,29.66 181.71,29.51 181.58,29.51 181.44,29.65 181.44,29.78 181.59,29.93 181.59,30.07 181.45,30.2 181.31,30.2 181.17,30.06 181.03,30.06 180.89,30.19 180.89,30.33 181.04,30.48 181.04,30.61 180.91,30.75 180.77,30.75 180.62,30.6 180.48,30.6 180.35,30.74 180.35,30.87 180.5,31.02 180.5,31.16 180.36,31.3 180.22,31.3 180.07,31.15 179.94,31.15 179.59,31.49 174.69,31.49 165.82,40.37 165.82,44.18 165.79,44.2
  BOTTOM w0.076: v1(164.94,49.03) 164.5,49.46 164.5,53.11 163.9,53.71 163.9,54.2 164.08,54.38 164.08,54.65 163.99,54.83 163.99,55.02 U4555.BG36
  BOTTOM w0.13: v2(187.67,18.76) 187.33,19.1 CN4125.67
