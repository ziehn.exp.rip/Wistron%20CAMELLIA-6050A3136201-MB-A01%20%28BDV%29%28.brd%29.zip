# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CAMELLIA-6012B1039001-001
  rect 0.356x0.864 smd: 1(7.25,2.5) 2(6.75,2.5) 3(6.25,2.5) 4(5.75,2.5) 5(5.25,2.5) 6(4.75,2.5) 7(4.25,2.5) 8(3.75,2.5) 9(3.25,2.5) 10(2.75,2.5) 11(2.25,2.5) 12(1.75,2.5) 13(1.25,2.5) 14(0.75,2.5) 15(0.25,2.5) 16(-0.25,2.5) 17(-0.75,2.5) 18(-1.25,2.5) 19(-1.75,2.5) 20(-2.25,2.5) 21(-2.75,2.5) 22(-3.25,2.5) 23(-3.75,2.5) 24(-4.25,2.5) 25(-4.75,2.5) 26(-5.25,2.5) 27(-5.75,2.5) 28(-6.25,2.5) 29(-6.75,2.5) 30(-7.25,2.5)
  rect 0.61x0.787 smd: G1(-8.25,0) G2(8.25,0)
CAMELLIA-6019B1265501-002
  rect 0.838x0.406 smd: 1(-1,0.6) 2(-1,0) 3(-1,-0.6) 4(1,-0.6) 5(1,0) 6(1,0.6)
CAMELLIA-6019B1806501-001
  round 0.254 smd: A1(3.25,-3.25) A2(2.75,-3.25) A3(2.25,-3.25) A4(1.75,-3.25) A5(1.25,-3.25) A6(0.75,-3.25) A7(0.25,-3.25) A8(-0.25,-3.25) A9(-0.75,-3.25) A10(-1.25,-3.25) A11(-1.75,-3.25) A12(-2.25,-3.25) A13(-2.75,-3.25) A14(-3.25,-3.25) B1(3.25,-2.75) B2(2.75,-2.75) B3(2.25,-2.75) B4(1.75,-2.75) B5(1.25,-2.75) B6(0.75,-2.75) B7(0.25,-2.75) B8(-0.25,-2.75) B9(-0.75,-2.75) B10(-1.25,-2.75) B11(-1.75,-2.75) B12(-2.25,-2.75) B13(-2.75,-2.75) B14(-3.25,-2.75) C1(3.25,-2.25) C2(2.75,-2.25) C3(2.25,-2.25) C4(1.75,-2.25) C5(1.25,-2.25) C6(0.75,-2.25) C7(0.25,-2.25) C8(-0.25,-2.25) C9(-0.75,-2.25) C10(-1.25,-2.25) C11(-1.75,-2.25) C12(-2.25,-2.25) C13(-2.75,-2.25) C14(-3.25,-2.25) D1(3.25,-1.75) D2(2.75,-1.75) D3(2.25,-1.75) D4(1.75,-1.75) D12(-2.25,-1.75) D13(-2.75,-1.75) D14(-3.25,-1.75) E1(3.25,-1.25) E2(2.75,-1.25) E3(2.25,-1.25) E5(1.25,-1.25) E6(0.75,-1.25) E7(0.25,-1.25) E8(-0.25,-1.25) E9(-0.75,-1.25) E10(-1.25,-1.25) E12(-2.25,-1.25) E13(-2.75,-1.25) E14(-3.25,-1.25) F1(3.25,-0.75) F2(2.75,-0.75) F3(2.25,-0.75) F5(1.25,-0.75) F10(-1.25,-0.75) F12(-2.25,-0.75) F13(-2.75,-0.75) F14(-3.25,-0.75) G1(3.25,-0.25) G2(2.75,-0.25) G3(2.25,-0.25) G5(1.25,-0.25) G10(-1.25,-0.25) G12(-2.25,-0.25) G13(-2.75,-0.25) G14(-3.25,-0.25) H1(3.25,0.25) H2(2.75,0.25) H3(2.25,0.25) H5(1.25,0.25) H10(-1.25,0.25) H12(-2.25,0.25) H13(-2.75,0.25) H14(-3.25,0.25) J1(3.25,0.75) J2(2.75,0.75) J3(2.25,0.75) J5(1.25,0.75) J10(-1.25,0.75) J12(-2.25,0.75) J13(-2.75,0.75) J14(-3.25,0.75) K1(3.25,1.25) K2(2.75,1.25) K3(2.25,1.25) K5(1.25,1.25) K6(0.75,1.25) K7(0.25,1.25) K8(-0.25,1.25) K9(-0.75,1.25) K10(-1.25,1.25) K12(-2.25,1.25) K13(-2.75,1.25) K14(-3.25,1.25) L1(3.25,1.75) L2(2.75,1.75) L3(2.25,1.75) L12(-2.25,1.75) L13(-2.75,1.75) L14(-3.25,1.75) M1(3.25,2.25) M2(2.75,2.25) M3(2.25,2.25) M4(1.75,2.25) M5(1.25,2.25) M6(0.75,2.25) M7(0.25,2.25) M8(-0.25,2.25) M9(-0.75,2.25) M10(-1.25,2.25) M11(-1.75,2.25) M12(-2.25,2.25) M13(-2.75,2.25) M14(-3.25,2.25) N1(3.25,2.75) N2(2.75,2.75) N3(2.25,2.75) N4(1.75,2.75) N5(1.25,2.75) N6(0.75,2.75) N7(0.25,2.75) N8(-0.25,2.75) N9(-0.75,2.75) N10(-1.25,2.75) N11(-1.75,2.75) N12(-2.25,2.75) N13(-2.75,2.75) N14(-3.25,2.75) P1(3.25,3.25) P2(2.75,3.25) P3(2.25,3.25) P4(1.75,3.25) P5(1.25,3.25) P6(0.75,3.25) P7(0.25,3.25) P8(-0.25,3.25) P9(-0.75,3.25) P10(-1.25,3.25) P11(-1.75,3.25) P12(-2.25,3.25) P13(-2.75,3.25) P14(-3.25,3.25)
CHROMIA-6011B0197701-001
  rect 0.94x0.711 smd: 1(-1.175,0) 2(1.175,0)
CLOONEY-6010B0219002-001
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
CPU_INTEL_CLU_6C_B_4600X2400
  round 0.356 smd: A3(10.396,-22.315) A36(-10.855,-22.315) B2(10.855,-21.855) B37(-11.315,-21.855) C1(11.315,-21.396) CP1(11.315,21.855) CP37(-11.315,21.855) CR2(10.855,22.315) CR36(-10.855,22.315)
  round 0.33 smd: A4(9.746,-22.315) A35(-10.205,-22.315) B3(10.227,-21.687) B36(-10.687,-21.687) C2(10.687,-21.227) C37(-11.315,-21.205) CN1(11.315,21.205) CN37(-11.315,21.205) CP2(10.687,21.687) CP36(-10.687,21.687) CR3(10.205,22.315) CR35(-10.205,22.315) D1(11.315,-20.746)
  round 0.305 smd: A5(9.096,-22.292) A6(8.232,-22.315) A32(-8.228,-22.315) A34(-9.555,-22.315) AA4(9.365,-10.421) AA9(6.21,-10.624) AA24(-3.679,-10.481) AA26(-4.606,-10.481) AA34(-9.365,-10.719) AB3(10.334,-9.763) AB4(9.325,-9.763) AB5(8.617,-10.162) AB6(7.967,-10.162) AB7(7.317,-10.162) AB8(6.668,-10.162) AB9(6.21,-9.7) AB10(5.753,-10.162) AB25(-4.142,-10.025) AB27(-5.069,-10.025) AB28(-5.719,-10.025) AB29(-6.369,-10.025) AB30(-7.019,-10.025) AB31(-7.669,-10.025) AB32(-8.32,-10.025) AB33(-9.04,-10.068) AB34(-9.69,-10.068) AC4(9.365,-9.106) AC5(8.617,-9.238) AC6(7.967,-9.238) AC7(7.317,-9.238) AC8(6.668,-9.238) AC10(5.753,-9.238) AC24(-3.679,-9.57) AC25(-4.142,-9.114) AC26(-4.606,-9.57) AC27(-5.069,-9.114) AC28(-5.719,-9.114) AC29(-6.369,-9.114) AC30(-7.019,-9.114) AC31(-7.669,-9.114) AC32(-8.32,-9.114) AC34(-9.365,-9.417) AD4(9.69,-8.543) AD9(6.21,-8.776) AD24(-3.679,-8.658) AD26(-4.606,-8.658) AD33(-9.04,-8.809) AD35(-10.245,-8.809) AE4(9.365,-7.98) AE5(8.617,-8.314) AE6(7.967,-8.314) AE7(7.317,-8.314) AE8(6.668,-8.314) AE9(6.21,-7.852) AE10(5.753,-8.314) AE24(-3.679,-7.747) AE25(-4.142,-8.203) AE26(-4.606,-7.747) AE27(-5.069,-8.203) AE28(-5.719,-8.203) AE29(-6.369,-8.203) AE30(-7.019,-8.203) AE31(-7.669,-8.203) AE32(-8.32,-8.203) AE34(-9.365,-8.202) AF3(10.334,-7.322) AF4(9.325,-7.322) AF5(8.617,-7.39) AF6(7.967,-7.39) AF7(7.317,-7.39) AF8(6.668,-7.39) AF10(5.753,-7.39) AF25(-4.142,-7.291) AF27(-5.069,-7.291) AF28(-5.719,-7.291) AF29(-6.369,-7.291) AF30(-7.019,-7.291) AF31(-7.669,-7.291) AF32(-8.32,-7.291) AF33(-9.04,-7.551) AF34(-9.69,-7.551) AG4(9.365,-6.665) AG5(8.617,-6.467) AG6(7.967,-6.467) AG7(7.317,-6.467) AG8(6.668,-6.467) AG9(6.21,-6.929) AG10(5.753,-6.467) AG24(-3.679,-6.835) AG26(-4.606,-6.835) AG34(-9.365,-6.9) AH4(9.69,-6.102) AH9(6.21,-6.005) AH24(-3.679,-5.924) AH25(-4.142,-6.38) AH26(-4.606,-5.924) AH27(-5.069,-6.38) AH28(-5.719,-6.38) AH29(-6.369,-6.38) AH30(-7.019,-6.38) AH31(-7.669,-6.38) AH32(-8.32,-6.38) AH33(-9.04,-6.293) AH35(-10.245,-6.293) AJ4(9.365,-5.539) AJ5(8.617,-5.543) AJ6(7.967,-5.543) AJ7(7.317,-5.543) AJ8(6.668,-5.543) AJ10(5.753,-5.543) AJ25(-4.142,-5.468) AJ27(-5.069,-5.468) AJ28(-5.719,-5.468) AJ29(-6.369,-5.468) AJ30(-7.019,-5.468) AJ31(-7.669,-5.468) AJ32(-8.32,-5.468) AJ34(-9.365,-5.685) AK3(10.334,-4.882) AK4(9.325,-4.882) AK9(6.21,-5.081) AK24(-3.679,-5.013) AK26(-4.606,-5.013) AK33(-9.04,-5.034) AK34(-9.69,-5.034) AL4(9.365,-4.224) AL5(8.617,-4.619) AL6(7.967,-4.619) AL7(7.317,-4.619) AL8(6.668,-4.619) AL9(6.21,-4.157) AL10(5.753,-4.619) AL24(-3.679,-4.101) AL25(-4.142,-4.557) AL26(-4.606,-4.101) AL27(-5.069,-4.557) AL28(-5.719,-4.557) AL29(-6.369,-4.557) AL30(-7.019,-4.557) AL31(-7.669,-4.557) AL32(-8.32,-4.557) AL34(-9.365,-4.383) AM4(9.69,-3.661) AM5(8.617,-3.695) AM6(7.967,-3.695) AM7(7.317,-3.695) AM8(6.668,-3.695) AM10(5.753,-3.695) AM25(-4.142,-3.646) AM27(-5.069,-3.646) AM28(-5.719,-3.646) AM29(-6.369,-3.646) AM30(-7.019,-3.646) AM31(-7.669,-3.646) AM32(-8.32,-3.646) AM33(-9.04,-3.775) AM35(-10.245,-3.775) AN4(9.365,-3.098) AN5(8.617,-2.771) AN6(7.967,-2.771) AN7(7.317,-2.771) AN8(6.668,-2.771) AN9(6.21,-3.233) AN10(5.753,-2.771) AN24(-3.679,-3.19) AN25(-4.142,-2.734) AN26(-4.606,-3.19) AN27(-5.069,-2.734) AN28(-5.719,-2.734) AN29(-6.369,-2.734) AN30(-7.019,-2.734) AN31(-7.669,-2.734) AN32(-8.32,-2.734) AN34(-9.365,-3.168) AP3(10.334,-2.441) AP4(9.325,-2.441) AP9(6.21,-2.31) AP24(-3.679,-2.278) AP26(-4.606,-2.278) AP33(-9.04,-2.517) AP34(-9.69,-2.517) AR4(9.365,-1.783) AR5(8.617,-1.848) AR6(7.967,-1.848) AR7(7.317,-1.848) AR8(6.668,-1.848) AR10(5.753,-1.848) AR25(-4.142,-1.823) AR27(-5.069,-1.823) AR28(-5.719,-1.823) AR29(-6.369,-1.823) AR30(-7.019,-1.823) AR31(-7.669,-1.823) AR32(-8.32,-1.823) AR34(-9.365,-1.866) AT4(9.69,-1.22) AT9(6.21,-1.386) AT24(-3.679,-1.367) AT26(-4.606,-1.367) AT33(-9.04,-1.259) AT35(-10.245,-1.259) AU4(9.365,-0.657) AU5(8.617,-0.924) AU6(7.967,-0.924) AU7(7.317,-0.924) AU8(6.668,-0.924) AU9(6.21,-0.462) AU10(5.753,-0.924) AU24(-3.679,-0.456) AU25(-4.142,-0.911) AU26(-4.606,-0.456) AU27(-5.069,-0.911) AU28(-5.719,-0.911) AU29(-6.369,-0.911) AU30(-7.019,-0.911) AU31(-7.669,-0.911) AU32(-8.32,-0.911) AU34(-9.365,-0.65) AV3(10.334,0) AV4(9.325,0) AV5(8.617,0) AV6(7.967,0) AV7(7.317,0) AV8(6.668,0) AV10(5.753,0) AV25(-4.142,0) AV27(-5.069,0) AV28(-5.719,0) AV29(-6.369,0) AV30(-7.019,0) AV31(-7.669,0) AV32(-8.32,0) AV33(-9.04,0) AV34(-9.69,0) AW4(9.365,0.657) AW5(8.617,0.924) AW6(7.967,0.924) AW7(7.317,0.924) AW8(6.668,0.924) AW9(6.21,0.462) AW10(5.753,0.924) AW24(-3.679,0.456) AW25(-4.142,0.911) AW26(-4.606,0.456) AW27(-5.069,0.911) AW28(-5.719,0.911) AW29(-6.369,0.911) AW30(-7.019,0.911) AW31(-7.669,0.911) AW32(-8.32,0.911) AW34(-9.365,0.65) AY4(9.69,1.22) AY9(6.21,1.386) AY24(-3.679,1.367) AY26(-4.606,1.367) AY33(-9.04,1.259) AY35(-10.245,1.259) B4(9.515,-21.707) B5(8.866,-21.684) B33(-8.901,-22.004) B34(-9.396,-21.582) B35(-10.037,-21.687) BA4(9.365,1.783) BA5(8.617,1.848) BA6(7.967,1.848) BA7(7.317,1.848) BA8(6.668,1.848) BA10(5.753,1.848) BA25(-4.142,1.823) BA27(-5.069,1.823) BA28(-5.719,1.823) BA29(-6.369,1.823) BA30(-7.019,1.823) BA31(-7.669,1.823) BA32(-8.32,1.823) BA34(-9.365,1.866) BB3(10.334,2.441) BB4(9.325,2.441) BB9(6.21,2.31) BB24(-3.679,2.278) BB26(-4.606,2.278) BB33(-9.04,2.517) BB34(-9.69,2.517) BC4(9.365,3.098) BC5(8.617,2.771) BC6(7.967,2.771) BC7(7.317,2.771) BC8(6.668,2.771) BC9(6.21,3.233) BC10(5.753,2.771) BC24(-3.679,3.19) BC25(-4.142,2.734) BC26(-4.606,3.19) BC27(-5.069,2.734) BC28(-5.719,2.734) BC29(-6.369,2.734) BC30(-7.019,2.734) BC31(-7.669,2.734) BC32(-8.32,2.734) BC34(-9.365,3.168) BD4(9.69,3.661) BD5(8.617,3.695) BD6(7.967,3.695) BD7(7.317,3.695) BD8(6.668,3.695) BD10(5.753,3.695) BD25(-4.142,3.646) BD27(-5.069,3.646) BD28(-5.719,3.646) BD29(-6.369,3.646) BD30(-7.019,3.646) BD31(-7.669,3.646) BD32(-8.32,3.646) BD33(-9.04,3.775) BD35(-10.245,3.775) BE4(9.365,4.224) BE5(8.617,4.619) BE6(7.967,4.619) BE7(7.317,4.619) BE8(6.668,4.619) BE9(6.21,4.157) BE10(5.753,4.619) BE24(-3.679,4.101) BE25(-4.142,4.557) BE26(-4.606,4.101) BE27(-5.069,4.557) BE28(-5.719,4.557) BE29(-6.369,4.557) BE30(-7.019,4.557) BE31(-7.669,4.557) BE32(-8.32,4.557) BE34(-9.365,4.383) BF3(10.334,4.882) BF4(9.325,4.882) BF9(6.21,5.081) BF24(-3.679,5.013) BF26(-4.606,5.013) BF33(-9.04,5.034) BF34(-9.69,5.034) BG4(9.365,5.539) BG5(8.617,5.543) BG6(7.967,5.543) BG7(7.317,5.543) BG8(6.668,5.543) BG10(5.753,5.543) BG25(-4.142,5.468) BG27(-5.069,5.468) BG28(-5.719,5.468) BG29(-6.369,5.468) BG30(-7.019,5.468) BG31(-7.669,5.468) BG32(-8.32,5.468) BG34(-9.365,5.685) BH4(9.69,6.102) BH9(6.21,6.005) BH24(-3.679,5.924) BH25(-4.142,6.38) BH26(-4.606,5.924) BH27(-5.069,6.38) BH28(-5.719,6.38) BH29(-6.369,6.38) BH30(-7.019,6.38) BH31(-7.669,6.38) BH32(-8.32,6.38) BH33(-9.04,6.293) BH35(-10.245,6.293) BJ4(9.365,6.665) BJ5(8.617,6.467) BJ6(7.967,6.467) BJ7(7.317,6.467) BJ8(6.668,6.467) BJ9(6.21,6.929) BJ10(5.753,6.467) BJ24(-3.679,6.835) BJ26(-4.606,6.835) BJ34(-9.365,6.9) BK3(10.334,7.322) BK4(9.325,7.322) BK5(8.617,7.39) BK6(7.967,7.39) BK7(7.317,7.39) BK8(6.668,7.39) BK10(5.753,7.39) BK25(-4.142,7.291) BK27(-5.069,7.291) BK28(-5.719,7.291) BK29(-6.369,7.291) BK30(-7.019,7.291) BK31(-7.669,7.291) BK32(-8.32,7.291) BK33(-9.04,7.551) BK34(-9.69,7.551) BL4(9.365,7.98) BL5(8.617,8.314) BL6(7.967,8.314) BL7(7.317,8.314) BL8(6.668,8.314) BL9(6.21,7.852) BL10(5.753,8.314) BL24(-3.679,7.747) BL25(-4.142,8.203) BL26(-4.606,7.747) BL27(-5.069,8.203) BL28(-5.719,8.203) BL29(-6.369,8.203) BL30(-7.019,8.203) BL31(-7.669,8.203) BL32(-8.32,8.203) BL34(-9.365,8.202) BM4(9.69,8.543) BM9(6.21,8.776) BM24(-3.679,8.658) BM26(-4.606,8.658) BM33(-9.04,8.809) BM35(-10.245,8.809) BN4(9.365,9.106) BN5(8.617,9.238) BN6(7.967,9.238) BN7(7.317,9.238) BN8(6.668,9.238) BN10(5.753,9.238) BN25(-4.142,9.114) BN27(-5.069,9.114) BN28(-5.719,9.114) BN29(-6.369,9.114) BN30(-7.019,9.114) BN31(-7.669,9.114) BN32(-8.32,9.114) BN34(-9.365,9.417) BP3(10.334,9.763) BP4(9.325,9.763) BP5(8.617,10.162) BP6(7.967,10.162) BP7(7.317,10.162) BP8(6.668,10.162) BP9(6.018,10.162) BP11(5.093,9.786) BP12(4.253,9.786) BP14(3.413,9.786) BP15(2.574,9.786) BP16(1.734,9.786) BP18(0.894,9.786) BP19(0.054,9.786) BP20(-0.786,9.786) BP22(-1.626,9.786) BP23(-2.465,9.786) BP24(-3.305,9.786) BP25(-4.145,9.786) BP27(-5.069,10.025) BP28(-5.719,10.025) BP29(-6.369,10.025) BP30(-7.019,10.025) BP31(-7.669,10.025) BP32(-8.32,10.025) BP33(-9.04,10.068) BP34(-9.69,10.068) BR4(9.365,10.421) BR11(5.093,10.436) BR12(4.253,10.436) BR14(3.413,10.436) BR15(2.574,10.436) BR16(1.734,10.436) BR18(0.894,10.436) BR19(0.054,10.436) BR20(-0.786,10.436) BR22(-1.626,10.436) BR23(-2.465,10.436) BR24(-3.305,10.436) BR25(-4.145,10.436) BR34(-9.365,10.719) BT4(9.69,10.984) BT5(8.617,11.086) BT6(7.967,11.086) BT7(7.317,11.086) BT8(6.668,11.086) BT9(6.018,11.086) BT11(5.093,11.086) BT12(4.253,11.086) BT14(3.413,11.086) BT15(2.574,11.086) BT16(1.734,11.086) BT18(0.894,11.086) BT19(0.054,11.086) BT20(-0.786,11.086) BT22(-1.626,11.086) BT23(-2.465,11.086) BT24(-3.305,11.086) BT25(-4.145,11.086) BT27(-5.069,10.937) BT28(-5.719,10.937) BT29(-6.369,10.937) BT30(-7.019,10.937) BT31(-7.669,10.937) BT32(-8.32,10.937) BT33(-9.04,11.327) BT35(-10.245,11.327) BU4(9.365,11.547) BU5(8.617,12.009) BU6(7.967,12.009) BU7(7.317,12.009) BU8(6.668,12.009) BU9(6.018,12.009) BU11(5.093,11.736) BU12(4.253,11.736) BU14(3.413,11.736) BU15(2.574,11.736) BU16(1.734,11.736) BU18(0.894,11.736) BU19(0.054,11.736) BU20(-0.786,11.736) BU22(-1.626,11.736) BU23(-2.465,11.736) BU24(-3.305,11.736) BU25(-4.145,11.736) BU27(-5.069,11.848) BU28(-5.719,11.848) BU29(-6.369,11.848) BU30(-7.019,11.848) BU31(-7.669,11.848) BU32(-8.32,11.848) BU34(-9.365,11.934) BV3(10.334,12.204) BV4(9.325,12.204) BV11(5.093,12.386) BV12(4.253,12.386) BV14(3.413,12.386) BV15(2.574,12.386) BV16(1.734,12.386) BV18(0.894,12.386) BV19(0.054,12.386) BV20(-0.786,12.386) BV22(-1.626,12.386) BV23(-2.465,12.386) BV24(-3.305,12.386) BV25(-4.145,12.386) BV27(-5.069,12.76) BV28(-5.719,12.76) BV29(-6.369,12.76) BV30(-7.019,12.76) BV31(-7.669,12.76) BV32(-8.32,12.76) BV33(-9.04,12.585) BV34(-9.69,12.585) BW4(9.365,12.861) BW5(8.617,12.933) BW6(7.967,12.933) BW7(7.317,12.933) BW8(6.668,12.933) BW9(6.018,12.933) BW11(5.093,13.036) BW12(4.253,13.036) BW14(3.413,13.036) BW15(2.574,13.036) BW16(1.734,13.036) BW18(0.894,13.036) BW19(0.054,13.036) BW20(-0.786,13.036) BW22(-1.626,13.036) BW23(-2.465,13.036) BW24(-3.305,13.036) BW25(-4.145,13.036) BW34(-9.365,13.236) BY4(9.69,13.424) BY5(8.617,13.857) BY6(7.967,13.857) BY7(7.317,13.857) BY8(6.668,13.857) BY9(6.018,13.857) BY11(5.093,13.686) BY12(4.253,13.686) BY14(3.413,13.686) BY15(2.574,13.686) BY16(1.734,13.686) BY18(0.894,13.686) BY19(0.054,13.686) BY20(-0.786,13.686) BY22(-1.626,13.686) BY23(-2.465,13.686) BY24(-3.305,13.686) BY25(-4.145,13.686) BY27(-5.069,13.671) BY28(-5.719,13.671) BY29(-6.369,13.671) BY30(-7.019,13.671) BY31(-7.669,13.671) BY32(-8.32,13.671) BY33(-9.04,13.844) BY35(-10.245,13.844) C3(10.059,-21.059) C4(9.213,-21.132) C9(6.305,-21.245) C21(-1.275,-21.245) C25(-3.792,-21.245) C29(-6.309,-21.245) C33(-8.826,-21.245) C34(-9.396,-20.932) C35(-10.037,-21.037) C36(-10.687,-21.037) CA4(9.365,13.988) CA11(5.093,14.336) CA12(4.253,14.336) CA14(3.413,14.336) CA15(2.574,14.336) CA16(1.734,14.336) CA18(0.894,14.336) CA19(0.054,14.336) CA20(-0.786,14.336) CA22(-1.626,14.336) CA23(-2.465,14.336) CA24(-3.305,14.336) CA25(-4.145,14.336) CA27(-5.069,14.582) CA28(-5.719,14.582) CA29(-6.369,14.582) CA30(-7.019,14.582) CA31(-7.669,14.582) CA32(-8.32,14.582) CA34(-9.365,14.451) CB3(10.334,14.645) CB4(9.325,14.645) CB5(8.617,14.781) CB6(7.967,14.781) CB7(7.317,14.781) CB8(6.668,14.781) CB9(6.018,14.781) CB11(5.093,14.985) CB12(4.253,14.985) CB14(3.413,14.985) CB15(2.574,14.985) CB16(1.734,14.985) CB18(0.894,14.985) CB19(0.054,14.985) CB20(-0.786,14.985) CB22(-1.626,14.985) CB23(-2.465,14.985) CB24(-3.305,14.985) CB25(-4.145,14.985) CB33(-9.04,15.102) CB34(-9.69,15.102) CC4(9.365,15.302) CC5(8.617,15.705) CC6(7.967,15.705) CC7(7.317,15.705) CC8(6.668,15.705) CC9(6.018,15.705) CC11(5.093,15.635) CC12(4.253,15.635) CC14(3.413,15.635) CC15(2.574,15.635) CC16(1.734,15.635) CC18(0.894,15.635) CC19(0.054,15.635) CC20(-0.786,15.635) CC22(-1.626,15.635) CC23(-2.465,15.635) CC24(-3.305,15.635) CC25(-4.145,15.635) CC27(-5.069,15.494) CC28(-5.719,15.494) CC29(-6.369,15.494) CC30(-7.019,15.494) CC31(-7.669,15.494) CC32(-8.32,15.494) CC34(-9.365,15.753) CD4(9.69,15.865) CD11(5.093,16.285) CD12(4.253,16.285) CD14(3.413,16.285) CD15(2.574,16.285) CD16(1.734,16.285) CD18(0.894,16.285) CD19(0.054,16.285) CD20(-0.786,16.285) CD22(-1.626,16.285) CD23(-2.465,16.285) CD24(-3.305,16.285) CD25(-4.145,16.285) CE4(9.365,16.428) CE5(8.617,16.628) CE6(7.967,16.628) CE7(7.317,16.628) CE8(6.668,16.628) CE9(6.018,16.628) CE27(-5.069,16.405) CE28(-5.719,16.405) CE29(-6.369,16.405) CE30(-7.019,16.405) CE31(-7.669,16.405) CE32(-8.32,16.405) CE33(-9.04,16.36) CE35(-10.245,16.36) CF3(10.334,17.086) CF4(9.325,17.086) CF11(5.37,17.115) CF12(4.368,17.115) CF14(3.33,17.115) CF15(2.292,17.115) CF17(1.254,17.115) CF19(0.216,17.115) CF20(-0.822,17.115) CF22(-1.86,17.115) CF23(-2.898,17.115) CF25(-3.936,17.115) CF27(-5.069,17.317) CF28(-5.719,17.317) CF29(-6.369,17.317) CF30(-7.019,17.317) CF31(-7.669,17.317) CF32(-8.32,17.317) CF34(-9.365,16.968) CG4(9.365,17.743) CG5(8.617,17.552) CG6(7.967,17.552) CG7(7.317,17.552) CG8(6.668,17.552) CG9(6.018,17.552) CG11(5.37,17.765) CG12(4.368,17.765) CG14(3.33,17.765) CG15(2.292,17.765) CG17(1.254,17.765) CG19(0.216,17.765) CG20(-0.822,17.765) CG22(-1.86,17.765) CG23(-2.898,17.765) CG25(-3.936,17.765) CG33(-9.04,17.619) CG34(-9.69,17.619) CH4(9.69,18.306) CH5(8.617,18.476) CH6(7.967,18.476) CH7(7.317,18.476) CH8(6.668,18.476) CH9(6.018,18.476) CH11(5.37,18.415) CH12(4.368,18.415) CH14(3.33,18.415) CH15(2.292,18.415) CH17(1.254,18.415) CH19(0.216,18.415) CH20(-0.822,18.415) CH22(-1.86,18.415) CH23(-2.898,18.415) CH25(-3.936,18.415) CH27(-5.069,18.228) CH28(-5.719,18.228) CH29(-6.369,18.228) CH30(-7.019,18.228) CH31(-7.669,18.228) CH32(-8.32,18.228) CH34(-9.365,18.27) CJ4(9.365,18.869) CJ11(5.37,19.065) CJ12(4.368,19.065) CJ14(3.33,19.065) CJ15(2.292,19.065) CJ17(1.254,19.065) CJ19(0.216,19.065) CJ20(-0.822,19.065) CJ22(-1.86,19.065) CJ23(-2.898,19.065) CJ25(-3.936,19.065) CJ27(-5.069,19.139) CJ28(-5.719,19.139) CJ29(-6.369,19.139) CJ30(-7.019,19.139) CJ31(-7.669,19.139) CJ32(-8.32,19.139) CJ33(-9.04,18.833) CJ35(-10.245,18.878) CK1(11.315,19.561) CK3(9.895,19.83) CK4(9.325,19.518) CK5(8.617,19.4) CK6(7.967,19.4) CK7(7.317,19.4) CK8(6.668,19.4) CK9(6.018,19.4) CK11(5.37,19.715) CK12(4.368,19.715) CK14(3.33,19.715) CK15(2.292,19.715) CK17(1.254,19.715) CK19(0.216,19.715) CK20(-0.822,19.715) CK22(-1.86,19.715) CK23(-2.898,19.715) CK25(-3.936,19.715) CK33(-9.15,19.504) CK34(-9.775,19.326) CK36(-10.612,19.462) CK37(-11.315,19.374) CL2(10.896,20.058) CL35(-10.061,19.91) CL36(-10.948,20.019) CM1(11.315,20.555) CM3(10.333,20.383) CM4(9.496,20.343) CM5(8.782,20.365) CM6(8.132,20.371) CM7(7.565,20.69) CM8(6.999,20.371) CM9(6.305,20.365) CM10(5.61,20.371) CM11(5.044,20.69) CM12(4.478,20.371) CM13(3.783,20.365) CM14(3.088,20.371) CM15(2.522,20.69) CM16(1.956,20.371) CM17(1.261,20.365) CM18(0.566,20.371) CM19(0,20.69) CM20(-0.566,20.371) CM21(-1.261,20.365) CM22(-1.956,20.371) CM23(-2.522,20.69) CM24(-3.088,20.371) CM25(-3.783,20.365) CM26(-4.478,20.371) CM27(-5.044,20.69) CM28(-5.61,20.371) CM29(-6.305,20.365) CM30(-6.955,20.365) CM31(-7.531,20.814) CM32(-8.176,20.365) CM33(-8.826,20.365) CM34(-9.471,20.286) CM35(-10.447,20.433) CM37(-11.315,20.555) CN2(10.752,20.88) CN3(10.007,20.946) CN4(9.358,20.978) CN5(8.794,21.367) CN9(6.305,21.245) CN13(3.783,21.245) CN17(1.261,21.245) CN21(-1.261,21.245) CN25(-3.783,21.245) CN29(-6.305,21.245) CN33(-8.826,21.245) CN34(-9.396,20.932) CN35(-10.037,21.037) CN36(-10.687,21.037) CP3(10.037,21.687) CP4(9.39,21.627) CP5(8.942,22.099) CP33(-8.871,21.968) CP34(-9.396,21.582) CP35(-10.037,21.687) CR4(9.555,22.315) CR6(8.232,22.315) CR32(-8.321,22.315) CR34(-9.555,22.315) D2(10.64,-20.579) D4(9.594,-20.605) D5(8.782,-20.365) D6(8.132,-20.371) D7(7.565,-20.69) D8(6.999,-20.371) D9(6.305,-20.505) D21(-1.275,-20.595) D22(-1.883,-20.365) D23(-2.534,-20.69) D24(-3.184,-20.365) D25(-3.792,-20.595) D26(-4.4,-20.365) D27(-5.051,-20.69) D28(-5.701,-20.365) D30(-6.917,-20.365) D31(-7.568,-20.69) D32(-8.218,-20.365) D34(-9.396,-20.282) D35(-10.447,-20.433) D37(-11.315,-20.555) E1(11.315,-20.096) E3(10.008,-20.089) E4(9.365,-19.995) E9(6.21,-19.862) E23(-2.621,-20.04) E27(-5.051,-20.04) E29(-6.309,-20.04) E31(-7.568,-20.04) E33(-8.781,-20.04) E35(-10.061,-19.91) E36(-10.948,-20.019) F2(11.001,-19.527) F3(10.334,-19.527) F4(9.69,-19.432) F5(8.617,-19.4) F6(7.967,-19.4) F7(7.317,-19.4) F8(6.668,-19.4) F21(-1.149,-19.715) F22(-2.058,-19.715) F24(-3.184,-19.715) F25(-4.093,-19.715) F33(-9.15,-19.504) F34(-9.775,-19.326) F36(-10.612,-19.462) F37(-11.315,-19.374) G1(11.315,-18.844) G4(9.365,-18.869) G9(6.21,-18.938) G21(-1.149,-19.065) G22(-2.058,-19.065) G24(-3.184,-19.065) G25(-4.093,-19.065) G27(-5.069,-19.139) G28(-5.719,-19.139) G29(-6.369,-19.139) G30(-7.019,-19.139) G31(-7.669,-19.139) G32(-8.32,-19.139) G33(-9.04,-18.833) G35(-10.245,-18.878) H4(9.69,-18.306) H5(8.617,-18.476) H6(7.967,-18.476) H7(7.317,-18.476) H8(6.668,-18.476) H9(6.21,-18.014) H21(-1.149,-18.415) H22(-2.058,-18.415) H24(-3.184,-18.415) H25(-4.093,-18.415) H27(-5.069,-18.228) H28(-5.719,-18.228) H29(-6.369,-18.228) H30(-7.019,-18.228) H31(-7.669,-18.228) H32(-8.32,-18.228) H34(-9.365,-18.27) J4(9.365,-17.743) J5(8.617,-17.552) J6(7.967,-17.552) J7(7.317,-17.552) J8(6.668,-17.552) J21(-1.149,-17.765) J22(-2.058,-17.765) J24(-3.184,-17.765) J25(-4.093,-17.765) J33(-9.04,-17.619) J34(-9.69,-17.619) K3(10.334,-17.086) K4(9.325,-17.086) K9(6.21,-17.09) K11(5.322,-17.115) K12(4.38,-17.115) K14(3.438,-17.115) K15(2.496,-17.115) K17(1.554,-17.115) K18(0.613,-17.115) K20(-0.329,-17.115) K21(-1.149,-17.115) K22(-2.058,-17.115) K24(-3.184,-17.115) K25(-4.093,-17.115) K27(-5.069,-17.317) K28(-5.719,-17.317) K29(-6.369,-17.317) K30(-7.019,-17.317) K31(-7.669,-17.317) K32(-8.32,-17.317) K34(-9.365,-16.968) L4(9.365,-16.428) L5(8.617,-16.628) L6(7.967,-16.628) L7(7.317,-16.628) L8(6.668,-16.628) L10(5.753,-16.628) L25(-4.142,-16.405) L27(-5.069,-16.405) L28(-5.719,-16.405) L29(-6.369,-16.405) L30(-7.019,-16.405) L31(-7.669,-16.405) L32(-8.32,-16.405) L33(-9.04,-16.36) L35(-10.245,-16.36) M4(9.69,-15.865) M9(6.21,-16.167) M24(-3.679,-15.949) M26(-4.606,-15.949) N4(9.365,-15.302) N5(8.617,-15.705) N6(7.967,-15.705) N7(7.317,-15.705) N8(6.668,-15.705) N9(6.21,-15.243) N10(5.753,-15.705) N25(-4.142,-15.494) N27(-5.069,-15.494) N28(-5.719,-15.494) N29(-6.369,-15.494) N30(-7.019,-15.494) N31(-7.669,-15.494) N32(-8.32,-15.494) N34(-9.365,-15.753) P3(10.334,-14.645) P4(9.325,-14.645) P5(8.617,-14.781) P6(7.967,-14.781) P7(7.317,-14.781) P8(6.668,-14.781) P10(5.753,-14.781) P24(-3.679,-15.038) P26(-4.606,-15.038) P33(-9.04,-15.102) P34(-9.69,-15.102) R4(9.365,-13.988) R9(6.21,-14.319) R24(-3.679,-14.127) R25(-4.142,-14.582) R26(-4.606,-14.127) R27(-5.069,-14.582) R28(-5.719,-14.582) R29(-6.369,-14.582) R30(-7.019,-14.582) R31(-7.669,-14.582) R32(-8.32,-14.582) R34(-9.365,-14.451) T4(9.69,-13.424) T5(8.617,-13.857) T6(7.967,-13.857) T7(7.317,-13.857) T8(6.668,-13.857) T9(6.21,-13.395) T10(5.753,-13.857) T25(-4.142,-13.671) T27(-5.069,-13.671) T28(-5.719,-13.671) T29(-6.369,-13.671) T30(-7.019,-13.671) T31(-7.669,-13.671) T32(-8.32,-13.671) T33(-9.04,-13.844) T35(-10.245,-13.844) U4(9.365,-12.861) U5(8.617,-12.933) U6(7.967,-12.933) U7(7.317,-12.933) U8(6.668,-12.933) U10(5.753,-12.933) U24(-3.679,-13.215) U26(-4.606,-13.215) U34(-9.365,-13.236) V3(10.334,-12.204) V4(9.325,-12.204) V9(6.21,-12.471) V24(-3.679,-12.304) V25(-4.142,-12.76) V26(-4.606,-12.304) V27(-5.069,-12.76) V28(-5.719,-12.76) V29(-6.369,-12.76) V30(-7.019,-12.76) V31(-7.669,-12.76) V32(-8.32,-12.76) V33(-9.04,-12.585) V34(-9.69,-12.585) W4(9.365,-11.547) W5(8.617,-12.009) W6(7.967,-12.009) W7(7.317,-12.009) W8(6.668,-12.009) W9(6.21,-11.548) W10(5.753,-12.009) W25(-4.142,-11.848) W27(-5.069,-11.848) W28(-5.719,-11.848) W29(-6.369,-11.848) W30(-7.019,-11.848) W31(-7.669,-11.848) W32(-8.32,-11.848) W34(-9.365,-11.934) Y4(9.69,-10.984) Y5(8.617,-11.086) Y6(7.967,-11.086) Y7(7.317,-11.086) Y8(6.668,-11.086) Y10(5.753,-11.086) Y24(-3.679,-11.392) Y25(-4.142,-10.937) Y26(-4.606,-11.392) Y27(-5.069,-10.937) Y28(-5.719,-10.937) Y29(-6.369,-10.937) Y30(-7.019,-10.937) Y31(-7.669,-10.937) Y32(-8.32,-10.937) Y33(-9.04,-11.327) Y35(-10.245,-11.327)
  oval 0.254x0.343 smd: A8(6.915,-22.315) A22(-1.883,-22.315) A24(-3.184,-22.315) A26(-4.4,-22.315) A28(-5.701,-22.315) A30(-6.917,-22.315) B6(8.216,-21.665) B7(7.565,-21.99) B8(6.915,-21.665) B9(6.305,-21.895) B21(-1.275,-21.895) B22(-1.883,-21.665) B23(-2.534,-21.99) B24(-3.184,-21.665) B25(-3.792,-21.895) B26(-4.4,-21.665) B27(-5.051,-21.99) B28(-5.701,-21.665) B29(-6.309,-21.895) B30(-6.917,-21.665) B31(-7.568,-21.99) B32(-8.218,-21.665) C6(8.216,-21.015) C7(7.565,-21.34) C8(6.999,-21.021) C22(-1.883,-21.015) C23(-2.534,-21.34) C24(-3.184,-21.015) C26(-4.4,-21.015) C27(-5.051,-21.34) C28(-5.701,-21.015) C30(-6.917,-21.015) C31(-7.568,-21.34) C32(-8.218,-21.015) CN6(8.216,21.015) CN7(7.565,21.34) CN8(6.999,21.021) CN10(5.61,21.021) CN11(5.044,21.34) CN12(4.478,21.021) CN14(3.088,21.021) CN15(2.522,21.34) CN16(1.956,21.021) CN18(0.566,21.021) CN19(0,21.34) CN20(-0.566,21.021) CN22(-1.956,21.021) CN23(-2.522,21.34) CN24(-3.088,21.021) CN26(-4.478,21.021) CN27(-5.044,21.34) CN28(-5.61,21.021) CN30(-6.912,21.014) CN31(-7.605,21.461) CN32(-8.219,21.014) CP6(8.216,21.665) CP7(7.565,21.99) CP8(6.915,21.665) CP9(6.305,21.895) CP10(5.694,21.665) CP11(5.044,21.99) CP12(4.393,21.665) CP13(3.783,21.895) CP14(3.172,21.665) CP15(2.522,21.99) CP16(1.871,21.665) CP17(1.261,21.895) CP18(0.65,21.665) CP19(0,21.99) CP20(-0.65,21.665) CP21(-1.261,21.895) CP22(-1.871,21.665) CP23(-2.522,21.99) CP24(-3.172,21.665) CP25(-3.783,21.895) CP26(-4.393,21.665) CP27(-5.044,21.99) CP28(-5.694,21.665) CP29(-6.305,21.895) CP30(-6.983,21.669) CP31(-7.605,22.19) CP32(-8.296,21.665) CR8(6.915,22.315) CR10(5.694,22.315) CR12(4.393,22.315) CR14(3.172,22.315) CR16(1.871,22.315) CR18(0.65,22.315) CR20(-0.65,22.315) CR22(-1.871,22.315) CR24(-3.172,22.315) CR26(-4.393,22.315) CR28(-5.694,22.315) CR30(-6.912,22.315)
  round 0.406 smd: A11(5.322,-22.315) A12(4.38,-22.315) A14(3.438,-22.315) A15(2.496,-22.315) A17(1.554,-22.315) A18(0.613,-22.315) A20(-0.329,-22.315) B11(5.322,-21.665) B12(4.38,-21.665) B14(3.438,-21.665) B15(2.496,-21.665) B17(1.554,-21.665) B18(0.613,-21.665) B20(-0.329,-21.665) C11(5.322,-21.015) C12(4.38,-21.015) C14(3.438,-21.015) C15(2.496,-21.015) C17(1.554,-21.015) C18(0.613,-21.015) C20(-0.329,-21.015) D11(5.322,-20.365) D12(4.38,-20.365) D14(3.438,-20.365) D15(2.496,-20.365) D17(1.554,-20.365) D18(0.613,-20.365) D20(-0.329,-20.365) F11(5.322,-19.715) F12(4.38,-19.715) F14(3.438,-19.715) F15(2.496,-19.715) F17(1.554,-19.715) F18(0.613,-19.715) F20(-0.329,-19.715) G11(5.322,-19.065) G12(4.38,-19.065) G14(3.438,-19.065) G15(2.496,-19.065) G17(1.554,-19.065) G18(0.613,-19.065) G20(-0.329,-19.065) H11(5.322,-18.415) H12(4.38,-18.415) H14(3.438,-18.415) H15(2.496,-18.415) H17(1.554,-18.415) H18(0.613,-18.415) H20(-0.329,-18.415) J11(5.322,-17.765) J12(4.38,-17.765) J14(3.438,-17.765) J15(2.496,-17.765) J17(1.554,-17.765) J18(0.613,-17.765) J20(-0.329,-17.765)
  oval 0.343x0.254 smd: AA1(11.315,-10.421) AA2(10.665,-10.421) AA3(10.015,-10.421) AA35(-10.015,-10.719) AA36(-10.665,-10.719) AA37(-11.315,-10.719) AB2(10.99,-9.763) AB35(-10.34,-10.068) AB36(-10.99,-10.068) AC1(11.315,-9.106) AC2(10.665,-9.106) AC3(10.015,-9.106) AC35(-10.015,-9.417) AC36(-10.665,-9.417) AC37(-11.315,-9.417) AD3(10.34,-8.543) AD36(-10.895,-8.809) AE1(11.315,-7.98) AE2(10.665,-7.98) AE3(10.015,-7.98) AE35(-10.015,-8.202) AE36(-10.665,-8.202) AE37(-11.315,-8.202) AF2(10.99,-7.322) AF35(-10.34,-7.551) AF36(-10.99,-7.551) AG1(11.315,-6.665) AG2(10.665,-6.665) AG3(10.015,-6.665) AG35(-10.015,-6.9) AG36(-10.665,-6.9) AG37(-11.315,-6.9) AH3(10.34,-6.102) AH36(-10.895,-6.293) AJ1(11.315,-5.539) AJ2(10.665,-5.539) AJ3(10.015,-5.539) AJ35(-10.015,-5.685) AJ36(-10.665,-5.685) AJ37(-11.315,-5.685) AK2(10.99,-4.882) AK35(-10.34,-5.034) AK36(-10.99,-5.034) AL1(11.315,-4.224) AL2(10.665,-4.224) AL3(10.015,-4.224) AL35(-10.015,-4.383) AL36(-10.665,-4.383) AL37(-11.315,-4.383) AM3(10.34,-3.661) AM36(-10.895,-3.775) AN1(11.315,-3.098) AN2(10.665,-3.098) AN3(10.015,-3.098) AN35(-10.015,-3.168) AN36(-10.665,-3.168) AN37(-11.315,-3.168) AP2(10.99,-2.441) AP35(-10.34,-2.517) AP36(-10.99,-2.517) AR1(11.315,-1.783) AR2(10.665,-1.783) AR3(10.015,-1.783) AR35(-10.015,-1.866) AR36(-10.665,-1.866) AR37(-11.315,-1.866) AT3(10.34,-1.22) AT36(-10.895,-1.259) AU1(11.315,-0.657) AU2(10.665,-0.657) AU3(10.015,-0.657) AU35(-10.015,-0.65) AU36(-10.665,-0.65) AU37(-11.315,-0.65) AV2(10.99,0) AV35(-10.34,0) AV36(-10.99,0) AW1(11.315,0.657) AW2(10.665,0.657) AW3(10.015,0.657) AW35(-10.015,0.65) AW36(-10.665,0.65) AW37(-11.315,0.65) AY3(10.34,1.22) AY36(-10.895,1.259) BA1(11.315,1.783) BA2(10.665,1.783) BA3(10.015,1.783) BA35(-10.015,1.866) BA36(-10.665,1.866) BA37(-11.315,1.866) BB2(10.99,2.441) BB35(-10.34,2.517) BB36(-10.99,2.517) BC1(11.315,3.098) BC2(10.665,3.098) BC3(10.015,3.098) BC35(-10.015,3.168) BC36(-10.665,3.168) BC37(-11.315,3.168) BD3(10.34,3.661) BD36(-10.895,3.775) BE1(11.315,4.224) BE2(10.665,4.224) BE3(10.015,4.224) BE35(-10.015,4.383) BE36(-10.665,4.383) BE37(-11.315,4.383) BF2(10.99,4.882) BF35(-10.34,5.034) BF36(-10.99,5.034) BG1(11.315,5.539) BG2(10.665,5.539) BG3(10.015,5.539) BG35(-10.015,5.685) BG36(-10.665,5.685) BG37(-11.315,5.685) BH3(10.34,6.102) BH36(-10.895,6.293) BJ1(11.315,6.665) BJ2(10.665,6.665) BJ3(10.015,6.665) BJ35(-10.015,6.9) BJ36(-10.665,6.9) BJ37(-11.315,6.9) BK2(10.99,7.322) BK35(-10.34,7.551) BK36(-10.99,7.551) BL1(11.315,7.98) BL2(10.665,7.98) BL3(10.015,7.98) BL35(-10.015,8.202) BL36(-10.665,8.202) BL37(-11.315,8.202) BM3(10.34,8.543) BM36(-10.895,8.809) BN1(11.315,9.106) BN2(10.665,9.106) BN3(10.015,9.106) BN35(-10.015,9.417) BN36(-10.665,9.417) BN37(-11.315,9.417) BP2(10.99,9.763) BP35(-10.34,10.068) BP36(-10.99,10.068) BR1(11.315,10.421) BR2(10.665,10.421) BR3(10.015,10.421) BR35(-10.015,10.719) BR36(-10.665,10.719) BR37(-11.315,10.719) BT3(10.34,10.984) BT36(-10.895,11.327) BU1(11.315,11.547) BU2(10.665,11.547) BU3(10.015,11.547) BU35(-10.015,11.934) BU36(-10.665,11.934) BU37(-11.315,11.934) BV2(10.99,12.204) BV35(-10.34,12.585) BV36(-10.99,12.585) BW1(11.315,12.861) BW2(10.665,12.861) BW3(10.015,12.861) BW35(-10.015,13.236) BW36(-10.665,13.236) BW37(-11.315,13.236) BY3(10.34,13.424) BY36(-10.895,13.844) CA1(11.315,13.988) CA2(10.665,13.988) CA3(10.015,13.988) CA35(-10.015,14.451) CA36(-10.665,14.451) CA37(-11.315,14.451) CB2(10.99,14.645) CB35(-10.34,15.102) CB36(-10.99,15.102) CC1(11.315,15.302) CC2(10.665,15.302) CC3(10.015,15.302) CC35(-10.015,15.753) CC36(-10.665,15.753) CC37(-11.315,15.753) CD3(10.34,15.865) CE1(11.315,16.428) CE2(10.665,16.428) CE3(10.015,16.428) CE36(-10.895,16.36) CF2(10.99,17.086) CF35(-10.015,16.968) CF36(-10.665,16.968) CF37(-11.315,16.968) CG1(11.315,17.743) CG2(10.665,17.743) CG3(10.015,17.743) CG35(-10.34,17.619) CG36(-10.99,17.619) CH3(10.34,18.306) CH35(-10.015,18.27) CH36(-10.665,18.27) CH37(-11.315,18.27) CJ1(11.315,18.869) CJ2(10.665,18.869) CJ3(10.015,18.869) CJ36(-10.895,18.878) CK2(10.485,19.555) G2(10.665,-18.869) G3(10.015,-18.869) G36(-10.895,-18.878) H3(10.34,-18.306) H35(-10.015,-18.27) H36(-10.665,-18.27) H37(-11.315,-18.27) J1(11.315,-17.743) J2(10.665,-17.743) J3(10.015,-17.743) J35(-10.34,-17.619) J36(-10.99,-17.619) K2(10.99,-17.086) K35(-10.015,-16.968) K36(-10.665,-16.968) K37(-11.315,-16.968) L1(11.315,-16.428) L2(10.665,-16.428) L3(10.015,-16.428) L36(-10.895,-16.36) M3(10.34,-15.865) N1(11.315,-15.302) N2(10.665,-15.302) N3(10.015,-15.302) N35(-10.015,-15.753) N36(-10.665,-15.753) N37(-11.315,-15.753) P2(10.99,-14.645) P35(-10.34,-15.102) P36(-10.99,-15.102) R1(11.315,-13.988) R2(10.665,-13.988) R3(10.015,-13.988) R35(-10.015,-14.451) R36(-10.665,-14.451) R37(-11.315,-14.451) T3(10.34,-13.424) T36(-10.895,-13.844) U1(11.315,-12.861) U2(10.665,-12.861) U3(10.015,-12.861) U35(-10.015,-13.236) U36(-10.665,-13.236) U37(-11.315,-13.236) V2(10.99,-12.204) V35(-10.34,-12.585) V36(-10.99,-12.585) W1(11.315,-11.547) W2(10.665,-11.547) W3(10.015,-11.547) W35(-10.015,-11.934) W36(-10.665,-11.934) W37(-11.315,-11.934) Y3(10.34,-10.984) Y36(-10.895,-11.327)
CRESCENT-6012B0240012-003
  rect 0.356x0.965 smd: 1(-2.25,3.05) 2(-1.75,3.05) 3(-1.25,3.05) 4(-0.75,3.05) 5(-0.25,3.05) 6(0.25,3.05) 7(0.75,3.05) 8(1.25,3.05) 9(1.75,3.05) 10(2.25,3.05)
  rect 0.991x1.499 smd: G1(-4.35,0) G2(4.35,0)
CS_350X280X200_2
  rect 1.6x2.692 smd: 1(-1.501,0) 2(1.501,0)
CS_730X430X200_2_610
  rect 2.388x2.896 smd: 1(-3.051,0) 2(3.051,0)
CS_730X430X210_2
  rect 2.388x2.794 smd: 1(-3.2,0) 2(3.2,0)
CSC_060X030X030_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
CSC_060X030X033_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
CSC_060X030X035_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
CSC_060X030X039_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
CSC_100X050X040_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
CSC_100X050X055_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
CSC_100X050X055_2_NP
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
CSC_100X050X065_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
CSC_100X050X070_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
CSC_160X080X080_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
CSC_160X080X090_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
CSC_160X080X095_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
CSC_160X080X100_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
CSC_200X125X130_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
CSC_200X125X135_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
CSC_200X125X140_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
CST_320X160X180_2_245
  rect 1.346x1.499 smd: 1(-1.227,0) 2(1.227,0)
DESD_060X030X032_2_040
  rect 0.297x0.381 smd: 1(-0.2,0) 2(0.2,0)
DS_060X030X025_2_043
  rect 0.297x0.356 smd: 1(-0.213,0) 2(0.213,0)
DS_060X030X030_2_040
  rect 0.305x0.305 smd: 1(-0.2,0) 2(0.2,0)
DS_250X100X055_10_050_P2
  rect 0.356x0.762 smd: 1(-1.001,-0.437) 2(-0.5,-0.437) 3(0,-0.437) 4(0.5,-0.437) 5(1.001,-0.437) 6(1.001,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1.001,0.437)
  rect 0.356x0.965 smd: 8(0,0.338)
DS_292X130X110_3_190
  rect 1.016x1.016 smd: 1(-0.953,-1.049) 2(0.953,-1.049) 3(0,1.049)
DSOD323_185X125X095_2_231
  rect 0.559x0.813 smd: 1(-1.152,0) 2(1.152,0)
DSOD523_120X080X070_2_150_P2
  rect 0.61x0.787 smd: 1(-0.749,0) 2(0.749,0)
DSOT23_290X130X110_3_095_NP
  rect 0.61x0.711 smd: 1(-0.95,-1.001) 2(0.95,-1.001) 3(0,1.001)
DSOT23_290X130X110_3_095_P2
  rect 0.787x0.889 smd: 1(-0.95,-1.001) 2(0.95,-1.001) 3(0,1.001)
DSOT23_290X130X110_3_095_P3
  rect 0.61x0.711 smd: 1(-0.95,-1.001) 2(0.95,-1.001) 3(0,1.001)
DSOT23_290X130X115_3_095
  rect 0.889x1.397 smd: 1(-0.95,-1.05) 2(0.95,-1.05) 3(0,1.05)
DSSOD123_280X180X100_2
  rect 2.311x1.397 smd: 1(-0.9,0)
  rect 1.245x1.397 smd: 2(1.425,0)
DSSOT23_290X130X110_3_095-2
  rect 0.508x1.219 smd: 1(0.95,-1.085) 2(-0.95,-1.085) 3(0,1.085)
DSSOT363_200X125X110_6_065
  rect 0.406x0.889 smd: 1(-0.65,-0.889) 2(0,-0.889) 3(0.65,-0.889) 4(0.65,0.889) 5(0,0.889) 6(-0.65,0.889)
FGR_SOLDERING_560X134X151X015
  rect 6.198x1.651 smd: 1(0,0)
FIX_MASK_080
  round 0.813 smd: 1(0,0)
FPC_ACES_8_050_R_120_1
  rect 0.356x0.737 smd: 1(1.75,2.075) 2(1.25,2.075) 3(0.752,2.075) 4(0.249,2.075) 5(-0.249,2.075) 6(-0.752,2.075) 7(-1.25,2.075) 8(-1.75,2.075)
  rect 0.559x0.787 smd: G1(2.675,0) G2(-2.675,0)
FPC_ACES_15_050_R_100_2
  rect 0.356x0.864 smd: 1(3.5,2.5) 2(3,2.5) 3(2.5,2.5) 4(2,2.5) 5(1.5,2.5) 6(1,2.5) 7(0.5,2.5) 8(0,2.5) 9(-0.5,2.5) 10(-1,2.5) 11(-1.5,2.5) 12(-2,2.5) 13(-2.5,2.5) 14(-3,2.5) 15(-3.5,2.5)
  rect 0.406x0.787 smd: G1(4.5,0) G2(-4.5,0)
FPC_ENTRY_8_050_R_100
  rect 0.356x0.864 smd: 1(-1.75,2.4) 2(-1.25,2.4) 3(-0.75,2.4) 4(-0.25,2.4) 5(0.25,2.4) 6(0.75,2.4) 7(1.25,2.4) 8(1.75,2.4)
  rect 0.406x0.787 smd: G1(-2.75,-0.1) G2(2.75,-0.1)
FPC_HRS_15_050_R_175
  rect 0.356x0.914 smd: 1(-3.5,3.175) 2(-3,3.175) 3(-2.5,3.175) 4(-2,3.175) 5(-1.5,3.175) 6(-1,3.175) 7(-0.5,3.175) 8(0,3.175) 9(0.5,3.175) 10(1,3.175) 11(1.5,3.175) 12(2,3.175) 13(2.5,3.175) 14(3,3.175) 15(3.5,3.175)
  rect 0.787x2.007 smd: G1(-5.2,0) G2(5.2,0)
FPC_PTWO_42_050_R_160
  rect 0.356x1.321 smd: 1(-10.25,3.275) 2(-9.75,3.275) 3(-9.25,3.275) 4(-8.75,3.275) 5(-8.25,3.275) 6(-7.75,3.275) 7(-7.25,3.275) 8(-6.75,3.275) 9(-6.25,3.275) 10(-5.75,3.275) 11(-5.25,3.275) 12(-4.75,3.275) 13(-4.25,3.275) 14(-3.75,3.275) 15(-3.25,3.275) 16(-2.75,3.275) 17(-2.25,3.275) 18(-1.75,3.275) 19(-1.25,3.275) 20(-0.75,3.275) 21(-0.25,3.275) 22(0.25,3.275) 23(0.75,3.275) 24(1.25,3.275) 25(1.75,3.275) 26(2.25,3.275) 27(2.75,3.275) 28(3.25,3.275) 29(3.75,3.275) 30(4.25,3.275) 31(4.75,3.275) 32(5.25,3.275) 33(5.75,3.275) 34(6.25,3.275) 35(6.75,3.275) 36(7.25,3.275) 37(7.75,3.275) 38(8.25,3.275) 39(8.75,3.275) 40(9.25,3.275) 41(9.75,3.275) 42(10.25,3.275)
  rect 1.397x1.194 smd: G1(-12.705,0) G2(12.705,0)
FUSE_210X135X075_2_220
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
HDMI_TCONN_19_RS_225_261
  round 0.787 hole 0.559: 1(-4.5,6.55) 2(-4,8.1) 3(-3.5,6.55) 4(-3,8.1) 5(-2.5,6.55) 6(-2,8.1) 7(-1.5,6.55) 8(-1,8.1) 9(-0.5,6.55) 10(0,8.1) 11(0.5,6.55) 12(1,8.1) 13(1.5,6.55) 14(2,8.1) 15(2.5,6.55) 16(3,8.1) 17(3.5,6.55) 18(4,8.1) 19(4.5,6.55)
  oval 1.499x2.21 hole 0.889x1.6: G1(-7.45,6.8) G2(7.45,6.8) G3(-9.15,0) G4(9.15,0)
IC-HALL_MST_3_SMD_105
  rect 0.787x0.787 smd: GND(0,1.01) OUTPUT(0.95,-1.01) VDD(-0.95,-1.01)
LADYLUCK-6012B0446101-002
  rect 0.787x2.007 smd: 1(-1.877,3.101) 2(-0.627,3.101) 3(0.625,3.101) 4(1.875,3.101)
  rect 1.6x2.997 smd: G1(4.675,0) G2(-4.677,0)
LADYLUCK-6014B0026101-007
  rect 1.854x3.099 smd: 1(-2.776,0) 2(2.776,0)
LED_LITON_V_150X160X055_S_YW
  rect 0.66x0.838 smd: 1(0.425,0.725) 2(-0.425,0.725) 3(0.425,-0.725) 4(-0.425,-0.725)
LS_065X050X035_4_050
  rect 0.297x0.356 smd: 1(-0.24,-0.25) 2(-0.24,0.25) 3(0.24,0.25) 4(0.24,-0.25)
LS_100X125X090_6
  rect 0.381x0.584 smd: 1(-0.288,-0.575) 2(-0.288,0.575) 3(0.288,0.575) 4(0.288,-0.575)
  rect 0.457x0.279 smd: 5(-0.475,0) 6(0.475,0)
LS_160X080X095_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
LS_400X400X180_2_280
  rect 1.194x3.708 smd: 1(-1.4,0) 2(1.4,0)
LS_440X420X120_2_370
  rect 1.499x2.489 smd: 1(-1.85,0) 2(1.85,0)
LS_660X660X300_4_P3
  rect 0.381x0.457 smd: (-3.296,0.002) (3.294,0.001)
  custom 0.462x0.462 smd: 1(-2.776,1.008) 2(2.776,1.008)
  rect 1.295x0.254 smd: 3(-2.503,0) 4(2.501,0)
LS_700X660X300_2_555
  rect 1.953x3.505 smd: 1(-2.776,0) 2(2.776,0)
LS_730X680X300_4
  rect 0.381x0.457 smd: (-3.923,-0.001) (3.928,0.002)
  custom 0.622x0.622 smd: 1(-3.1,0.762) 2(3.1,0.762)
  rect 1.905x0.254 smd: 3(-2.808,0) 4(2.808,0)
LS_1000X1000X300_4_P2
  custom 0.875x0.875 smd: 1(-4,1.016) 2(4,1.016)
  rect 3.15x0.254 smd: 3(-3.823,0) 4(3.823,0)
MICP_KNOW_8_100_2
  rect 0.457x0.94 smd: 1(-0.425,-0.675) 2(-0.425,0.675) 3(0.425,0.675) 4(0.425,-0.675)
  custom 0.081x0.081 smd: 5(0,-1.712) 6(-1.213,0) 7(0,1.712) 8(1.213,0)
MICRO_300X300X110_8_065
  rect 0.381x1.041 smd: 1(-0.975,-2.12) 2(-0.325,-2.12) 3(0.325,-2.12) 4(0.975,-2.12) 5(0.975,2.12) 6(0.325,2.12) 7(-0.325,2.12) 8(-0.975,2.12)
MOSFET_300X300X080_8_065
  rect 0.432x0.869 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.636x0.636 smd: 5(0.975,1.527)
  rect 0.432x0.744 smd: 6(0.325,1.527) 7(-0.325,1.527) 8(-0.975,1.527)
MOSFET_300X300X090_8_065
  rect 0.432x0.869 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.636x0.636 smd: 5(0.975,1.527)
  rect 0.432x0.744 smd: 6(0.325,1.527) 7(-0.325,1.527) 8(-0.975,1.527)
MOSFET_300X300X100_8_065
  rect 0.432x0.869 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.636x0.636 smd: 5(0.975,1.527)
  rect 0.432x0.744 smd: 6(0.325,1.527) 7(-0.325,1.527) 8(-0.975,1.527)
MOSFET_500X600X100_8_127
  rect 0.61x1.473 smd: 1(-1.905,-2.756) 2(-0.635,-2.756) 3(0.635,-2.756) 4(1.905,-2.756)
  custom 1.274x1.274 smd: 5(1.905,2.797)
  rect 0.61x1.245 smd: 6(0.635,2.797) 7(-0.635,2.797) 8(-1.905,2.797)
MQFN_600X600X100_48_040_T1
  rect 0.297x0.864 smd: 1(-2.2,-2.901) 2(-1.801,-2.901) 3(-1.4,-2.901) 4(-1.001,-2.901) 5(-0.599,-2.901) 6(-0.201,-2.901) 7(0.201,-2.901) 8(0.599,-2.901) 9(1.001,-2.901) 10(1.4,-2.901) 11(1.801,-2.901) 12(2.2,-2.901) 25(2.2,2.901) 26(1.801,2.901) 27(1.4,2.901) 28(1.001,2.901) 29(0.599,2.901) 30(0.201,2.901) 31(-0.201,2.901) 32(-0.599,2.901) 33(-1.001,2.901) 34(-1.4,2.901) 35(-1.801,2.901) 36(-2.2,2.901)
  rect 0.864x0.297 smd: 13(2.901,-2.2) 14(2.901,-1.801) 15(2.901,-1.4) 16(2.901,-1.001) 17(2.901,-0.599) 18(2.901,-0.201) 19(2.901,0.201) 20(2.901,0.599) 21(2.901,1.001) 22(2.901,1.4) 23(2.901,1.801) 24(2.901,2.2) 37(-2.901,2.2) 38(-2.901,1.801) 39(-2.901,1.4) 40(-2.901,1.001) 41(-2.901,0.599) 42(-2.901,0.201) 43(-2.901,-0.201) 44(-2.901,-0.599) 45(-2.901,-1.001) 46(-2.901,-1.4) 47(-2.901,-1.801) 48(-2.901,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
MSOP_300X300X110_8_065_P3
  rect 0.508x1.295 smd: 1(-0.975,-2.197) 2(-0.325,-2.197) 3(0.325,-2.197) 4(0.975,-2.197) 5(0.975,2.197) 6(0.325,2.197) 7(-0.325,2.197) 8(-0.975,2.197)
NGFF_LOTES_67_050_B_305
  round 1.6 hole 1.6 unplated: (-10,0)
  round 1.092 hole 1.092 unplated: (10,0)
  rect 0.356x1.626 smd: 1(9.251,-5.276) 2(8.999,2.276) 3(8.748,-5.276) 4(8.499,2.276) 5(8.25,-5.276) 6(8.001,2.276) 7(7.75,-5.276) 8(7.501,2.276) 9(7.249,-5.276) 10(7,2.276) 11(6.749,-5.276) 20(4.501,2.276) 21(4.249,-5.276) 22(4,2.276) 23(3.749,-5.276) 24(3.5,2.276) 25(3.251,-5.276) 26(3,2.276) 27(2.751,-5.276) 28(2.499,2.276) 29(2.25,-5.276) 30(1.999,2.276) 31(1.75,-5.276) 32(1.501,2.276) 33(1.25,-5.276) 34(1.001,2.276) 35(0.749,-5.276) 36(0.5,2.276) 37(0.249,-5.276) 38(0,2.276) 39(-0.249,-5.276) 40(-0.5,2.276) 41(-0.752,-5.276) 42(-1.001,2.276) 43(-1.252,-5.276) 44(-1.501,2.276) 45(-1.75,-5.276) 46(-2.002,2.276) 47(-2.25,-5.276) 48(-2.499,2.276) 49(-2.751,-5.276) 50(-3.002,2.276) 51(-3.251,-5.276) 52(-3.5,2.276) 53(-3.752,-5.276) 54(-4,2.276) 55(-4.252,-5.276) 56(-4.501,2.276) 57(-4.75,-5.276) 58(-5.001,2.276) 59(-5.25,-5.276) 60(-5.502,2.276) 61(-5.751,-5.276) 62(-6.002,2.276) 63(-6.251,-5.276) 64(-6.502,2.276) 65(-6.749,-5.276) 66(-7,2.276) 67(-7.252,-5.276) 68(-7.501,2.276) 69(-7.752,-5.276) 70(-8.001,2.276) 71(-8.252,-5.276) 72(-8.501,2.276) 73(-8.75,-5.276) 74(-9.002,2.276) 75(-9.251,-5.276)
  rect 1.194x2.743 smd: G1(10.351,-4.501) G2(-10.351,-4.501)
NGFF_LOTES_67_050_E_308
  round 1.6 hole 1.6 unplated: (-10,0)
  round 1.092 hole 1.092 unplated: (10,0)
  rect 0.356x1.626 smd: 1(9.25,-5.275) 2(9,2.275) 3(8.75,-5.275) 4(8.5,2.275) 5(8.25,-5.275) 6(8,2.275) 7(7.75,-5.275) 8(7.5,2.275) 9(7.25,-5.275) 10(7,2.275) 11(6.75,-5.275) 12(6.5,2.275) 13(6.25,-5.275) 14(6,2.275) 15(5.75,-5.275) 16(5.5,2.275) 17(5.25,-5.275) 18(5,2.275) 19(4.75,-5.275) 20(4.5,2.275) 21(4.25,-5.275) 22(4,2.275) 23(3.75,-5.275) 32(1.5,2.275) 33(1.25,-5.275) 34(1,2.275) 35(0.75,-5.275) 36(0.5,2.275) 37(0.25,-5.275) 38(0,2.275) 39(-0.25,-5.275) 40(-0.5,2.275) 41(-0.75,-5.275) 42(-1,2.275) 43(-1.25,-5.275) 44(-1.5,2.275) 45(-1.75,-5.275) 46(-2,2.275) 47(-2.25,-5.275) 48(-2.5,2.275) 49(-2.75,-5.275) 50(-3,2.275) 51(-3.25,-5.275) 52(-3.5,2.275) 53(-3.75,-5.275) 54(-4,2.275) 55(-4.25,-5.275) 56(-4.5,2.275) 57(-4.75,-5.275) 58(-5,2.275) 59(-5.25,-5.275) 60(-5.5,2.275) 61(-5.75,-5.275) 62(-6,2.275) 63(-6.25,-5.275) 64(-6.5,2.275) 65(-6.75,-5.275) 66(-7,2.275) 67(-7.25,-5.275) 68(-7.5,2.275) 69(-7.75,-5.275) 70(-8,2.275) 71(-8.25,-5.275) 72(-8.5,2.275) 73(-8.75,-5.275) 74(-9,2.275) 75(-9.25,-5.275)
  rect 1.194x2.743 smd: G1(10.35,-4.5) G2(-10.35,-4.5)
OLYMPIA-6026B0270301-004
  round 1.092 hole 1.092 unplated: (0,2.002)
  round 0.889 hole 0.889 unplated: (0,-1.999)
  custom 0.163x0.163 smd: 1(-3.907,-3.823) 2(-2.634,-3.823) 3(-1.367,-3.823) 4(-0.097,-3.823) 5(-0.097,3.828) 6(-1.367,3.828) 7(-2.634,3.828) 8(-3.907,3.828)
POWERPAD1X1M
  custom 0.194x0.194 smd: 1(-0.437,0) 2(0.437,0)
POWERPAD2X2M
  custom 0.252x0.252 smd: 1(0,0) 2(1.27,0)
POWERPAD_2_0610
  custom 0.252x0.252 smd: 1(0,0) 2(1.27,0)
POWERPAD_2_0805
  custom 0.324x0.324 smd: 1(-0.9,0) 2(0.9,0)
POWERPAD_4_0610_SHORT
  rect 0.229x0.838 smd: (0.17,-0.775)
  rect 0.635x0.229 smd: (0.577,-0.47)
  rect 0.399x0.254 smd: (1.185,-0.607)
  custom 0.252x0.252 smd: 1(0,0) 2(1.27,0)
  rect 0.635x0.635 smd: 3(0.577,-0.876)
  rect 0.399x0.5 smd: 4(1.185,-0.944)
QFN_250X250X065_16_045_T1
  custom 0.075x0.075 smd: 1(-0.675,-1.2) 2(-0.225,-1.2) 3(0.225,-1.2) 4(0.675,-1.2) 5(1.2,-0.675) 6(1.2,-0.225) 7(1.2,0.225) 8(1.2,0.675) 9(0.675,1.2) 10(0.225,1.2) 11(-0.225,1.2) 12(-0.675,1.2) 13(-1.2,0.675) 14(-1.2,0.225) 15(-1.2,-0.225) 16(-1.2,-0.675)
  rect 0.61x0.61 smd: 17(0,0)
QFN_300X200X100_12_050
  rect 0.356x1.575 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 7(0,0.55)
  rect 0.787x0.356 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 9(-1.45,0.75) 10(-1.45,0.25) 11(-1.45,-0.25) 12(-1.45,-0.75)
  rect 0.356x0.787 smd: 8(-0.5,0.95)
QFN_300X200X100_13_050
  rect 0.356x1.575 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.787x0.356 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.356x0.787 smd: 7(0.5,0.95) 9(-0.5,0.95)
QFN_300X300X080_16_050_T1
  custom 0.089x0.089 smd: 1(-0.752,-1.476) 2(-0.249,-1.476) 3(0.249,-1.476) 4(0.752,-1.476) 5(1.476,-0.752) 6(1.476,-0.249) 7(1.476,0.249) 8(1.476,0.752) 9(0.752,1.476) 10(0.249,1.476) 11(-0.249,1.476) 12(-0.752,1.476) 13(-1.476,0.752) 14(-1.476,0.249) 15(-1.476,-0.249) 16(-1.476,-0.752)
  rect 1.702x1.702 smd: 17(0,0)
QFN_300X300X090_20_045_T2
  custom 0.075x0.075 smd: 1(-0.9,-1.45) 5(0.9,-1.45) 6(1.45,-0.9) 10(1.45,0.9) 11(0.9,1.45) 15(-0.9,1.45) 16(-1.45,0.9) 20(-1.45,-0.9)
  rect 0.297x0.762 smd: 2(-0.45,-1.45) 3(0,-1.45) 4(0.45,-1.45) 12(0.45,1.45) 13(0,1.45) 14(-0.45,1.45)
  rect 0.762x0.297 smd: 7(1.45,-0.45) 8(1.45,0) 9(1.45,0.45) 17(-1.45,0.45) 18(-1.45,0) 19(-1.45,-0.45)
  rect 1.092x1.092 smd: 21(0,0)
QFN_300X300X100_16_050_P1
  rect 0.356x2.184 smd: 1(-0.5,-0.75) 2(0.5,-0.75) 9(0,0.75)
  rect 0.787x0.356 smd: 3(1.45,-1.25) 4(1.45,-0.75) 5(1.45,-0.25) 6(1.45,0.25) 7(1.45,0.75) 8(1.45,1.25) 11(-1.45,1.25) 12(-1.45,0.75) 13(-1.45,0.25) 14(-1.45,-0.25) 15(-1.45,-0.75) 16(-1.45,-1.25)
  rect 0.356x0.965 smd: 10(-0.5,1.359)
QFN_300X400X085_13
  custom 0.337x0.337 smd: 1(0.25,-1.68)
  rect 1.702x0.457 smd: 2(1,-0.5) 12(-1,-0.5)
  rect 1.702x0.838 smd: 3(1,0.38) 11(-1,0.35)
  rect 0.787x0.203 smd: 4(1.45,1.13) 10(-1.45,1.13)
  rect 0.297x0.864 smd: 5(0.9,1.95) 6(0.45,1.95) 7(0,1.95) 8(-0.45,1.95) 9(-0.9,1.95)
  rect 0.787x0.254 smd: 13(-1.45,-1.125)
QFN_700X700X090_56_040_T6
  custom 0.074x0.074 smd: 1(-2.601,-3.475) 2(-2.2,-3.475) 3(-1.801,-3.475) 4(-1.4,-3.475) 5(-1.001,-3.475) 6(-0.599,-3.475) 7(-0.201,-3.475) 8(0.201,-3.475) 9(0.599,-3.475) 10(1.001,-3.475) 11(1.4,-3.475) 12(1.801,-3.475) 13(2.2,-3.475) 14(2.601,-3.475) 15(3.475,-2.601) 16(3.475,-2.2) 17(3.475,-1.801) 18(3.475,-1.4) 19(3.475,-1.001) 20(3.475,-0.599) 21(3.475,-0.201) 22(3.475,0.201) 23(3.475,0.599) 24(3.475,1.001) 25(3.475,1.4) 26(3.475,1.801) 27(3.475,2.2) 28(3.475,2.601) 29(2.601,3.475) 30(2.2,3.475) 31(1.801,3.475) 32(1.4,3.475) 33(1.001,3.475) 34(0.599,3.475) 35(0.201,3.475) 36(-0.201,3.475) 37(-0.599,3.475) 38(-1.001,3.475) 39(-1.4,3.475) 40(-1.801,3.475) 41(-2.2,3.475) 42(-2.601,3.475) 43(-3.475,2.601) 44(-3.475,2.2) 45(-3.475,1.801) 46(-3.475,1.4) 47(-3.475,1.001) 48(-3.475,0.599) 49(-3.475,0.201) 50(-3.475,-0.201) 51(-3.475,-0.599) 52(-3.475,-1.001) 53(-3.475,-1.4) 54(-3.475,-1.801) 55(-3.475,-2.2) 56(-3.475,-2.601)
  rect 4.699x3.912 smd: 57(0,0)
RANGERS-6010B0044902-001
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
REBORN-60130B4R700T-002
  rect 0.813x0.813 smd: 1(-0.804,0) 2(0.804,0)
RSC_060X030X025_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_060X030X026_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_060X030X030_2
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_060X030X030_2_5_SHORT
  rect 0.254x0.127 smd: (0,0)
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_060X030X030_2_10_SHORT
  rect 0.305x0.254 smd: (0,0)
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_060X030X030_2_NP
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_060X030X030_2_NSP
  custom 0.075x0.075 smd: 1(-0.249,0) 2(0.249,0)
RSC_100X050X035_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_15_NSP_SHORT
  rect 0.457x0.381 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_15_SHORT
  rect 0.457x0.381 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_SHORT
  rect 0.508x0.127 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_160X080X055_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_160X080X080_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_160X080X080_2_25_SHORT
  rect 0.508x0.635 smd: (0,0)
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_200X125X060_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
RSC_200X125X115_2_40_SHORT_NSP
  rect 1.067x1.016 smd: (0,0)
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
RSC_200X125X115_2_50_SHORT
  rect 1.067x1.27 smd: (0,0)
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
RSC_200X125X115_2_50_SHORT_NSP
  rect 1.067x1.27 smd: (0,0)
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
RSC_320X160X085_4
  rect 0.254x0.508 smd: (-1.741,0.001) (1.741,0.001)
  custom 0.349x0.349 smd: 1(-1.989,0.508) 2(1.989,0.508)
  rect 0.914x0.254 smd: 3(-1.168,0) 4(1.168,0)
RSC_320X160X089_4_P2
  rect 0.254x0.508 smd: (-1.741,0.001) (1.741,0.001)
  custom 0.349x0.349 smd: 1(-1.989,0.508) 2(1.989,0.508)
  rect 0.914x0.254 smd: 3(-1.168,0) 4(1.168,0)
RSC_320X160X145_2
  rect 1.321x1.6 smd: 1(-1.35,0) 2(1.35,0)
RSC_368X216X050_10_064
  rect 0.559x1.143 smd: 1(-1.356,-0.826) 5(1.356,-0.826) 6(1.356,0.826) 10(-1.356,0.826)
  rect 0.406x1.143 smd: 2(-0.64,-0.826) 3(0,-0.826) 4(0.64,-0.826) 7(0.64,0.826) 8(0,0.826) 9(-0.64,0.826)
