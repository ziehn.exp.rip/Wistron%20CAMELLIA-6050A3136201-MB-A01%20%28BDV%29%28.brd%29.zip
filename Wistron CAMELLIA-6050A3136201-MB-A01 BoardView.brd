# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SAGE12-6026B0328101-004
  oval 1.092x1.194 hole 1.092x1.194 unplated: (-34.4,0)
  oval 1.6x1.702 hole 1.6x1.702 unplated: (34.4,0)
  rect 0.356x2.007 smd: 1(33.375,4.227) 2(33.125,-4.227) 3(32.875,4.227) 4(32.625,-4.227) 5(32.375,4.227) 6(32.125,-4.227) 7(31.875,4.227) 8(31.625,-4.227) 9(31.375,4.227) 10(31.125,-4.227) 11(30.875,4.227) 12(30.625,-4.227) 13(30.375,4.227) 14(30.125,-4.227) 15(29.875,4.227) 16(29.625,-4.227) 17(29.375,4.227) 18(29.125,-4.227) 19(28.875,4.227) 20(28.625,-4.227) 21(28.375,4.227) 22(28.125,-4.227) 23(27.875,4.227) 24(27.625,-4.227) 25(27.375,4.227) 26(27.125,-4.227) 27(26.875,4.227) 28(26.625,-4.227) 29(26.375,4.227) 30(26.125,-4.227) 31(25.875,4.227) 32(25.625,-4.227) 33(25.375,4.227) 34(25.125,-4.227) 35(24.875,4.227) 36(24.625,-4.227) 37(24.375,4.227) 38(24.125,-4.227) 39(23.875,4.227) 40(23.625,-4.227) 41(23.375,4.227) 42(23.125,-4.227) 43(22.875,4.227) 44(22.625,-4.227) 45(22.375,4.227) 46(22.125,-4.227) 47(21.875,4.227) 48(21.625,-4.227) 49(21.375,4.227) 50(21.125,-4.227) 51(20.875,4.227) 52(20.625,-4.227) 53(20.375,4.227) 54(20.125,-4.227) 55(19.875,4.227) 56(19.625,-4.227) 57(19.375,4.227) 58(19.125,-4.227) 59(18.875,4.227) 60(18.625,-4.227) 61(18.375,4.227) 62(18.125,-4.227) 63(17.875,4.227) 64(17.625,-4.227) 65(17.375,4.227) 66(17.125,-4.227) 67(16.875,4.227) 68(16.625,-4.227) 69(16.375,4.227) 70(16.125,-4.227) 71(15.875,4.227) 72(15.625,-4.227) 73(15.375,4.227) 74(15.125,-4.227) 75(14.875,4.227) 76(14.625,-4.227) 77(14.375,4.227) 78(14.125,-4.227) 79(13.875,4.227) 80(13.625,-4.227) 81(13.375,4.227) 82(13.125,-4.227) 83(12.875,4.227) 84(12.625,-4.227) 85(12.375,4.227) 86(12.125,-4.227) 87(11.875,4.227) 88(11.625,-4.227) 89(11.375,4.227) 90(11.125,-4.227) 91(10.875,4.227) 92(10.625,-4.227) 93(10.375,4.227) 94(10.125,-4.227) 95(9.875,4.227) 96(9.625,-4.227) 97(9.375,4.227) 98(9.125,-4.227) 99(8.875,4.227) 100(8.625,-4.227) 101(8.375,4.227) 102(8.125,-4.227) 103(7.875,4.227) 104(7.625,-4.227) 105(7.375,4.227) 106(7.125,-4.227) 107(6.875,4.227) 108(6.625,-4.227) 109(6.375,4.227) 110(6.125,-4.227) 111(5.875,4.227) 112(5.625,-4.227) 113(5.375,4.227) 114(5.125,-4.227) 115(4.875,4.227) 116(4.625,-4.227) 117(4.375,4.227) 118(4.125,-4.227) 119(3.875,4.227) 120(3.625,-4.227) 121(3.375,4.227) 122(3.125,-4.227) 123(2.875,4.227) 124(2.625,-4.227) 125(2.375,4.227) 126(2.125,-4.227) 127(1.875,4.227) 128(1.625,-4.227) 129(1.375,4.227) 130(1.125,-4.227) 131(0.875,4.227) 132(0.625,-4.227) 133(0.375,4.227) 134(0.125,-4.227) 135(-0.125,4.227) 136(-0.375,-4.227) 137(-0.625,4.227) 138(-0.875,-4.227) 139(-1.125,4.227) 140(-1.375,-4.227) 141(-1.625,4.227) 142(-1.875,-4.227) 143(-2.125,4.227) 144(-2.375,-4.227) 145(-4.625,4.227) 146(-4.875,-4.227) 147(-5.125,4.227) 148(-5.375,-4.227) 149(-5.625,4.227) 150(-5.875,-4.227) 151(-6.125,4.227) 152(-6.375,-4.227) 153(-6.625,4.227) 154(-6.875,-4.227) 155(-7.125,4.227) 156(-7.375,-4.227) 157(-7.625,4.227) 158(-7.875,-4.227) 159(-8.125,4.227) 160(-8.375,-4.227) 161(-8.625,4.227) 162(-8.875,-4.227) 163(-9.125,4.227) 164(-9.375,-4.227) 165(-9.625,4.227) 166(-9.875,-4.227) 167(-10.125,4.227) 168(-10.375,-4.227) 169(-10.625,4.227) 170(-10.875,-4.227) 171(-11.125,4.227) 172(-11.375,-4.227) 173(-11.625,4.227) 174(-11.875,-4.227) 175(-12.125,4.227) 176(-12.375,-4.227) 177(-12.625,4.227) 178(-12.875,-4.227) 179(-13.125,4.227) 180(-13.375,-4.227) 181(-13.625,4.227) 182(-13.875,-4.227) 183(-14.125,4.227) 184(-14.375,-4.227) 185(-14.625,4.227) 186(-14.875,-4.227) 187(-15.125,4.227) 188(-15.375,-4.227) 189(-15.625,4.227) 190(-15.875,-4.227) 191(-16.125,4.227) 192(-16.375,-4.227) 193(-16.625,4.227) 194(-16.875,-4.227) 195(-17.125,4.227) 196(-17.375,-4.227) 197(-17.625,4.227) 198(-17.875,-4.227) 199(-18.125,4.227) 200(-18.375,-4.227) 201(-18.625,4.227) 202(-18.875,-4.227) 203(-19.125,4.227) 204(-19.375,-4.227) 205(-19.625,4.227) 206(-19.875,-4.227) 207(-20.125,4.227) 208(-20.375,-4.227) 209(-20.625,4.227) 210(-20.875,-4.227) 211(-21.125,4.227) 212(-21.375,-4.227) 213(-21.625,4.227) 214(-21.875,-4.227) 215(-22.125,4.227) 216(-22.375,-4.227) 217(-22.625,4.227) 218(-22.875,-4.227) 219(-23.125,4.227) 220(-23.375,-4.227) 221(-23.625,4.227) 222(-23.875,-4.227) 223(-24.125,4.227) 224(-24.375,-4.227) 225(-24.625,4.227) 226(-24.875,-4.227) 227(-25.125,4.227) 228(-25.375,-4.227) 229(-25.625,4.227) 230(-25.875,-4.227) 231(-26.125,4.227) 232(-26.375,-4.227) 233(-26.625,4.227) 234(-26.875,-4.227) 235(-27.125,4.227) 236(-27.375,-4.227) 237(-27.625,4.227) 238(-27.875,-4.227) 239(-28.125,4.227) 240(-28.375,-4.227) 241(-28.625,4.227) 242(-28.875,-4.227) 243(-29.125,4.227) 244(-29.375,-4.227) 245(-29.625,4.227) 246(-29.875,-4.227) 247(-30.125,4.227) 248(-30.375,-4.227) 249(-30.625,4.227) 250(-30.875,-4.227) 251(-31.125,4.227) 252(-31.375,-4.227) 253(-31.625,4.227) 254(-31.875,-4.227) 255(-32.125,4.227) 256(-32.375,-4.227) 257(-32.625,4.227) 258(-32.875,-4.227) 259(-33.125,4.227) 260(-33.375,-4.227)
  rect 3.505x4.597 smd: G1(33.8,12) G2(-33.8,12)
SC70_200X125X100_3_065
  rect 0.711x0.889 smd: D(0,0.95) G(-0.65,-0.95) S(0.65,-0.95)
SC70_200X125X110_6_065_NP
  rect 0.432x0.914 smd: 1(-0.65,-1.1) 2(0,-1.1) 3(0.65,-1.1) 4(0.65,1.1) 5(0,1.1) 6(-0.65,1.1)
SC70_200X125X110_6_065_P2
  rect 0.432x0.914 smd: 1(-0.65,-1.1) 2(0,-1.1) 3(0.65,-1.1) 4(0.65,1.1) 5(0,1.1) 6(-0.65,1.1)
SCREW250_500_1P
  round 5.004 hole 2.489: 1(0,0)
SCREW250_600_1P
  custom 1.49x1.49 hole 2.489: 1(0,0)
SCREW250_600_500_1P
  custom 1.449x1.449 hole 2.489: 1(0,0)
SCREW250_700_1P
  custom 1.506x1.506 hole 2.489: 1(0,0)
SCREW260_460_1P
  round 4.597 hole 2.591: 1(0,0)
SCREW300X420_860_1P
  round 8.611 hole 4.191x2.997: 1(0,0)
SCREW330_600_500_1P
  round 5.004 hole 3.302: 1(0,0)
SCREW370_700_1P
  round 7.01 hole 3.708: 1(0,0)
SCREW400_700_1P
  round 7.01 hole 3.988: 1(0,0)
SCREW450_700_1P
  round 7.01 hole 4.496: 1(0,0)
SCREW500_700_NP_1P
  round 5.004 hole 5.004 unplated: (0,0)
  custom 1.753x1.753 hole 0.406: 1(0,3.122)
SILVERBE-6014B0378101-002
  rect 0.356x0.381 smd: 1(-0.25,-0.267) 2(0.25,-0.267) 3(0.25,0.267) 4(-0.25,0.267)
SIM-N_FULHP_7_ST_138
  oval 1.397x0.94 hole 1.397x0.94 unplated: (-6,0)
  round 0.94 hole 0.94 unplated: (6,0)
  rect 0.61x0.762 smd: C1(0,14.875) C2(-0.9,14.875) C3(-2.7,14.875) C5(2.7,14.875) C6(0.9,14.875) C7(-1.8,14.875) S/W(1.8,14.875)
  rect 0.838x1.6 smd: G1(-7.99,12.35) G2(7.99,12.35) G3(-7.99,6.11) G4(7.99,6.11)
  oval 1.092x2.007 hole 0.508x1.397: G5(-7.915,0) G6(7.915,0)
SKT-BIOS_ACES_1015X1000X295
  round 1.041 hole 1.041 unplated: (-2,0)
  round 0.838 hole 0.838 unplated: (2,0)
  rect 1.397x0.838 smd: 1(4.8,-4.405) 2(4.8,-3.135) 3(4.8,-1.865) 4(4.8,-0.595) 5(-4.8,-0.595) 6(-4.8,-1.865) 7(-4.8,-3.135) 8(-4.8,-4.405)
SOT23_290X130X110_3_095_P2
  rect 0.787x0.889 smd: 1(-0.95,-1) 2(0.95,-1) 3(0,1)
SOT23_290X160X115_6_095
  rect 0.61x0.94 smd: 1(-0.95,-1.125) 2(0,-1.125) 3(0.95,-1.125) 4(0.95,1.125) 5(0,1.125) 6(-0.95,1.125)
SOT563_160X120X060_6_050_P3
  rect 0.356x0.508 smd: 1(-0.5,-0.675) 2(0,-0.675) 3(0.5,-0.675) 4(0.5,0.675) 5(0,0.675) 6(-0.5,0.675)
SOT723_120X080X055_3_040_NP
  rect 0.508x0.457 smd: D(0,0.577)
  rect 0.406x0.457 smd: G(-0.401,-0.577) S(0.401,-0.577)
SOT723_120X080X055_3_040_P3
  rect 0.508x0.457 smd: D(0,0.577)
  rect 0.406x0.457 smd: G(-0.401,-0.577) S(0.401,-0.577)
STALLONE-6026B0240301-004
  oval 1.6x1.702 hole 1.6x1.702 unplated: (-10,0)
  oval 1.092x1.194 hole 1.092x1.194 unplated: (10.003,0)
  rect 0.356x1.626 smd: 1(9.251,-5.276) 2(9.002,2.276) 3(8.75,-5.276) 4(8.501,2.276) 5(8.252,-5.276) 6(8.001,2.276) 7(7.752,-5.276) 8(7.501,2.276) 9(7.252,-5.276) 10(7,2.276) 11(6.749,-5.276) 12(6.502,2.276) 13(6.251,-5.276) 14(6.002,2.276) 15(5.751,-5.276) 16(5.502,2.276) 17(5.25,-5.276) 18(5.001,2.276) 19(4.75,-5.276) 20(4.501,2.276) 21(4.252,-5.276) 22(4,2.276) 23(3.752,-5.276) 24(3.5,2.276) 25(3.251,-5.276) 26(3.002,2.276) 27(2.751,-5.276) 28(2.499,2.276) 29(2.25,-5.276) 30(2.002,2.276) 31(1.75,-5.276) 32(1.501,2.276) 33(1.252,-5.276) 34(1.001,2.276) 35(0.752,-5.276) 36(0.5,2.276) 37(0.249,-5.276) 38(0.003,2.276) 39(-0.249,-5.276) 40(-0.5,2.276) 41(-0.749,-5.276) 42(-1.001,2.276) 43(-1.25,-5.276) 44(-1.501,2.276) 45(-1.75,-5.276) 46(-1.999,2.276) 47(-2.25,-5.276) 48(-2.499,2.276) 49(-2.751,-5.276) 50(-3,2.276) 51(-3.251,-5.276) 52(-3.5,2.276) 53(-3.749,-5.276) 54(-4,2.276) 55(-4.249,-5.276) 56(-4.501,2.276) 57(-4.75,-5.276) 58(-4.999,2.276) 67(-7.249,-5.276) 68(-7.501,2.276) 69(-7.75,-5.276) 70(-8.001,2.276) 71(-8.25,-5.276) 72(-8.499,2.276) 73(-8.748,-5.276) 74(-8.999,2.276) 75(-9.251,-5.276)
  rect 1.194x2.743 smd: G1(10.351,-4.501) G2(-10.351,-4.501)
STD_R_FF45021_D30007_M20275_SN
  round 3.505 hole 3.2: 1(0,0)
STQFN_160X160X060_12_040_P2
  rect 0.297x0.508 smd: 1(-0.6,-0.718) 2(-0.2,-0.718) 3(0.2,-0.718) 4(0.6,-0.718) 7(0.6,0.718) 8(0.2,0.718) 9(-0.2,0.718) 10(-0.6,0.718)
  rect 0.457x0.297 smd: 5(0.755,-0.2) 6(0.755,0.2) 11(-0.755,0.2) 12(-0.755,-0.2)
SWCH-DETECT_MISKI_4_SMD_V_380_NSP
  round 1.067 hole 1.067 unplated: (0,0)
  oval 0.864x0.965 hole 0.864x0.965 unplated: (0,2.5)
  rect 0.787x1.194 smd: 1(-2.175,0.3) 2(-2.175,2.7) 3(2.175,0.3) 4(2.175,2.7)
SWCH-TACT_DIP_2_SMD_V_060_NSP
  rect 0.61x1.499 smd: T1(-1.6,0) T2(1.6,0)
TDFN_300X200X080_14_040_T4
  rect 0.297x0.711 smd: 1(-1.2,-1) 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 6(0.8,-1) 8(1.2,1) 10(0.4,1) 11(0,1) 12(-0.4,1) 13(-0.8,1)
  custom 0.174x0.174 smd: 2(-0.8,-1) 7(1.2,-1) 9(0.8,1) 14(-1.2,1)
  rect 2.489x0.787 smd: 15(0,0)
TP24
  round 0.61 smd: 1(0,0)
TP24_NP
  round 0.61 smd: 1(0,0)
TP30
  round 0.762 smd: 1(0,0)
TP30_NP
  round 0.762 smd: 1(0,0)
TQFN_300X300X080_13_040
  rect 0.356x1.676 smd: 1(-0.55,-1) 2(-0.05,-1)
  rect 0.254x1.6 smd: 3(0.75,-1) 4(1.05,1) 5(0.25,1) 6(-0.55,1)
  custom 0.197x0.197 smd: 7(-1.45,1.2) 13(-1.45,-1.2)
  rect 0.787x0.297 smd: 8(-1.45,0.8) 9(-1.45,0.4) 10(-1.45,0) 11(-1.45,-0.4) 12(-1.45,-0.8)
TQFN_400X400X075_32_040_T2
  rect 0.297x0.584 smd: 1(-1.4,-1.95) 2(-1,-1.95) 3(-0.6,-1.95) 4(-0.2,-1.95) 5(0.2,-1.95) 6(0.6,-1.95) 7(1,-1.95) 8(1.4,-1.95) 17(1.4,1.95) 18(1,1.95) 19(0.6,1.95) 20(0.2,1.95) 21(-0.2,1.95) 22(-0.6,1.95) 23(-1,1.95) 24(-1.4,1.95)
  rect 0.584x0.297 smd: 9(1.95,-1.4) 10(1.95,-1) 11(1.95,-0.6) 12(1.95,-0.2) 13(1.95,0.2) 14(1.95,0.6) 15(1.95,1) 16(1.95,1.4) 25(-1.95,1.4) 26(-1.95,1) 27(-1.95,0.6) 28(-1.95,0.2) 29(-1.95,-0.2) 30(-1.95,-0.6) 31(-1.95,-1) 32(-1.95,-1.4)
  rect 2.692x2.692 smd: 33(0,0)
TQFN_400X400X080_24_050_T6
  rect 0.356x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 13(1.25,2) 14(0.75,2) 15(0.25,2) 16(-0.25,2) 17(-0.75,2) 18(-1.25,2)
  rect 0.787x0.356 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.25) 11(2,0.75) 12(2,1.25) 19(-2,1.25) 20(-2,0.75) 21(-2,0.25) 22(-2,-0.25) 23(-2,-0.75) 24(-2,-1.25)
  rect 2.692x2.692 smd: 25(0,0)
TQFN_500X300X080_21_040
  rect 0.305x1.6 smd: 1(-1.475,-1) 2(-0.825,-1) 3(0.275,-1) 4(1.375,-1) 12(0.825,1) 13(-0.275,1) 14(-1.475,1)
  rect 0.914x0.297 smd: 5(2.375,-1.2) 6(2.375,-0.8) 7(2.375,-0.4) 9(2.375,0.4) 10(2.375,0.8) 11(2.375,1.2) 16(-2.375,0.8) 17(-2.375,0.4) 18(-2.375,0) 19(-2.375,-0.4) 20(-2.375,-0.8)
  custom 0.229x0.229 smd: 8(2.375,0)
  custom 0.197x0.197 smd: 15(-2.375,1.2) 21(-2.375,-1.2)
TQFN_600X600X080_48_040_T3
  rect 0.297x0.787 smd: 1(-2.2,-2.95) 2(-1.8,-2.95) 3(-1.4,-2.95) 4(-1,-2.95) 5(-0.6,-2.95) 6(-0.2,-2.95) 7(0.2,-2.95) 8(0.6,-2.95) 9(1,-2.95) 10(1.4,-2.95) 11(1.8,-2.95) 12(2.2,-2.95) 25(2.2,2.95) 26(1.8,2.95) 27(1.4,2.95) 28(1,2.95) 29(0.6,2.95) 30(0.2,2.95) 31(-0.2,2.95) 32(-0.6,2.95) 33(-1,2.95) 34(-1.4,2.95) 35(-1.8,2.95) 36(-2.2,2.95)
  rect 0.787x0.297 smd: 13(2.95,-2.2) 14(2.95,-1.8) 15(2.95,-1.4) 16(2.95,-1) 17(2.95,-0.6) 18(2.95,-0.2) 19(2.95,0.2) 20(2.95,0.6) 21(2.95,1) 22(2.95,1.4) 23(2.95,1.8) 24(2.95,2.2) 37(-2.95,2.2) 38(-2.95,1.8) 39(-2.95,1.4) 40(-2.95,1) 41(-2.95,0.6) 42(-2.95,0.2) 43(-2.95,-0.2) 44(-2.95,-0.6) 45(-2.95,-1) 46(-2.95,-1.4) 47(-2.95,-1.8) 48(-2.95,-2.2)
  rect 4.699x4.699 smd: 49(0,0)
TRYPTICO-6014B0378101-001
  rect 0.356x0.381 smd: 1(-0.25,-0.28) 2(0.25,-0.28) 3(0.25,0.28) 4(-0.25,0.28)
TSOP_290X160X125_6_095
  rect 0.635x0.787 smd: 1(-0.95,-1.201) 2(0,-1.201) 3(0.95,-1.201) 4(0.95,1.201) 5(0,1.201) 6(-0.95,1.201)
TSOT23_290X160X110_6_095
  rect 0.737x0.991 smd: 1(-0.95,-1.2) 2(0,-1.2) 3(0.95,-1.2) 4(0.95,1.2) 5(0,1.2) 6(-0.95,1.2)
TSOT23_290X160X125_5_095
  rect 0.508x1.27 smd: 1(-0.965,-1.27) 2(0,-1.27) 3(0.965,-1.27) 4(1.016,1.27) 5(-0.965,1.27)
TSOT23_290X160X130_5_095
  rect 0.66x1.016 smd: 1(-0.95,-1.3) 2(0,-1.3) 3(0.95,-1.3) 4(0.95,1.29) 5(-0.95,1.29)
TSOT23_290X160X130_6_095
  rect 0.508x1.194 smd: 1(-0.95,-1.5) 2(0,-1.5) 3(0.95,-1.5) 4(0.95,1.5) 5(0,1.5) 6(-0.95,1.5)
TSOT23_292X130X120_3_095
  rect 0.711x0.787 smd: 1(-0.95,-1.025) 2(0,1.025) 3(0.95,-1.025)
TSOT23_295X160X130_5_095
  rect 0.559x0.787 smd: 1(-0.95,-1.2) 2(0,-1.2) 3(0.95,-1.2) 4(0.95,1.2) 5(-0.95,1.2)
TSOT26_290X160X100_6_095
  rect 0.711x0.991 smd: 1(-0.95,-1.1) 2(0,-1.1) 3(0.95,-1.1) 4(0.95,1.1) 5(0,1.1) 6(-0.95,1.1)
TSOT353_205X125X110_5_065
  rect 0.457x0.991 smd: 1(-0.65,-1.001) 2(0,-1.001) 3(0.65,-1.001) 4(0.65,1.001) 5(-0.65,1.001)
TSOT363_200X125X110_6_065_3
  rect 0.508x0.914 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
TSOT886_145X100X050_6_050
  rect 0.305x0.533 smd: 1(-0.5,-0.356)
  rect 0.356x0.559 smd: 2(0,-0.373) 3(0.5,-0.373) 4(0.5,0.373) 5(0,0.373) 6(-0.5,0.373)
TSSC88_200X125X110_6_065
  rect 0.508x0.61 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
TSSC88A_200X125X110_5_065
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
TSSOP_205X125X110_5_065
  rect 0.356x1.143 smd: 1(-0.65,-0.993) 2(0,-0.993) 3(0.65,-0.993) 4(0.65,0.993) 5(-0.65,0.993)
TSSOT23_290X160X135_5_095
  rect 0.66x1.016 smd: 1(-0.95,-1.295) 2(0,-1.295) 3(0.95,-1.295) 4(0.95,1.295) 5(-0.95,1.295)
TSSOT23_292X130X111_3_095
  rect 0.787x0.889 smd: 1(-0.95,-1.001) 2(0.95,-1.001) 3(0,1.001)
TSSOT23_292X130X111_3_096
  rect 0.787x0.889 smd: 1(-0.955,-1.001) 2(0.955,-1.001) 3(0,1.001)
unnamed#2
  rect 2.007x2.007 smd: (0,0) (0,0)
unnamed#3
  round 2.007 hole 2.007 unplated: (0,0)
unnamed#4
  oval 2.007x2.515 hole 2.007x2.515 unplated: (0,-0.254)
unnamed#5
  oval 1.295x1.6 hole 1.295x1.6 unplated: (0,0.152)
USB3_SIGAT_9_DIP_RS_S_210_271
  round 1.295 hole 0.787: 1(3.5,1.98) 2(1,1.98) 3(-1,1.98) 4(-3.5,1.98) 5(-4,0.48) 6(-2,0.48) 7(0,0.48) 8(2,0.48) 9(4,0.48)
  oval 1.295x2.489 hole 0.711x1.905: G1(7.85,0) G2(-7.85,0)
  oval 1.219x2.362 hole 0.711x1.854: G3(-7.85,-7.1) G4(7.85,-7.1)
USB31_SYN_24_SMD_S_158_341
  round 0.67 hole 0.67 unplated: (-3.6,0)
  oval 0.813x0.66 hole 0.813x0.66 unplated: (3.6,0)
  rect 0.356x0.965 smd: A1(-2.625,2.69) A2(-2.125,2.69) A3(-1.625,2.69) A4(-1.125,2.69) A5(-0.625,2.69) A6(-0.125,2.69) A7(0.375,2.69) A8(0.875,2.69) A9(1.375,2.69) A10(1.875,2.69) A11(2.375,2.69) A12(2.875,2.69) B1(2.625,1.19) B2(2.125,1.19) B3(1.625,1.19) B4(1.125,1.19) B5(0.625,1.19) B6(0.125,1.19) B7(-0.375,1.19) B8(-0.875,1.19) B9(-1.375,1.19) B10(-1.875,1.19) B11(-2.375,1.19) B12(-2.875,1.19)
  oval 1.295x2.591 hole 0.61x1.803: G1(-4.32,-3.05) G2(4.32,-3.05)
  oval 1.448x1.092 hole 1.245x0.711: G3(-3.995,1.394) G5(3.995,1.394)
  oval 1.194x2.388 hole 0.61x1.905: G4(-4.32,2) G6(4.32,2)
  oval 1.295x2.591 hole 0.559x1.803: G7(-5.82,-0.5) G8(5.82,-0.5) G9(-6.42,-3.4) G10(6.42,-3.4)
VFBGA_800X800X095_144_065_P2
  round 0.305 smd: A1(3.575,-3.575) A2(2.925,-3.575) A3(2.275,-3.575) A4(1.625,-3.575) A5(0.975,-3.575) A6(0.325,-3.575) A7(-0.325,-3.575) A8(-0.975,-3.575) A9(-1.625,-3.575) A10(-2.275,-3.575) A11(-2.925,-3.575) A12(-3.575,-3.575) B1(3.575,-2.925) B2(2.925,-2.925) B3(2.275,-2.925) B4(1.625,-2.925) B5(0.975,-2.925) B6(0.325,-2.925) B7(-0.325,-2.925) B8(-0.975,-2.925) B9(-1.625,-2.925) B10(-2.275,-2.925) B11(-2.925,-2.925) B12(-3.575,-2.925) C1(3.575,-2.275) C2(2.925,-2.275) C3(2.275,-2.275) C4(1.625,-2.275) C5(0.975,-2.275) C6(0.325,-2.275) C7(-0.325,-2.275) C8(-0.975,-2.275) C9(-1.625,-2.275) C10(-2.275,-2.275) C11(-2.925,-2.275) C12(-3.575,-2.275) D1(3.575,-1.625) D2(2.925,-1.625) D3(2.275,-1.625) D4(1.625,-1.625) D5(0.975,-1.625) D6(0.325,-1.625) D7(-0.325,-1.625) D8(-0.975,-1.625) D9(-1.625,-1.625) D10(-2.275,-1.625) D11(-2.925,-1.625) D12(-3.575,-1.625) E1(3.575,-0.975) E2(2.925,-0.975) E3(2.275,-0.975) E4(1.625,-0.975) E5(0.975,-0.975) E6(0.325,-0.975) E7(-0.325,-0.975) E8(-0.975,-0.975) E9(-1.625,-0.975) E10(-2.275,-0.975) E11(-2.925,-0.975) E12(-3.575,-0.975) F1(3.575,-0.325) F2(2.925,-0.325) F3(2.275,-0.325) F4(1.625,-0.325) F5(0.975,-0.325) F6(0.325,-0.325) F7(-0.325,-0.325) F8(-0.975,-0.325) F9(-1.625,-0.325) F10(-2.275,-0.325) F11(-2.925,-0.325) F12(-3.575,-0.325) G1(3.575,0.325) G2(2.925,0.325) G3(2.275,0.325) G4(1.625,0.325) G5(0.975,0.325) G6(0.325,0.325) G7(-0.325,0.325) G8(-0.975,0.325) G9(-1.625,0.325) G10(-2.275,0.325) G11(-2.925,0.325) G12(-3.575,0.325) H1(3.575,0.975) H2(2.925,0.975) H3(2.275,0.975) H4(1.625,0.975) H5(0.975,0.975) H6(0.325,0.975) H7(-0.325,0.975) H8(-0.975,0.975) H9(-1.625,0.975) H10(-2.275,0.975) H11(-2.925,0.975) H12(-3.575,0.975) J1(3.575,1.625) J2(2.925,1.625) J3(2.275,1.625) J4(1.625,1.625) J5(0.975,1.625) J6(0.325,1.625) J7(-0.325,1.625) J8(-0.975,1.625) J9(-1.625,1.625) J10(-2.275,1.625) J11(-2.925,1.625) J12(-3.575,1.625) K1(3.575,2.275) K2(2.925,2.275) K3(2.275,2.275) K4(1.625,2.275) K5(0.975,2.275) K6(0.325,2.275) K7(-0.325,2.275) K8(-0.975,2.275) K9(-1.625,2.275) K10(-2.275,2.275) K11(-2.925,2.275) K12(-3.575,2.275) L1(3.575,2.925) L2(2.925,2.925) L3(2.275,2.925) L4(1.625,2.925) L5(0.975,2.925) L6(0.325,2.925) L7(-0.325,2.925) L8(-0.975,2.925) L9(-1.625,2.925) L10(-2.275,2.925) L11(-2.925,2.925) L12(-3.575,2.925) M1(3.575,3.575) M2(2.925,3.575) M3(2.275,3.575) M4(1.625,3.575) M5(0.975,3.575) M6(0.325,3.575) M7(-0.325,3.575) M8(-0.975,3.575) M9(-1.625,3.575) M10(-2.275,3.575) M11(-2.925,3.575) M12(-3.575,3.575)
VQFN_500X500X090_32_050_T1
  custom 0.089x0.089 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4) 9(2.4,-1.75) 10(2.4,-1.25) 11(2.4,-0.75) 12(2.4,-0.25) 13(2.4,0.25) 14(2.4,0.75) 15(2.4,1.25) 16(2.4,1.75) 17(1.75,2.4) 18(1.25,2.4) 19(0.75,2.4) 20(0.25,2.4) 21(-0.25,2.4) 22(-0.75,2.4) 23(-1.25,2.4) 24(-1.75,2.4) 25(-2.4,1.75) 26(-2.4,1.25) 27(-2.4,0.75) 28(-2.4,0.25) 29(-2.4,-0.25) 30(-2.4,-0.75) 31(-2.4,-1.25) 32(-2.4,-1.75)
  rect 3.607x3.607 smd: 33(0,0)
WLCSP_220X220X060_16_050
  round 0.356 smd: A1(0.75,-0.75) A2(0.25,-0.75) A3(-0.25,-0.75) A4(-0.75,-0.75) B1(0.75,-0.25) B2(0.25,-0.25) B3(-0.25,-0.25) B4(-0.75,-0.25) C1(0.75,0.25) C2(0.25,0.25) C3(-0.25,0.25) C4(-0.75,0.25) D1(0.75,0.75) D2(0.25,0.75) D3(-0.25,0.75) D4(-0.75,0.75)
WLCSP_254X274X060_11_065
  round 0.297 smd: A1(0.65,-0.975) A2(0,-0.975) A3(-0.65,-0.975) B1(0.65,-0.325) B2(0,-0.325) B3(-0.65,-0.325) C1(0.65,0.325) C3(-0.65,0.325) D1(0.65,0.975) D2(0,0.975) D3(-0.65,0.975)
WSON_500X600X080_8_127_T2
  custom 0.125x0.125 smd: 1(-1.905,-2.625) 2(-0.635,-2.625) 3(0.635,-2.625) 4(1.905,-2.625) 5(1.905,2.625) 6(0.635,2.625) 7(-0.635,2.625) 8(-1.905,2.625)
  rect 4.293x3.404 smd: 9(0,0)
WSON_600X500X080_8_127_T1P2
  custom 0.125x0.125 smd: 1(-1.905,-2.625) 2(-0.635,-2.625) 3(0.635,-2.625) 4(1.905,-2.625) 5(1.905,2.625) 6(0.635,2.625) 7(-0.635,2.625) 8(-1.905,2.625)
  rect 4.293x3.404 smd: 9(0,0)
WSON_600X800X080_8_127_T1
  rect 0.508x0.991 smd: 1(-1.905,-3.8) 2(-0.635,-3.8) 3(0.635,-3.8) 4(1.905,-3.8) 5(1.905,3.8) 6(0.635,3.8) 7(-0.635,3.8) 8(-1.905,3.8)
  rect 4.293x3.404 smd: 9(0,0)
WTB_ACES_4_100_SMD_R_M_295
  rect 0.61x1.549 smd: 1(-1.501,3.873) 2(-0.5,3.873) 3(0.5,3.873) 4(1.501,3.873)
  rect 1.194x1.803 smd: G1(-2.802,0) G2(2.802,0)
WTB_ACES_6_100_SMD_R_M_295_2
  rect 0.61x1.549 smd: 1(-2.499,3.873) 2(-1.501,3.873) 3(-0.5,3.873) 4(0.5,3.873) 5(1.501,3.873) 6(2.499,3.873)
  rect 1.194x1.803 smd: G1(-3.802,0) G2(3.8,0)
WTB_ACES_7_100_SMD_R_M_295_2
  rect 0.61x1.549 smd: 1(-3,4.1) 2(-2,4.1) 3(-1,4.1) 4(0,4.1) 5(1,4.1) 6(2,4.1) 7(3,4.1)
  rect 1.194x1.803 smd: G1(-4.3,0.225) G2(4.3,0.225)
WTB_ACES_9_125_SMD_R_M_215
  rect 0.787x1.905 smd: 1(-5,4.925) 2(-3.75,4.925) 3(-2.5,4.925) 4(-1.25,4.925) 5(0,4.925) 6(1.25,4.925) 7(2.5,4.925) 8(3.75,4.925) 9(5,4.925)
  rect 1.295x3.353 smd: G1(-7.85,0) G2(7.85,0)
WTB_ACES_20_050_SMD_V_F_140
  rect 0.254x1.295 smd: 1(-4.75,-1.951) 2(-4.249,-1.951) 3(-3.752,-1.951) 4(-3.251,-1.951) 5(-2.751,-1.951) 6(-2.25,-1.951) 7(-1.75,-1.951) 8(-1.25,-1.951) 9(-0.749,-1.951) 10(-0.249,-1.951) 11(0.249,-1.951) 12(0.752,-1.951) 13(1.25,-1.951) 14(1.75,-1.951) 15(2.25,-1.951) 16(2.751,-1.951) 17(3.251,-1.951) 18(3.752,-1.951) 19(4.252,-1.951) 20(4.75,-1.951)
  rect 2.311x1.295 smd: G1(-3.899,1.951) G3(3.899,1.951)
  rect 1.194x2.692 smd: G2(-7.15,-0.003) G4(7.15,-0.003)
WTB_ENTRY_2_100_SMD_R_M_295
  rect 0.61x1.549 smd: 1(-0.5,3.775) 2(0.5,3.775)
  rect 1.194x2.007 smd: G1(-1.8,0) G2(1.8,0)
WTB_IPEX_30_050_SMD_R_F_100_1
  rect 0.356x0.965 smd: 1(-7.25,2.82) 2(-6.75,2.82) 3(-6.25,2.82) 4(-5.75,2.82) 5(-5.25,2.82) 6(-4.75,2.82) 7(-4.25,2.82) 8(-3.75,2.82) 9(-3.25,2.82) 10(-2.75,2.82) 11(-2.25,2.82) 12(-1.75,2.82) 13(-1.25,2.82) 14(-0.75,2.82) 15(-0.25,2.82) 16(0.25,2.82) 17(0.75,2.82) 18(1.25,2.82) 19(1.75,2.82) 20(2.25,2.82) 21(2.75,2.82) 22(3.25,2.82) 23(3.75,2.82) 24(4.25,2.82) 25(4.75,2.82) 26(5.25,2.82) 27(5.75,2.82) 28(6.25,2.82) 29(6.75,2.82) 30(7.25,2.82)
  rect 0.559x0.889 smd: G1(-8.15,2.82) G2(8.15,2.82)
  rect 1.397x1.905 smd: G3(-10.35,0) G4(10.35,0)
XTAL_320X250X080_4_220
  rect 1.397x1.194 smd: 1(-1.1,-0.851) 2(1.1,-0.851) 3(1.1,0.851) 4(-1.1,0.851)
XTAL_670X140X140_4_630
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)

## Nets
1V05A_PG: R7420.1(A) U60900.7(PG)
1V8_PG: U60600.7(PG)
2V5_PG: U60400.5
3V3DS_PG: R7000.2(B) U60100.3
3V3DS_PG_R: C7001.1(A) R7000.1(A) R7017.2(B) U7000.2
3V_LP#: TP60102.1 U60100.12
5V0_PG: U60200.4(PG)
5V_PG: R7429.1(A) U60250.9
AGND_AUDIO: C500.1(A) C501.1(A) C502.2(B) C503.2(B) C506.1(A) C507.1(A) C508.2(B) C515.2(B) C516.1(A) C517.1(A) C524.2(B) C525.2(B) C526.1(A) CN2500.23 CN2500.28 R506.1(A) R507.2(B) R509.2(B) R510.2(B) U500.22(AVSS2) U500.30(RING2) U500.37(AVSS1)
AGND_KBC: C301.2(B) C304.2(B) C309.2(B) C313.1(A) C318.1(A) C320.2(B) PAD310.2 U300.E1(AVSS)
AGND_USB: C9226.2(B) C9227.2(B) C9228.2(B) CN9202.3 CN9202.8 JACK9200.3 JACK9200.5
