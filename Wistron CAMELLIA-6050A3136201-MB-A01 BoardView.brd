# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND_ALS on L5: 75.29,91.07 75.29,111.99 81.06,111.99 81.06,91.07
GND_ALS on L6: 75.09,91.07 75.09,112.04 81.16,112.04 81.16,91.07
GND_ALS on L7: 75.19,90.97 75.19,112.54 81.16,112.54 81.16,90.97
P0V6S on TOP (solid shape): 162.33,11.11 162.33,7.69 161.19,7.69 160.96,7.91 160.96,9.18 160.42,9.72 160.42,11.24 162.2,11.24
P0V6S on TOP: 242.21,14.29 240.18,14.29 239.04,13.15 237.39,13.15 237.26,13.02 237.26,9.84 238.66,9.84 242.34,13.53 242.34,14.16
P0V6S on TOP: 225.83,10.1 220.37,10.1 215.41,5.15 205.76,5.15 200.94,9.97 189,9.97 189,8.45 194.21,3.24 215.16,3.24 220.24,8.32 225.57,8.32 225.96,8.7 225.96,9.97
P0V6S on TOP: 163.73,8.45 160.93,8.45 160.93,6.03 164.61,2.35 171.6,2.35 177.7,8.45 179.35,8.45 179.35,9.97 176.81,9.97 171.85,5.02 167.15,5.02
P0V9_PCIE on TOP: 258.13,62.06 258.13,60.66 258.23,60.56 259.04,60.56 259.69,61.2 259.69,61.44 258.93,62.2 258.27,62.2
P0V9_PCIE on BOTTOM: 259.71,60.88 259.26,61.34 258.16,61.34 257.96,61.13 257.96,59.76 257.96,59.76 257.83,59.63 256.69,59.63 256.56,59.5 256.56,58.74 256.69,58.61 257.83,58.61 257.96,58.49 257.96,57.34 258.09,57.22 259.59,57.22 259.71,57.34
P1V2 on TOP: 139.6,37.12 139.6,55.38 142.44,58.23 162.66,58.23 164.08,56.81 164.08,54.88 164.87,54.09 164.87,52.51 167.28,50.1 167.28,25.21 167.66,24.83 218.33,24.83 220.11,23.05 233.96,23.05 233.96,12.25 178.08,12.25 172.75,6.92 168.17,6.92 168.04,7.05 168.04,12.25 155.47,12.25 154.07,10.86 151.79,10.86 150.77,11.87 96.92,11.87 96.92,21.53 97.05,21.66 111.66,21.66 114.07,24.07 126.54,24.07 ; 1 cut-out
P1V2 on BOTTOM: 174.65,6.54 174.77,6.67 174.77,8.57 174.65,8.7 169.31,8.7 169.19,8.57 169.19,7.43 170.08,6.54
P1V05A on TOP: 168.55,63.94 169.57,63.94 169.69,64.07 169.69,68.13 170.08,68.52 172.23,68.52 172.49,68.77 172.49,69.66 174.14,71.31 174.14,78.04 177.57,81.47 177.57,85.28 177.44,85.41 175.28,85.41 175.16,85.54 175.16,87.95 175.03,88.08 166.27,88.08 166.14,87.95 166.14,86.04 169.82,82.36 169.82,70.42 168.3,68.9 168.3,66.61 167.66,65.98 167.66,64.83
P1V05A on BOTTOM: 171.65,65.01 171.17,65.49 171.17,67.73 171.37,67.93 171.88,67.93 172.01,67.81 172.01,67.17 171.62,66.79 171.62,65.88 172.03,65.47 172.03,65.09 171.95,65.01
P1V05A on BOTTOM: 167.64,63.99 168.5,63.99 169.97,65.47 169.97,67.09 169.67,67.4 168.78,67.4 168.63,67.25 168.63,66.03 168.35,65.75 167.56,65.75 167.43,65.62 167.43,64.2
P1V05A on BOTTOM: 168.81,88.58 168.81,86.55 168.42,86.17 163.09,86.17 163.09,89.6 162.07,90.62 161.06,90.62 160.93,90.74 160.93,93.79 161.06,93.92 164.23,93.92 164.36,93.79 164.36,90.49 165.5,89.35 166.39,89.35 167.03,88.71 168.68,88.71
P1V05A on BOTTOM: 172.11,68.64 169.57,68.64 169.31,68.39 169.31,67.93 169.14,67.75 168.75,67.75 167.54,68.97 167.54,69.91 167.89,70.27 171.9,70.27 171.98,70.19 171.98,69.89 172.51,69.35 172.51,69.05
P1V05A on L4: 168.68,70.29 169.57,71.17 169.57,80.46 165.88,84.14 165.88,87.95 174.9,87.95 174.9,70.42 172.36,70.42 172.36,68.77 169.69,68.77 169.69,63.57 167.28,63.57 167.28,67.25 168.68,68.65
P1V5S on BOTTOM: 232.05,86.3 231.42,85.66 231.42,85.41 231.54,85.28 233.32,85.28 234.08,86.04 235.23,86.04 235.99,86.81 242.21,86.81 242.85,86.17 243.99,86.17 244.12,86.3 244.12,94.93 243.86,95.19 233.7,95.19 233.58,95.06 233.58,90.49 232.94,89.85 232.94,88.97 232.05,88.08
P1V8A on BOTTOM: 118.13,91.51 118.39,91.51 119.4,90.49 119.4,89.22 118.13,87.95 116.61,87.95 115.34,89.22 115.34,89.35 117.39,91.4 117.93,90.86 118.11,91.05 117.89,91.26
P1V8A on BOTTOM: 173.76,65.52 174.55,65.52 175.08,66.05 175.08,68.42 174.82,68.67 173.76,68.67 173.66,68.57 173.66,68.44 173.89,68.21 173.89,67.32 173.58,67.02 173.58,65.7
P1V8A on BOTTOM: 205,77.54 205,73.34 205.13,73.22 206.27,73.22 206.4,73.34 206.4,77.54 206.27,77.66 205.13,77.66
P1V8A on L5: 201.83,63.95 201.83,64.84 166.98,64.84 165.07,66.74 132.61,66.74 126.64,72.71 126.64,73.6 124.74,75.5 123.09,75.5 117.62,80.96 117.62,90.62 117.75,90.74 119.28,90.74 119.4,90.62 119.4,88.33 130.96,76.77 131.72,76.77 132.74,75.76 132.74,72.96 135.3,70.4 173.28,70.4 175.03,68.65 181.12,68.65 182.39,67.38 195.09,67.38 198.52,70.8 203.48,70.8 205,72.33 205,74.23 205.13,74.36 206.4,74.36 206.52,74.23 206.52,63.95
P1V8A_EMMC on TOP: 204.49,76.9 204.49,77.41 204.37,77.54 203.48,77.54 203.35,77.41 203.35,76.77 202.84,76.27 202.84,75.5 202.97,75.38 205.51,75.38 205.64,75.5 205.64,76.9
P1V8A_EMMC on BOTTOM: 204.64,76.13 202.99,76.13 202.71,75.85 202.71,74.49 203.23,73.97 204.64,73.97 204.77,74.09 204.77,76
P2V5 on TOP: 215.16,5.27 220.24,10.35 236.75,10.35 237,10.61 237,16.32 237.26,16.58 237.26,18.86 237.13,18.99 234.21,18.99 234.21,12.13 217.07,12.13 213.13,8.19 206.14,8.19 206.14,5.27
P2V5 on BOTTOM: 160.87,21.96 162.13,21.96 162.14,21.94 166.23,21.94 167.29,20.89 167.29,14.92 168.3,13.91 168.3,11.88 168.17,11.75 167.28,11.75 165.76,13.27 165.76,18.3 164.28,19.78 160.9,19.78 160.87,19.82
P2V5 on BOTTOM: 206.02,8.07 206.02,4.51 206.14,4.38 206.78,4.38 207.79,5.4 207.79,8.07 207.67,8.19 206.14,8.19
P2V8S_FRONT_DMIC on L4: 59,42.38 58.63,42.53 58.48,42.9 58.48,71.11 57.55,71.11 57.55,71.13 58.48,71.13 58.48,117.9 58.63,118.27 59,118.42 61.64,118.42 62.01,118.27 62.16,117.9 62.16,113.2 61.79,112.83 61.66,112.33 61.66,96.65 61.83,95.97 62.46,95.25 62.52,95.01 62.52,79.29 63.27,79.29 63.27,79.26 62.52,79.26 62.52,65.79 62.46,65.55 61.83,64.84 61.66,64.15 61.66,56.17 61.79,55.68 62.16,55.3 62.16,42.9 62.01,42.53 61.64,42.38
P3V3_SVR on TOP: 260.07,68.37 260.58,68.37 260.8,68.59 260.8,69.18 262.56,70.93 263.09,70.93 265.71,73.55 265.71,79.69 265.58,79.82 264.18,79.82 264.06,79.69 264.06,76.21 263.88,76.04 263.88,73.6 260.37,70.09 260.37,68.85 260.27,68.75 260.07,68.75 260.02,68.7 260.02,68.42
P3V3A on BOTTOM: 207.41,79.32 207.56,79.17 208.8,79.17 208.94,79.31 208.94,83.38 208.81,83.5 207.54,83.5 207.41,83.38
P3V3A on L4: 209.45,80.46 214.91,75 214.91,71.95 202.46,71.95 202.46,67.12 195.6,67.12 193.44,64.96 193.44,64.33 189.13,64.33 189.13,71.19 189.51,71.57 193.19,71.57 198.27,76.65 202.21,76.65 202.71,77.15 202.71,80.46
P3V3A on L5: 213.13,72.33 213.13,74.23 214.27,74.23 214.27,72.33
P3V3A_EMMC on TOP: 206.29,78.29 206.29,78.85 205.12,80.02 204.44,80.02 204.38,80.07 204.38,80.32 205.07,81.01 205.17,81.01 207.03,79.15 207.13,79.15 207.31,78.97 207.31,78.67 206.8,78.16 206.42,78.16
P3V3A_EMMC on BOTTOM: 207.18,81.84 207.18,78.67 206.92,78.41 204.38,78.41 204.26,78.54 204.26,81.84 204.38,81.97 207.05,81.97
P3V3A_PRIME on TOP: 174.9,64.96 173.76,64.96 173.12,64.32 173.12,62.8 173.25,62.67 174.9,62.67 175.03,62.8 175.03,64.83
P3V3A_PRIME on BOTTOM: 216.43,93.66 216.43,89.73 216.3,89.6 215.54,89.6 215.41,89.73 215.41,93.66 215.54,93.79 216.3,93.79
P3V3A_PRIME on BOTTOM: 173.12,62.83 174.72,62.83 175.03,63.13 175.03,64.68 174.82,64.88 173.48,64.88 172.95,64.35 172.95,63
P3V3A_PRIME on L4: 167.28,63.31 173.12,63.31 173.12,64.33 173.89,65.09 185.19,65.09 185.19,80.46 202.46,80.46 202.46,78.17 197.51,78.17 193.44,74.11 189,74.11 186.59,71.69 186.59,63.06 183.28,63.06 183.28,61.03 170.96,61.03 170.46,61.53 167.28,61.53
P3V3A_Q_WLAN on BOTTOM: 47.8,26.43 49.83,26.43 49.96,26.3 49.96,24.22 49.3,23.56 48.03,23.56 47.9,23.69 47.9,24.8 47.8,24.91
P3V3A_Q_WLAN on BOTTOM: 61.11,14.92 61.11,18.86 62.13,18.86 62.38,18.61 62.38,17.85 62.51,17.72 64.41,17.72 64.89,18.2 64.89,33.62 64.28,34.23 61.67,34.23 61.31,34.58 60.45,34.58 60.45,35.9 66.42,35.9 66.82,35.5 66.82,16.83 65.43,16.83 64.67,16.07 64.67,15.31 64.28,14.92
P3V3DS on TOP: 217.45,60.9 217.45,59.76 217.57,59.63 219.99,59.63 219.99,62.42 219.86,62.55 215.92,62.55 215.8,62.42 215.8,61.15 215.92,61.03 217.32,61.03
P3V3DS on TOP: 53.36,33.97 51.2,33.97 51.08,33.85 51.08,26.74 52.6,25.21 56.16,25.21 56.28,25.34 56.28,31.05
P3V3DS on TOP: 267.61,78.42 266.09,78.42 265.96,78.3 265.96,77.41 266.09,77.28 267.61,77.28 267.74,77.41 267.74,78.3
P3V3DS on BOTTOM: 212.37,84.27 212.37,88.08 213,88.71 213,89.22 213.13,89.35 216.3,89.35 216.43,89.22 216.43,86.17 216.3,86.04 216.3,84.27 216.18,84.14 212.49,84.14
P3V3DS on BOTTOM: 221.76,89.85 222.27,90.36 222.27,91.38 222.15,91.51 220.24,91.51 220.11,91.38 220.11,89.98 220.62,89.47 221.64,89.47 221.76,89.6
P3V3DS on BOTTOM: 258.72,55.18 258.72,52.39 258.85,52.26 259.99,52.26 260.12,52.39 260.12,55.18 259.99,55.31 258.85,55.31
P3V3DS on BOTTOM: 227.73,61.79 227.86,61.91 227.86,63.79 227.83,63.82 223.92,63.82 223.67,63.57 223.67,62.04 223.92,61.79
P3V3DS on BOTTOM: 51.2,33.19 51.2,36.01 54.38,36.01 54.38,34.61 54.25,34.48 54.25,33.19
P3V3DS on L4: 53.24,24.2 53.24,29.28 78.51,29.28 78.51,30.93 86,30.93 108.23,53.15 108.23,105.86 125.24,105.86 131.21,99.89 144.93,99.89 150.9,105.86 193.7,105.86 193.7,96.71 205.76,84.65 214.14,84.65 214.14,91.51 227.1,91.51 227.1,62.3 225.96,61.15 225.96,57.6 252.12,57.6 252.12,32.7 251.61,32.2 244.62,32.2 241.7,29.28 241.7,25.85 237.26,25.85 216.3,46.8 216.3,62.8 221.38,62.8 221.38,71.95 215.16,71.95 215.16,75.12 209.57,80.71 185.19,80.71 185.19,87.31 175.16,87.31 175.16,88.2 165.88,88.2 165.88,93.16 155.98,93.16 155.98,95.82 125.24,95.82 125.24,78.68 114.2,78.68 114.2,63.69 120.16,63.69 120.16,25.47 93.88,25.47 92.61,24.2
P3V3DS on L5: 258.72,54.93 258.72,52.39 258.85,52.26 259.86,52.26 259.99,52.39 259.99,54.93 259.86,55.06 258.85,55.06
P3V3DS_WLAN on BOTTOM: 55.27,36.01 59.33,36.01 59.46,35.88 59.46,34.48 59.33,34.36 58.82,34.36 57.81,33.34 57.81,32.2 57.68,32.07 56.79,32.07 56.54,31.82 56.54,31.43 56.28,31.18 54.51,31.18 54.51,34.36 54.89,34.36 55.14,34.61 55.14,35.88
P3V3DS_WWAN on TOP (solid shape): 217.19,59.73 217.13,59.73 215.9,58.5 215.9,57.41 215.83,57.34 207.74,57.34 207.51,57.42 207.29,57.34 198.9,57.34 198.9,58.42 200.14,58.42 200.26,58.3 212.18,58.3 212.19,58.3 213.93,58.3 214.85,59.23 214.86,59.23 215.96,60.32 215.96,60.33 215.99,60.36 217.19,60.36
P3V3DS_WWAN on BOTTOM: 199.67,60.77 198.78,60.77 198.65,60.64 198.65,57.22 198.78,57.09 200.43,57.09 200.56,57.22 200.56,58.1 199.79,58.87 199.79,60.64
P3V3DS_WWAN on BOTTOM: 219.1,62.04 217.07,62.04 215.8,60.77 215.8,59.25 214.4,57.85 214.4,57.22 214.53,57.09 216.68,57.09 216.81,57.22 216.81,57.98 217.32,58.49 217.32,60.14 217.57,60.39 219.1,60.39 219.22,60.52 219.22,61.91
P3V3S on TOP: 21.95,12.93 21.23,12.93 21.23,11.24 21.79,10.68 23.64,10.68 23.97,10.35 24.41,10.35 24.53,10.48 24.53,10.99 23.9,11.62 23.25,11.62
P3V3S on TOP: 107.08,5.02 107.08,3.49 106.96,3.37 105.31,3.37 105.18,3.49 105.18,5.02 105.31,5.15 106.96,5.15
P3V3S on TOP: 219.86,109.03 217.45,109.03 217.32,108.9 217.32,107.89 217.45,107.76 219.86,107.76 219.99,107.89 219.99,108.9
P3V3S on TOP: 44.6,38.04 44.09,38.04 43.96,37.91 43.96,36.13 44.85,35.24 46.89,35.24 47.01,35.37 47.01,37.02 46.89,37.15 46.38,37.15 46,37.53 45.11,37.53
P3V3S on TOP: 266.21,18.35 264.82,18.35 264.69,18.23 264.69,16.07 264.82,15.94 266.21,15.94 266.34,16.07 266.34,18.23
P3V3S on TOP: 265.96,79.69 265.96,78.68 266.09,78.55 267.61,78.55 267.74,78.68 267.74,79.69 267.61,79.82 266.09,79.82
P3V3S on TOP: 233.96,5.02 237.13,5.02 237.26,4.89 237.26,3.37 237.13,3.24 233.96,3.24
P3V3S on BOTTOM: 54.12,11.62 54.12,10.1 54,9.97 52.6,9.97 52.47,10.1 52.47,11.62 52.6,11.75 54,11.75
P3V3S on BOTTOM: 42.95,36.01 41.55,36.01 41.42,35.88 41.42,34.74 41.55,34.61 44.73,34.61 44.85,34.74 44.85,37.91 44.73,38.04 43.84,38.04 43.58,37.78 43.58,36.64
P3V3S on BOTTOM: 207.54,87.7 207.54,85.03 207.41,84.9 205.38,84.9 205.25,85.03 205.25,87.41 205.66,87.82 207.41,87.82
P3V3S on L4: 24.15,-4.38 -2.9,22.67 -2.9,47.18 0.66,50.74 34.82,50.74 45.49,40.07 65.55,40.07 88.67,63.18 88.67,68.9 88.03,69.53 88.03,119.06 93.24,124.27 272.44,124.27 272.44,117.29 275.36,114.37 275.36,102.94 278.41,102.94 278.41,92.14 275.36,92.14 275.36,86.17 277.26,84.27 280.06,84.27 280.06,81.73 280.06,81.72 280.06,76.74 279.44,76.13 279.44,66.2 278.56,65.31 278.56,64.19 279.31,63.44 279.31,62.61 278.26,61.56 278.26,42.21 274.19,38.14 274.19,21.86 281.91,14.14 281.91,-0.34 277.87,-4.38 ; 2 cut-outs
P3V3S_2ALS_H on L4: 72.23,82.34 72.23,77.36 82.37,77.36 82.37,82.34
P3V3S_AUDIO on TOP: 41.42,37.02 41.3,36.9 41.3,35.37 41.42,35.24 43.08,35.24 43.2,35.37 43.2,36.9 43.08,37.02
P3V3S_CAMERA_ALS on TOP: 223.67,106.62 223.67,105.22 223.54,105.09 218.72,105.09 218.08,105.73 217.45,105.73 217.32,105.86 217.32,106.75 217.45,106.87 220.37,106.87 220.88,106.36 221.13,106.36 221.51,106.75 223.54,106.75
P3V3S_CLKPAD on TOP: 109.75,5.02 108.23,5.02 108.1,4.89 108.1,3.49 108.35,3.24 110.26,3.24 110.39,3.37 110.39,3.75 109.88,4.26 109.88,4.89
P3V3S_LCDVDD on TOP: 22.63,27.24 22.63,25.47 22.76,25.34 25.17,25.34 25.3,25.47 25.3,26.61 24.53,27.37 22.76,27.37
P3V3S_LCDVDD on BOTTOM: 54.35,9.72 53.36,9.72 53.24,9.59 53.24,7.81 52.98,7.56 52.98,6.67 53.11,6.54 53.74,6.54 53.87,6.67 53.87,7.18 54.12,7.43 55.52,7.43 55.65,7.56 55.65,8.83 55.5,8.98 54.84,8.98 54.53,9.29 54.53,9.54
P3V3S_LCDVDD on L6: 55.65,6.92 55.52,6.8 20.22,6.8 20.22,12.26 20.72,12.77 20.72,16.07 20.22,16.58 20.22,23.81 23.14,26.74 26.31,26.74 26.69,26.35 26.69,11.47 29.08,9.08 30.63,9.08 31.52,9.97 48.16,9.97 49.04,9.08 52.98,9.08 53.62,9.72 55.52,9.72 55.65,9.59
P3V3S_SSD on TOP: 247.95,20.28 248.74,20.28 248.99,20.54 248.99,21.99 248.74,22.24 247.95,22.24 247.7,21.99 247.7,20.54
P3V3S_SSD on TOP: 267.99,18.73 267.99,20.13 267.87,20.26 264.94,20.26 264.82,20.13 264.82,18.73 264.94,18.61 267.87,18.61
P3V3S_SSD on BOTTOM: 248.21,18.73 248.21,23.38 268.17,23.38 268.17,18.73 265.23,18.73 265.23,20.56 265.15,20.64 252.65,20.64 252.58,20.56 252.58,18.73 250.72,18.73 250.72,20.36 250.47,20.61 249.3,20.61 249.05,20.36 249.05,18.84 249.15,18.73
P3V3S_TOUCH_F on TOP: 19.2,13.15 21.1,13.15 21.23,13.27 21.23,13.91 20.72,14.42 20.72,16.32 20.34,16.7 20.34,17.08 20.98,17.72 20.98,18.61 20.85,18.73 19.2,18.73
P3V3S_TOUCH_VCC on TOP: 20.75,23.87 21.15,23.87 21.33,23.69 21.33,22.24 20.75,21.66 20.6,21.66 20.47,21.53 20.47,21.27 20.98,20.77 20.98,19.75 20.85,19.62 19.33,19.62 19.2,19.75 19.2,23.03 19.43,23.26 20.47,23.26 20.62,23.41 20.62,23.74
P5V0A_USB on TOP: 76.6,31.18 76.6,28.26 77.37,27.5 77.37,19.5 77.49,19.37 80.03,19.37 80.16,19.5 80.16,31.18 80.03,31.31 76.73,31.31
P5V0A_USB on TOP: 265.81,89.63 267.48,89.63 267.48,88.84 267.61,88.71 272.06,88.71 272.06,88.15 271.17,87.26 265.83,87.26 265.66,87.44 265.66,89.47
P5V0A_USB on TOP: 29.23,27.5 28.34,28.39 28.34,29.28 28.22,29.4 25.04,29.4 24.91,29.28 24.91,28.51 25.04,28.39 26.06,28.39 26.31,28.13 26.31,24.2 26.69,23.81 26.69,19.12 29.49,19.12 30.88,20.51 30.88,25.21 29.74,26.35 29.74,27.24 29.49,27.5
P5V0A_USB on TOP: 259.13,42 259.25,41.87 260.45,41.87 260.8,42.23 260.8,48.63 261.26,49.09 264.31,49.09 266.21,47.18 267.87,47.18 267.99,47.31 267.99,49.98 266.21,51.75 261.29,51.75 259.13,49.6
P5V0A_USB on BOTTOM: 229.64,60.01 231.42,60.01 231.54,60.14 231.54,64.71 231.29,64.96 229.13,64.96 228.88,64.71 228.88,60.77
P5V0A_USB on BOTTOM: 76.6,31.18 76.6,28.39 76.73,28.26 77.87,28.26 78.38,27.75 79.02,27.75 79.14,27.88 79.14,31.18 79.02,31.31 76.73,31.31
P5V0A_USB on L3: 26.31,32.45 26.31,19.24 26.44,19.12 28.34,19.12 28.47,19.24 28.47,32.45 28.34,32.58 26.44,32.58
P5V0A_USB on L4: 111.4,6.16 107.34,10.23 85.62,10.23 83.97,11.88 52.47,11.88 52.47,17.85 20.47,17.85 20.47,23.56 20.85,23.56 21.1,23.81 21.1,25.59 20.98,25.72 20.47,25.72 20.47,29.28 52.98,29.28 52.98,23.94 92.73,23.94 94,25.21 120.16,25.21 120.16,12.13 238.02,12.13 240.05,14.16 240.05,20 247.23,27.18 253.07,27.18 255.42,29.53 255.42,60.52 231.8,60.52 231.16,59.88 229,59.88 229,70.3 240.94,82.23 243.86,82.23 245.64,84.01 251.86,84.01 254.15,86.3 257.2,86.3 260.5,89.6 267.36,89.6 267.36,84.52 266.6,83.76 266.6,78.93 267.36,78.17 267.36,39.56 261.64,33.85 261.64,16.19 254.66,9.21 242.21,9.21 239.16,6.16
P5V0A_USB on L6: 27.07,23.05 26.95,22.93 26.95,19.24 27.07,19.12 29.61,19.12 29.74,19.24 29.74,22.93 29.61,23.05
P5V0A_USB1 on BOTTOM: 78.38,35.37 78.38,31.69 78.25,31.56 76.73,31.56 76.6,31.69 76.6,33.09 75.97,33.72 75.97,34.48 76.6,35.12 76.6,35.37 76.73,35.5 78.25,35.5
P5V0A_USB1 on BOTTOM: 15.26,29.91 16.41,29.91 16.41,33.47 16.28,33.59 15.26,33.59 15.14,33.47 15.14,33.09 15.26,32.96
P5V0A_USB1 on L4: 78.25,35.5 74.19,35.5 71.65,32.96 43.84,32.96 39.77,37.02 15.14,37.02 15.14,32.32 20.47,32.32 20.47,29.53 26.06,29.53 31.39,24.2 52.98,24.2 52.98,29.53 78.25,29.53
P5V0A_USB_CHARGE on TOP: 17.17,32.2 19.33,32.2 20.85,30.67 20.85,30.04 21.49,29.4 22.63,29.4 22.88,29.15 22.88,28.77 22.63,28.51 16.91,28.51 16.91,29.78 13.36,29.78 13.36,33.59 13.48,33.72 15.64,33.72
P5V0A_USB_CHARGE on BOTTOM: 15.01,29.91 13.1,29.91 13.1,33.34 13.23,33.47 14.88,33.47 15.01,33.34
P5V0A_USB_CHARGE on L3, L5, L6: 15.01,33.47 15.01,31.43 14.88,31.31 13.61,31.31 13.48,31.43 13.48,33.47 13.61,33.59 14.88,33.59
P5V0A_USB_CHARGE_DB on TOP: 36.34,111.95 36.34,108.9 36.09,108.65 32.28,108.65 32.03,108.4 32.03,106.75 32.41,106.36 32.92,106.36 34.19,107.63 36.98,107.63 37.11,107.76 37.11,109.92 37.23,110.05 38.5,110.05 38.63,110.17 38.63,111.85 38.35,112.13 36.52,112.13
P5V0A_USB_CHARGE_DB on BOTTOM: 43.2,87.95 43.08,87.82 43.08,84.52 43.2,84.39 44.85,84.39 44.98,84.52 44.98,86.17 45.11,86.3 46,86.3 46.12,86.43 46.12,87.44 45.23,87.44 45.23,87.95
P5V0A_USB_CHARGE_DB on BOTTOM: 38.27,112.21 36.22,112.21 36.09,112.08 36.09,111.57 35.46,110.94 35.46,110.05 34.44,109.03 34.44,108.9 33.55,108.02 31.65,108.02 31.52,107.89 31.52,106.49 31.65,106.36 37.74,106.36 37.87,106.49 39.01,106.49 39.27,106.24 39.27,103.95 39.39,103.82 42.57,103.82 42.69,103.95 42.69,105.86 42.57,105.98 40.79,105.98 40.54,106.24 40.54,107.63 39.52,108.65 39.27,108.65 38.63,109.29 38.63,111.85
P5V0A_USB_CHARGE_DB on L3: 38.27,112.13 36.78,112.13 35.33,110.68 35.33,108.4 35.2,108.27 31.77,108.27 31.65,108.14 31.65,106.75 32.03,106.36 36.98,106.36 38.63,108.02 38.63,111.77
P5V0A_USB_CHARGE_DB on L3: 44.85,87.82 43.58,87.82 43.46,87.7 43.46,86.17 43.58,86.04 45.87,86.04 46,86.17 46,87.19 45.87,87.31 45.36,87.31
P5V0A_USB_CHARGE_DB on L4, L5: 51.46,86.17 51.46,126.43 32.08,126.43 32.08,114.75 31.26,113.93 31.44,113.76 31.44,106.72 33.3,104.87 33.3,98.36 32.69,97.75 32.69,88.33 35.84,88.33 38,86.17
P5V0A_USB_CHARGE_DB on L6: 38.25,112.13 36.65,112.13 35.48,110.96 35.48,108.55 35.2,108.27 31.77,108.27 31.65,108.14 31.65,106.75 32.03,106.36 36.98,106.36 38.63,108.02 38.63,111.75
P5V0A_USB_CHARGE_DB on L6: 44.85,87.82 43.58,87.82 43.46,87.7 43.46,86.17 43.58,86.04 45.87,86.04 46,86.17 46,87.06 45.87,87.19 45.36,87.19 45.36,87.31
P5V0A_USB_DB on TOP: 33.42,88.58 34.95,88.58 35.07,88.46 35.07,87.7 34.95,87.57 33.68,87.57 32.53,86.43 31.9,86.43 31.39,86.93 31.39,88.2 31.52,88.33 33.17,88.33
P5V0A_USB_DB on BOTTOM: 45.36,86.17 45.23,86.04 45.23,84.52 45.62,84.14 48.66,84.14 48.79,84.27 48.79,86.04 48.66,86.17
P5V0A_USB_DB on L4: 29.49,88.08 29.49,81.22 49.93,81.22 49.93,85.92 37.87,85.92 35.71,88.08
P5V0A_USB_DB on L5: 48.28,85.79 45.87,85.79 45.74,85.66 45.74,84.14 45.87,84.01 48.28,84.01 48.41,84.14 48.41,85.66
P5V0DS on TOP: 271.42,33.97 269.52,33.97 269.39,33.85 269.39,33.09 269.52,32.96 271.42,32.96 271.55,33.09 271.55,33.85
P5V0DS on TOP: 261.64,2.61 261.64,9.84 256.18,9.84 256.18,2.61
P5V0DS on BOTTOM: 193.42,6.8 193.29,6.92 192.02,6.92 191.89,6.8 191.89,6.03 192.02,5.91 192.53,5.91 193.04,5.4 193.29,5.4 193.42,5.53
P5V0DS on BOTTOM: 270.91,94.55 270.91,91.89 271.04,91.76 272.56,91.76 272.69,91.89 272.69,94.55 272.56,94.68 271.04,94.68
P5V0DS on BOTTOM: 194.21,87.44 194.21,85.79 194.33,85.66 197.76,85.66 199.29,87.19 199.29,90.24 199.16,90.36 196.87,90.36 196.62,90.11 196.62,89.6 195.35,88.33 195.09,88.33
P5V0DS on L3: 255.8,9.34 253.9,9.34 253.77,9.21 253.77,8.19 259.1,2.86 261.64,2.86 261.64,6.29 261.39,6.54 258.59,6.54
P5V0S on TOP: 220.75,103.95 220.75,102.43 218.59,100.27 200.68,100.27 199.41,101.54 199.41,106.49 199.79,106.87 199.79,109.92 204.49,109.92 204.49,105.48 217.95,105.48 219.35,104.08 220.62,104.08
P5V0S on TOP: 222.65,3.27 222.78,3.39 222.78,4.41 222.3,4.89 220.72,4.89 219.83,4 219.83,3.47 220.04,3.27
P5V0S on TOP: 10.16,34.96 11.88,34.96 12.09,35.17 12.09,37.15 11.96,37.28 10.69,37.28 9.9,36.49 9.9,35.22
P5V0S on BOTTOM: 201.32,90.62 201.32,98.74 202.59,100.01 202.59,104.33 202.33,104.59 197.76,104.59 197.51,104.33 197.51,93.16 197.13,92.78 196.62,92.78 196.49,92.65 196.49,91.89 196.62,91.76 197.63,91.76 197.76,91.63 197.76,90.74 197.89,90.62
P5V0S on BOTTOM: 130.71,4.64 129.44,4.64 129.31,4.51 129.31,3.88 129.18,3.75 128.8,3.75 128.75,3.8 128.75,5.98 128.8,6.03 130.71,6.03 130.83,5.91 130.83,4.76
P5V0S on BOTTOM: 56.03,11.62 55.9,11.75 54.51,11.75 54.38,11.62 54.38,10.61 54.51,10.48 55.9,10.48 56.03,10.61
P5V0S on BOTTOM: 80.41,39.44 80.41,37.28 80.79,36.9 80.79,33.09 80.92,32.96 81.68,32.96 81.81,33.09 81.81,39.44 81.68,39.56 80.54,39.56
P5V0S on L3: 199.41,108.9 199.03,109.29 199.03,112.08 197.76,113.35 177.82,113.35 177.44,112.97 124.1,112.97 123.97,113.1 123.97,117.29 124.1,117.41 127.53,117.41 128.04,116.91 128.04,116.27 128.17,116.14 177.7,116.14 180.49,118.94 185.19,118.94 187.86,116.27 201.32,116.27 201.32,110.43 201.7,110.05 201.7,109.03 201.57,108.9
P5V0S on L4: 18.18,14.04 -0.23,32.45 -0.23,48.45 36.34,48.45 45.23,39.56 68.09,39.56 76.98,48.45 77.11,48.45 91.34,62.68 91.34,119.57 202.71,119.57 202.71,103.44 199.29,103.44 199.29,109.03 144.55,109.03 139.6,104.08 128.93,104.08 125.75,107.25 105.05,107.25 102,104.21 102,89.35 106.32,85.03 106.32,63.31 78.76,35.75 74.06,35.75 71.52,33.21 43.96,33.21 39.9,37.28 15.14,37.28 15.14,32.07 19.96,32.07 19.96,15.94 21.36,14.54 21.36,14.04
P5V0S_AUDIO_AVDD on TOP: 12.6,36.01 12.98,35.63 14.25,35.63 14.37,35.75 14.37,37.91 14.12,38.17 12.85,38.17 12.6,37.91
P5V0S_AUDIO_AVDD on TOP: 14.63,45.15 13.74,45.15 13.61,45.02 13.61,42.48 13.87,42.23 14.63,42.23 14.88,42.48 14.88,44.9
P5V0S_AUDIO_AVDD on L5: 14.88,37.53 14.25,36.9 12.72,36.9 10.18,39.44 10.18,45.15 10.31,45.28 10.82,45.28 10.94,45.15 10.94,44.77 11.07,44.64 11.45,44.64 12.09,45.28 14.63,45.28 14.88,45.02
P5V0S_HDMI on BOTTOM: 273.47,92.79 273.47,92.13 273.57,92.03 275.37,92.03 276.37,93.03 276.37,94.05 276.12,94.3 274.98,94.3 274.93,94.25 274.34,94.25 274.16,94.07 274.16,92.95 274.11,92.9 273.58,92.9
P5V0S_IR_LED on TOP: 223.54,104.71 223.54,104.33 223.03,103.82 223.03,102.43 222.91,102.3 221.76,102.3 221.64,102.43 221.64,104.71 221.76,104.84 223.42,104.84
P5V0S_IR_LED on BOTTOM: 223.54,104.84 222.02,104.84 221.89,104.71 221.89,102.81 222.02,102.68 223.03,102.68 223.42,103.06 225.57,103.06 225.7,103.19 225.7,104.33 225.57,104.46 223.92,104.46
P5V0S_IR_LED on L5, L6: 223.42,104.84 222.02,104.84 221.89,104.71 221.89,104.08 222.02,103.95 223.42,103.95 223.54,104.08 223.54,104.71
P5V0S_KBL on BOTTOM: 130.58,8.7 146.33,8.7 146.45,8.57 146.45,5.25 146.17,4.96 141.08,4.96 139.88,6.16 130.83,6.16 130.45,6.54 130.45,8.57
P5V0S_NFC on TOP: 221.56,7.3 222.17,7.3 222.25,7.23 222.25,6.85 222.28,6.81 222.28,5.31 222.15,5.17 220.6,5.17 220.49,5.27 220.49,6.54 220.62,6.67 221.21,6.67 221.46,6.92 221.46,7.2
P5V0S_SM on BOTTOM: 57.43,8.96 57.43,11.62 57.43,11.62 57.3,11.75 56.54,11.75 56.41,11.62 56.41,10.5 56.18,10.28 54.96,10.28 54.86,10.17 54.86,9.39 54.97,9.27 56.35,9.27 56.79,8.83 57.3,8.83
PVBAT on TOP (solid shape): 155.09,5.02 155.09,1.82 154.76,1.49 152.65,1.49 152.3,1.84 152.3,3.29 147.67,3.29 147.6,3.37 147.6,5.04 147.77,5.22 154.89,5.22
PVBAT on BOTTOM (solid shape): 155.09,2.53 155.09,1.69 154.99,1.59 152.42,1.59 152.3,1.72 152.3,2.48 152.55,2.73 154.89,2.73
PVBAT on TOP: 82.83,7.56 82.83,20.77 90.76,28.7 90.76,43.82 96.03,49.09 96.03,50.48 97.81,52.26 99.21,52.26 101.62,54.68 109.88,54.68 110.51,55.31 110.51,61.15 108.61,63.06 108.61,84.14 117.24,92.78 117.24,94.68 121.31,98.74 121.31,100.27 117.24,104.33 117.24,109.54 116.23,110.56 116.23,111.06 118.13,112.97 177.06,112.97 177.06,110.43 190.9,96.59 202.46,96.59 205,94.05 221.76,94.05 224.3,91.51 224.3,84.52 228.11,80.71 232.05,80.71 234.72,78.04 234.72,76.65 234.46,76.39 217.32,76.39 213.26,80.46 209.7,80.46 209.45,80.71 209.45,84.01 208.18,85.28 199.41,85.28 198.4,86.3 183.67,86.3 173.52,96.45 126.5,96.45 122.96,92.9 122.96,87.82 122.83,87.7 116.23,87.7 111.66,83.12 111.66,64.2 114.83,61.03 114.83,52.77 113.81,51.75 104.04,51.75 94.51,42.23 94.51,27.75 88.95,22.19 88.95,10.23 129.31,10.23 129.31,7.56
PVBAT on BOTTOM: 103.65,79.57 103.65,82.74 103.25,83.15 103.25,89.5 102.38,90.36 102.38,94.15 101.16,95.37 101.16,100.83 101.47,101.13 101.8,101.13 102.33,100.6 102.33,100.34 103.78,98.9 103.78,95.65 105.43,93.99 105.43,90.87 106.58,89.73 106.58,87.95 109.75,84.77 109.75,79.44 109.5,79.19 105.43,79.19 105.05,79.57
PVBAT on BOTTOM: 174.27,99.89 175.03,99.89 175.16,100.01 175.16,100.4 175.66,100.9 175.66,101.28 175.54,101.41 174.27,101.41 174.14,101.28 174.14,100.01
PVBAT on BOTTOM: 120.29,110.81 121.05,110.05 121.05,109.79 119.02,107.76 118.77,107.76 116.23,110.3 116.23,110.94 116.99,111.7 116.99,113.1 117.24,113.35 118.64,113.35 120.29,111.7
PVBAT on BOTTOM: 95.78,54.17 95.78,49.85 95.91,49.72 98.32,49.72 98.45,49.85 98.45,52.29 98.09,52.64 98.09,53.15 98.57,53.63 98.57,54.24 98.47,54.35 95.96,54.35
PVBAT on BOTTOM: 223.03,83.43 224.56,83.43 224.81,83.68 224.81,86.1 224.56,86.35 223.03,86.35 222.78,86.1 222.78,83.68
PVBAT on BOTTOM: 233.07,78.42 233.19,78.55 234.01,78.55 234.36,78.91 234.97,78.91 235.12,78.75 235.12,76.82 234.9,76.6 233.19,76.6 233.07,76.72
PVBAT on BOTTOM: 57.17,15.31 54.76,15.31 54.63,15.18 54.63,12.13 54.76,12 57.17,12 57.3,12.13 57.3,15.18
PVBAT on BOTTOM: 146.83,110.81 148.61,110.81 148.74,110.68 148.74,109.16 150.64,109.16 150.77,109.29 150.77,112.08 149.37,113.48 149.37,117.03 149.25,117.16 146.07,117.16 145.95,117.03 145.95,110.56 146.07,110.43 146.45,110.43
PVBAT on BOTTOM: 181.63,99.38 182.39,99.38 182.65,99.63 182.65,102.55 182.52,102.68 181.38,102.68 181.25,102.55 181.25,99.76
PVBAT on BOTTOM: 156.99,101.16 159.41,101.16 159.92,101.67 159.92,107.89 159.79,108.02 156.87,108.02 156.74,107.89 156.74,101.41
PVBAT_CPU1 on BOTTOM (solid shape): 148.49,110.43 148.49,110.17 148.1,109.79 148.1,108.9 148.49,108.52 148.49,105.98 148.28,105.78 146.53,105.78 146.3,105.55 146.3,101.84 146.81,101.33 146.81,100.44 146.68,100.32 146.04,100.32 145.92,100.44 145.92,103.57 145.44,104.05 145.44,105.6 144.68,106.36 144.68,109.79 144.8,109.92 146.2,109.92 146.83,110.56 148.36,110.56
PVBAT_CPU2 on BOTTOM (solid shape): 118.77,106.87 118.77,106.19 117.69,105.11 117.69,104.78 120.31,102.16 121.03,102.16 121.66,101.53 121.66,101.35 121.21,100.91 121.03,100.91 118.75,103.19 117.97,103.19 112.04,109.16 112.04,109.54 113.69,111.19 114.45,111.19
PVBAT_CPU3 on BOTTOM (solid shape): 125.43,109.6 125.43,108.71 128.81,105.34 128.81,105.21 128.36,104.76 128.36,104.44 130.98,101.81 131.7,101.81 132.33,101.18 132.33,101.01 131.88,100.56 131.7,100.56 129.45,102.81 128.67,102.81 127.66,103.82 127.15,103.82 124.53,106.44 124.02,106.44 121.43,109.03 121.43,110.05 121.05,110.43 121.05,110.94 120.55,111.44 120.55,111.7 121.18,112.33 122.7,112.33
PVBAT_GT on BOTTOM: 105.53,67.65 105.97,67.22 105.97,65.57 105.76,65.37 105.76,64.38 105.91,64.23 106.58,64.23 106.7,64.35 106.7,65.27 106.37,65.6 106.37,69.36 106.47,69.46 107.64,69.46 108.35,70.17 108.35,78.68 108.1,78.93 105.43,78.93 105.05,78.55 104.29,78.55 103.91,78.93 103.65,78.93 103.65,77.79 103.91,77.54 104.29,77.54 104.54,77.28 104.54,76.39 105.43,75.5 105.43,72.76 105.53,72.66
PVBAT_LCM on BOTTOM (solid shape): 21.23,18.61 21.23,16.7 20.85,16.32 19.45,16.32 19.2,16.58 19.2,18.86 20.98,18.86
PVBAT_LCM on BOTTOM: 50.06,14.29 50.06,12.38 50.44,12 52.73,12 52.85,12.13 52.85,15.05 52.73,15.18 50.95,15.18
PVBAT_LCM on L4: 20.47,17.34 52.22,17.34 52.22,10.61 25.68,10.61 20.47,15.81
PVBAT_SA on BOTTOM (solid shape): 156.04,105.92 156.04,104.4 155.85,104.21 153.95,104.21 153.69,103.95 153.69,100.27 154.2,99.76 154.2,98.87 154.07,98.74 153.44,98.74 153.31,98.87 153.31,102.07 153.08,102.3 153.08,105.63 154.07,106.62 155.34,106.62
PVCC_PRIM on TOP: 171.76,63.54 171.75,63.54 170.11,63.54 169.95,63.7 169.95,64.07 169.95,68.13 170.08,68.26 172.39,68.26 172.8,68.67 172.8,69.57 173.27,70.04 173.56,70.04 173.72,69.87 173.72,68.92 173.71,68.84 173.72,68.76 173.72,67.56 173.68,67.48 173.59,67.47 173.1,67.16 173.59,66.85 173.68,66.85 173.72,66.77 173.72,66.72 173.68,66.64 173.59,66.63 173.1,66.32 173.59,66.01 173.68,66.01 173.72,65.93 173.72,65.89 173.68,65.81 173.59,65.81 173.09,65.6 173.4,65.16 173.48,65.1 173.46,65.01 173.01,64.56 173.01,63.75 172.8,63.54 172.55,63.54 172.53,63.54 ; 1 cut-out
PVCC_PRIM on BOTTOM: 173.76,84.52 176.3,84.52 176.93,85.16 176.93,86.81 176.68,87.06 173.63,87.06 173.38,86.81 173.38,84.9
PVCC_PRIM on BOTTOM: 170,63.59 171.5,63.59 171.57,63.66 171.57,64.02 171.93,64.38 172.28,64.38 173.05,65.14 173.05,67.25 173.61,67.8 173.61,68.19 173.5,68.29 173.5,69.4 173.68,69.58 173.68,69.86 172.95,70.6 172.46,70.6 172.26,70.39 172.26,69.96 172.77,69.46 172.77,68.95 172.59,68.77 172.59,68.24 172.26,67.91 172.26,67.07 172.08,66.89 172.08,65.87 172.39,65.57 172.39,65.24 171.9,64.76 171.55,64.76 170.91,65.39 170.91,67.42 170.89,67.45 170.89,67.73 170.99,67.83 170.99,68.19 170.68,68.49 169.74,68.49 169.67,68.41 169.67,68.03 170.23,67.47 170.23,64.88 169.67,64.32 169.67,63.92
PVCC_PRIM on L4: 175.16,87.06 184.93,87.06 184.93,65.34 173.76,65.34 172.87,64.45 172.87,63.57 169.95,63.57 169.95,68.52 172.62,68.52 172.62,70.17 175.16,70.17
PVCCGT on TOP: 148.87,60.77 148.87,68.64 146.96,70.55 146.96,73.6 146.83,73.72 142.39,73.72 140.74,75.37 140.74,78.04 140.61,78.17 140.13,78.17 138.44,76.48 137.42,76.48 134.54,73.6 134.54,64.76 138.53,60.77 ; 1 cut-out
PVCCGT on BOTTOM: 112.16,59.37 112.16,63.94 113.51,65.29 113.51,68.85 113.56,68.9 113.56,73.21 115.72,75.37 135.12,75.37 135.13,75.37 135.51,75.37 135.58,75.3 135.96,75.3 136.34,75.68 136.72,75.68 137.49,74.92 138.3,74.92 138.7,75.32 138.71,75.32 140.03,75.32 140.38,74.97 140.38,74.2 140.94,73.65 146.38,73.65 146.68,73.34 146.68,70.47 142.24,70.47 142.24,65.16 138.5,65.16 138.33,65.34 136.93,65.34 136.57,64.98 133.83,64.98 132.97,65.85 131.7,65.85 131.12,65.27 129.77,65.27 127.42,62.91 123.07,62.91 122.45,62.29 122.45,59.63 122.2,59.37
PVCCGT on L4: 146.96,65.34 146.96,75.63 144.17,78.42 112.93,78.42 112.93,63.95 126.01,63.95 128.04,65.98 139.72,65.98 144.17,61.53 148.99,61.53 148.99,65.34
PVCCIO on TOP: 154.45,63.31 153.18,63.31 153.06,63.18 153.06,62.04 153.18,61.91 154.45,61.91 154.58,62.04 154.58,63.18
PVCCIO on BOTTOM: 154.53,60.41 153.11,60.41 152.96,60.57 152.96,63.31 154.53,63.31
PVCCIO on BOTTOM: 163.95,63.31 163.95,60.41 165.07,60.41 165.07,63.31
PVCCIO on BOTTOM: 116.48,53.02 116.48,52.64 116.35,52.52 116.35,49.85 116.61,49.6 118.77,49.6 118.89,49.72 118.89,53.28 118.64,53.53 116.99,53.53
PVCCIO on L3: 153.06,63.44 153.06,60.9 163.09,60.9 163.73,60.26 164.23,60.26 164.36,60.39 164.36,60.77 165.25,61.66 165.25,63.44
PVCCIO on L5: 165.38,60.39 165.38,65.72 135.41,65.72 134.9,66.23 132.1,66.23 129.56,68.77 122.33,68.77 114.32,60.77 114.32,49.85 114.58,49.59 120.04,49.59 120.16,49.72 120.16,53.91 129.05,62.8 135.02,62.8 135.02,60.39
PVCCSA on TOP: 164.61,70.42 164.49,70.55 163.98,70.55 163.85,70.67 163.85,72.96 163.98,73.09 166.52,73.09 166.65,72.96 166.65,67.63 166.14,67.12 166.14,64.71 166.52,64.32 166.52,62.93 166.01,62.42 166.01,61.66 165.88,61.53 165.25,61.53 165.12,61.66 165.12,62.93 164.61,63.44
PVCCSA on BOTTOM: 165.4,60.51 166.32,60.51 167.41,61.61 167.41,63.31 165.33,63.31 165.33,60.59
PVCCSA on BOTTOM: 151.66,89.85 158.14,89.85 158.39,90.11 158.39,92.09 157.58,92.9 151.79,92.9 151.53,92.65 151.53,89.98
PVCCSA on BOTTOM: 166.11,70.47 163.75,70.47 163.57,70.65 163.57,72.81 163.78,73.01 166.6,73.01 166.7,73.11 167,73.11 167.18,72.93 167.18,72.53 166.72,72.07 166.72,71.08
PVCCSA on L4: 163.73,80.08 163.73,61.53 167.03,61.53 167.03,67.3 168.38,68.65 168.38,70.25 169.31,71.19 169.31,80.33 165.63,84.01 165.63,92.9 155.98,92.9 155.98,90.49 160.93,90.49 160.93,82.87
PVCCSA on L5: 159.53,93.03 155.98,93.03 155.85,92.9 155.85,88.08 163.73,80.2 163.73,70.8 163.85,70.68 167.28,70.68 167.92,71.31 167.92,84.65
PVCCSFR on TOP: 169.57,71.06 169.57,82.1 165.76,85.91 165.76,88.2 165.5,88.45 160.78,88.45 160.42,88.1 160.42,88.08 159.79,87.44 159.79,82.99 160.93,81.85 163.22,81.85 164.23,80.83 164.87,80.83 165.88,79.82 165.88,78.68 166.9,77.66 166.9,75.25 168.04,74.1 168.04,71.06
PVCCSFR on BOTTOM: 162.84,89.47 162.84,87.95 162.71,87.82 162.2,87.82 162.07,87.95 162.07,89.47 162.2,89.6 162.71,89.6
PVCCSFR on BOTTOM: 169.09,71.62 169.21,71.59 169.33,71.61 169.36,71.62 169.46,71.52 169.46,70.91 169.28,70.74 167.86,70.74 167.71,70.89 167.71,71.45 167.88,71.62 168.16,71.62 168.17,71.62 168.3,71.59 168.43,71.62 168.44,71.62 169.08,71.62
PVCCSFR on L6: 173.12,69.79 172.74,70.17 168.17,70.17 167.79,69.79 167.79,68.01 167.92,67.88 172.23,67.88 173.12,68.77
PVCCSTG on TOP: 163.34,77.53 163.45,77.43 164.89,77.43 165,77.53 165,80.45 164.87,80.58 163.47,80.58 163.34,80.45
PVCCSTG on TOP: 159.28,92.65 158.65,92.01 158.65,91.51 158.01,90.87 158.01,86.93 158.14,86.81 159.03,86.81 159.15,86.93 159.15,88.08 160.17,89.09 160.17,90.11 161.44,91.38 161.44,94.93 161.31,95.06 159.41,95.06 159.28,94.93
PVCCSTG on BOTTOM: 160.8,93.92 160.8,93.03 160.68,92.9 159.79,92.9 159.66,93.03 159.66,94.93 159.79,95.06 161.31,95.06 161.44,94.93 161.44,94.3 161.31,94.17 161.06,94.17
VCC0V9_SVR on TOP: 258.31,76.42 261.52,76.42 262.23,77.13 262.23,82.11 262.25,82.13 262.25,82.67 261.41,83.5 257.45,83.5 257.45,80.08 257.32,79.95 256.31,79.95 256.18,79.82 256.18,78.55
VCC0V9_SVR on TOP: 260.77,65.64 260.69,65.72 260.39,65.72 259.87,65.2 258.69,65.2 258.34,65.54 258.34,66.26 257.96,66.64 257.55,66.64 257.5,66.59 257.5,66.24 257.32,66.06 256.33,66.06 255.83,65.55 255.83,65.15 255.8,65.12 255.8,62.3 256.18,61.92 257.12,61.92 257.81,62.61 259.84,62.61 259.84,62 259.95,61.88 260.77,61.88
VCC0V9_SVR on BOTTOM: 255.95,61.72 255.73,61.94 255.73,65.88 257.17,65.88 257.68,66.39 257.68,66.56 259.81,66.56 260.12,66.87 260.12,68.26 259.99,68.39 257.71,68.39 256.61,69.48 256.61,77.54 257.17,78.09 261.82,78.09 263.17,76.75 263.17,73.85 267.1,69.92 267.1,62.42 266.96,62.27 260.81,62.27 260.65,62.12 260.32,62.12 259.92,61.72
VCC0V9_SVR on L3: 255.55,66.49 255.55,62.04 260.88,62.04 260.88,66.49
VCC0V9_SVR on L6: 255.55,66.61 255.55,62.04 260.88,62.04 260.88,66.61
VCC_HV_SYS1 on TOP: 257.45,36.26 256.94,36.26 256.18,37.02 255.93,37.02 255.67,36.77 251.36,36.77 250.97,37.15 250.97,38.29 251.36,38.67 251.36,40.45 251.61,40.71 255.04,40.71 255.17,40.58 255.17,39.94 255.29,39.82 255.8,39.82 256.31,40.32 257.45,40.32 257.58,40.2 257.58,36.39
VCC_HV_SYS_2 on TOP: 265.45,85.49 265.45,81.7 265.6,81.55 270.94,81.55 271.01,81.62 271.01,85.08 270.56,85.54 265.5,85.54
VCCA_XTAL_1P05 on BOTTOM: 182.65,85.16 181.76,85.16 181.63,85.03 181.63,83.89 182.52,83 182.52,76.01 181.76,75.25 181.76,74.87 181.89,74.74 184.68,74.74 184.81,74.87 184.81,83.89 184.68,84.01 182.9,84.01 182.78,84.14 182.78,85.03
VCCDPHY on BOTTOM: 171.78,62.42 172.56,62.42 172.69,62.55 172.69,63.61 172.26,64.04 172.03,64.04 171.83,63.84 171.83,63.56 171.65,63.38 171.65,62.55
VCCPLL_OC on TOP: 166.46,61.21 166.59,61.08 166.59,59.66 166.52,59.59 166.52,53.53 168.42,51.62 168.42,51.37 169.06,50.74 169.06,43.62 168.93,43.5 167.66,43.5 167.54,43.62 167.54,50.35 165.12,52.77 165.12,54.09 164.35,54.86 164.35,55.76 164.38,55.82 164.44,55.85 164.78,56.23 164.38,56.56 164.36,56.56 164.2,56.72 164.2,56.95 164.22,56.96 164.41,57.2 164.35,57.49 164.35,57.74 164.42,57.94 164.36,58.14 164.35,58.15 164.35,58.31 164.38,58.31 164.38,58.41 164.42,58.58 164.38,58.73 164.38,58.74 164.38,59.05 164.42,59.22 164.38,59.37 164.38,59.38 164.38,59.68 164.42,59.85 164.38,60 164.38,60.01 164.38,60.22 164.35,60.22 164.35,60.34 164.36,60.36 164.42,60.56 164.35,60.75 164.35,61.12 164.45,61.21
AUDIO_AVDD on TOP (solid shape): 15.01,41.59 15.82,41.59 15.89,41.55 15.97,41.54 16.08,41.54 16.16,41.55 16.23,41.59 16.63,41.59 16.69,41.54 17.67,41.54 18.04,41.16 18.07,41.14 18.1,41.11 18.07,41.03 17.05,41.03 16.98,40.96 13.53,40.96 13.23,41.26 13.23,41.59 13.36,41.72 14.88,41.72
AUDIO_AVDD on TOP: 17.93,36.9 14.88,36.9 14.75,37.02 14.75,38.04 14.88,38.17 18.18,38.17 18.44,37.91 18.44,37.4
AUDIO_AVDD on L3: 16.66,41.72 13.23,41.72 13.1,41.59 13.1,38.8 15.01,36.9 16.66,36.9 16.79,37.02 16.79,41.59
CCG5_VBUS_CSN1 on TOP: 262.61,40.93 263.32,40.93 263.42,41.04 263.42,41.21 262.96,41.67 262.96,42.56 263.42,43.02 263.42,47.44 263.29,47.56 262.53,47.56 262.28,47.82 262.28,48.71 262.15,48.83 261.39,48.83 261.26,48.71 261.26,43.02 261.74,42.53 261.74,41.8
CCG5_VBUS_CSN1_D on TOP: 263.34,40.81 262.61,40.81 261.77,41.65 259.56,41.65 259.33,41.42 259.33,40.07 259.43,39.97 262.89,39.97 262.96,40.04 262.96,40.27 263.04,40.35 263.29,40.35 263.45,40.5 263.45,40.71
CCG5_VBUS_CSN2 on TOP: 265.33,89.98 265.55,89.75 271.8,89.75 272.16,90.11 272.16,91.2 271.78,91.58 267.38,91.58 267.05,91.91 267.05,95.11 266.98,95.19 266.72,95.19 266.34,95.57 266.34,95.82 266.21,95.95 265.45,95.95 265.33,95.82
CCG5_VBUS_CSN2_D on TOP: 267.28,95.19 267.28,92.09 267.64,91.73 268.93,91.73 269.06,91.86 269.06,93.33 268.02,94.38 268.02,94.76 267.56,95.21 267.31,95.21
DIS_PVCCSTG on BOTTOM: 160.42,96.59 160.42,97.22 160.3,97.35 160.04,97.35 159.66,96.97 159.66,95.44 159.79,95.32 160.55,95.32 160.68,95.44 160.68,96.33
EC_AVCC_R on TOP (solid shape): 247.14,38.11 247.47,38.11 247.47,37.5 247.21,37.5 247.14,37.58 245.97,37.58 245.89,37.66 245.89,38.29 246.02,38.42 246.83,38.42
FPR_PWR on TOP: 238.53,7.18 238.53,5.4 238.4,5.27 235.61,5.27 235.48,5.4 235.48,6.92 236.5,7.94 237.77,7.94
FPR_PWR on BOTTOM: 238.27,8.45 236.24,8.45 236.12,8.32 236.12,6.92 236.5,6.54 236.5,6.03 236.62,5.91 237.64,5.91 238.4,6.67 238.4,8.32
FPR_PWR on L3: 237.77,7.69 232.31,7.69 232.18,7.56 232.18,4.38 232.31,4.26 237.77,4.26 237.89,4.38 237.89,7.56
Net_2127 on BOTTOM (solid shape): outline of 162 points within 13.89,-2.41 19.17,-0.51
Net_2127 on BOTTOM (solid shape): outline of 162 points within 270.43,240.79 275.71,242.7
Net_2128 on TOP (solid shape): outline of 162 points within 13.89,-2.41 19.17,-0.51
Net_2128 on TOP (solid shape): outline of 162 points within 270.43,240.79 275.71,242.7
NFC_3V3 on TOP: 232.69,4.89 231.92,4.89 231.8,4.76 231.8,3.49 231.92,3.37 232.69,3.37 232.81,3.49 232.81,4.76
PV_VBUS_CNTR_1 on TOP: 257.83,38.8 257.83,37.15 258.09,36.9 259,36.9 261.77,34.13 274.27,34.13 274.29,34.15 277.52,34.15 278.03,34.66 278.03,37.78 277.75,38.06 274.65,38.06 274.55,37.96 263.47,37.96 263.27,38.17 263.27,39.11 263.42,39.26 263.42,39.79 258.8,39.79 258.7,39.69 258.7,39 258.57,38.88 257.91,38.88
PV_VBUS_CNTR_1 on BOTTOM: 279.03,64.21 280.91,64.21 281.17,64.46 281.17,65.43 280.91,65.68 279,65.68 278.79,65.47 278.79,64.45
PV_VBUS_CNTR_1 on L4: 283.66,62.03 283.66,64.99 283.32,64.99 282.85,65.47 279.04,65.47 278.79,65.22 278.79,64.29 279.57,63.51 279.57,62.49 278.69,61.61 278.69,41.96 274.49,37.76 274.49,36.97 274.9,36.57 279.22,36.57 283.54,40.88 283.54,55.5 281.47,55.5 280.06,56.91 280.06,60.31 281.19,61.44 283.07,61.44
PV_VBUS_CNTR_1 on L5: 283.66,62.03 283.66,65.27 283.3,65.63 279.2,65.63 278.79,65.22 278.79,64.28 279.57,63.5 279.57,62.49 278.69,61.61 278.69,41.95 274.49,37.76 274.49,36.97 274.9,36.57 279.22,36.57 283.54,40.88 283.54,55.5 281.47,55.5 280.06,56.91 280.06,60.31 281.19,61.44 283.07,61.44
PV_VBUS_CNTR_2 on TOP (solid shape): 274.55,93.77 274.93,93.77 275,93.69 275,92.78 274.95,92.72 273.28,92.72 272.84,93.16 272.84,93.77 272.92,93.84 274.47,93.84
PV_VBUS_CNTR_2 on TOP: 273.02,95.8 275.99,92.83 275.99,87.8 275.1,86.91 275.1,82.49 272.44,79.82 270.15,79.82 269.64,80.33 269.64,81.09 269.9,81.35 271.17,81.35 271.29,81.47 271.29,83.96 271.83,84.49 271.83,87.54 272.39,88.1 272.39,91.2 271.7,91.89 269.52,91.89 269.47,91.94 269.47,93.33 268.22,94.58 268.22,95.29 268.78,95.29 269.29,95.8
PV_VBUS_CNTR_2 on BOTTOM: 279.02,79.85 280.26,79.85 280.26,79.77 280.79,79.24 281.71,79.24 281.86,79.39 281.86,80.96 281.75,81.08 281.16,81.08 280.91,81.32 279.26,81.32 278.79,80.84 278.79,80.08
PV_VBUS_CNTR_2 on L5: 279.75,77.66 283.4,77.66 284.07,78.33 284.07,80.66 279.07,85.66 272.56,85.66 272.31,85.41 272.31,81.85 273.58,80.58 276.37,80.58 278.15,78.81 279.37,78.81 279.55,78.63 279.55,77.87
PVADP on TOP: 248.82,99.94 253.54,99.94 253.84,99.63 253.84,97.19 253.77,97.12 251.69,97.12 251.58,97.22 251.58,98.11 251.28,98.41 250.19,98.41 249.96,98.19 248.87,98.19 248.69,98.36 248.69,99.81
PVADP on TOP: 235.61,81.98 238.53,81.98 238.66,81.85 238.66,80.33 237.89,79.57 233.58,79.57 232.18,80.96 228.24,80.96 224.56,84.65 224.56,91.68 223.49,92.75 223.49,97.09 224.56,98.16 224.56,100.4 224.69,100.52 233.32,100.52 233.45,100.4 233.45,97.86 231.82,96.23 229.28,96.23 227.94,94.88 227.94,94.3 230.53,91.71 230.53,91.25 232.69,89.09 232.69,84.14 233.32,83.5 234.08,83.5
PVADP on BOTTOM: 238.53,82.11 235.86,82.11 235.61,81.85 235.61,81.35 235.48,81.22 233.32,81.22 233.19,81.09 233.19,79.95 233.45,79.69 236.24,79.69 237,80.46 238.53,80.46 238.66,80.58 238.66,81.98
PVADP on BOTTOM: 252.83,99.81 231.04,99.81 231.04,96.84 231.16,96.71 243.74,96.71 245.01,97.98 252.5,97.98 253.01,98.49 253.01,99.63 ; 1 cut-out
PVADP on L6: 252.88,99.63 252.88,96.84 252.75,96.71 249.58,96.71 248.94,96.08 231.54,96.08 230.91,96.71 230.91,99.76 231.04,99.89 234.34,99.89 234.46,99.76 252.75,99.76 ; 1 cut-out
PVADP_DC on BOTTOM: 237.89,82.87 237.64,82.62 235.48,82.62 235.35,82.49 235.35,81.6 235.23,81.47 233.32,81.47 232.94,81.09 232.05,81.09 231.92,81.22 231.92,82.49 232.56,83.12 232.56,84.01 233.07,84.52 234.21,84.52 235.1,85.41 237.77,85.41 237.89,85.28
PVCORE on TOP: 157.38,91.25 157.38,83.37 163.22,77.53 163.22,72.45 163.47,72.2 163.47,71.18 161.95,71.18 161.95,63.18 163.98,63.18 163.98,60.26 155.09,60.26 155.09,60.26 154.33,60.26 154.2,60.39 154.2,61.53 154.33,61.66 154.71,61.66 154.84,61.79 154.84,62.8 154.71,62.93 154.71,63.18 154.96,63.44 154.96,72.12 154.76,72.33 153.72,72.33 153.31,71.92 153.31,69.56 153.03,69.28 148.61,69.28 147.22,70.67 147.22,73.34 147.85,73.98 147.85,89.72 147.72,89.85 142.77,89.85 141.75,90.87 123.34,90.87 123.21,90.99 123.21,91.76 126.9,95.44 156.74,95.44 156.99,95.19 156.99,91.63 ; 1 cut-out
PVCORE on BOTTOM: 146.91,70.47 162.61,70.47 163.32,71.18 163.32,74.28 162.76,74.84 156.21,74.84 156.13,74.76 156.13,73.24 155.88,72.99 147.16,72.99 146.91,72.73
PVCORE on BOTTOM: 148.43,96.07 149.14,95.35 149.14,91.57 148.3,90.73 130.24,90.73 128.5,88.99 123.57,88.99 120.42,92.14 120.42,92.39 124.09,96.07
PVCORE on BOTTOM: 163.7,60.41 154.78,60.41 154.78,63.31 162.53,63.31 163.7,62.14
PVCORE on L4: 163.47,79.95 163.47,60.36 155.75,60.36 154.58,61.53 149.25,61.53 149.25,65.6 147.22,65.6 147.22,75.88 144.42,78.68 125.5,78.68 125.5,95.57 155.72,95.57 155.72,90.24 160.68,90.24 160.68,82.74
PVCORE on L5: 125.5,95.82 125.5,89.35 126.39,88.46 126.39,81.85 129.56,78.68 144.42,78.68 145.56,77.54 145.56,74.36 146.96,72.96 146.96,70.68 163.47,70.68 163.47,80.08 155.6,87.95 155.6,95.82
PVPACK on TOP: 81.56,42.61 97.18,58.23 102.51,58.23 103.78,59.5 103.78,85.41 110.13,91.76 110.13,92.65 108.48,94.3 108.48,105.35 110.13,107 110.13,107.76 107.95,109.95 106.42,109.95 105.31,111.06 105.31,112.97 105.43,113.1 113.18,113.1 116.74,109.54 116.74,104.46 121.05,100.14 121.05,98.87 116.74,94.55 116.74,92.78 108.35,84.39 108.35,62.93 110.26,61.03 110.26,55.44 109.75,54.93 101.5,54.93 99.08,52.52 97.69,52.52 95.78,50.61 95.78,49.21 90.57,44.01 90.57,28.89 87.78,26.1 81.81,26.1 81.56,26.35
PVPACK on BOTTOM: 109.62,112.84 109.62,110.5 109.47,110.35 105.69,110.35 105.43,110.61 105.43,112.43 105.97,112.97 109.5,112.97
PVPACK on BOTTOM: 82.06,24.45 82.19,24.32 83.03,24.32 83.13,24.22 83.13,21.93 83.11,21.91 83.44,21.58 86.59,21.58 86.99,21.99 86.99,23.79 86.56,24.22 85.49,24.22 85.24,24.47 85.24,27.62 85.11,27.75 81.81,27.75 81.68,27.62 81.68,25.72 82.06,25.34
PVSYS on TOP: 253.39,36.39 253.26,36.51 251.23,36.51 250.72,37.02 250.72,38.42 250.59,38.55 249.58,38.55 249.32,38.29 249.32,35.37 250.85,33.85 253.26,33.85 253.39,33.97
PVSYS on TOP: 264.11,82.62 262.84,83.89 262.84,85.28 262.12,85.99 262.12,87.85 261.03,88.94 255.75,88.94 255.74,88.95 254.42,88.95 253.56,89.8 253.56,92.19 253.82,92.45 255.65,92.45 255.67,92.47 261.16,92.47 265.27,88.36 265.27,82.69 265.2,82.62
PVSYS on BOTTOM: 187.35,104.33 187.35,107.25 187.09,107.51 185.57,107.51 185.32,107.25 185.32,104.33 185.57,104.08 187.09,104.08
PVSYS on L3: 231.29,109.85 232.25,109.44 232.74,108.52 232.74,104.84 219.61,104.84 218.72,105.73 203.35,105.73 202.46,104.84 187.73,104.84 186.97,104.08 185.32,104.08 185.19,104.21 185.19,106.62 186.59,108.02 201.83,108.02 202.46,108.65 202.46,112.97 204.24,114.75 214.14,114.75 217.07,111.83 229.32,111.83
PVSYS on L5: 249.32,36.13 249.32,38.42 252.37,38.42 253.77,39.82 255.17,39.82 267.23,51.88 267.23,53.02 268.75,53.02 268.75,71.06 271.42,73.73 271.42,77.28 264.44,84.27 234.97,84.27 225.19,94.05 225.19,109.16 225.32,109.29 231.92,109.29 232.05,109.16 232.05,107.25 231.16,106.36 231.16,96.33 234.97,92.52 264.18,92.52 272.06,84.65 272.06,81.73 274.09,79.69 274.09,77.66 276.12,75.63 276.12,70.04 273.2,67.12 273.2,51.12 271.68,49.6 271.68,41.24 268.6,38.17 266.6,38.17 265.83,37.4 256.69,37.4 255.42,36.13
PVSYS_BUCK on BOTTOM: 179.22,109.54 181.89,109.54 182.65,108.78 183.79,108.78 183.79,104.84 183.54,104.59 177.95,104.59 177.31,103.95 177.31,102.55 177.19,102.43 171.35,102.43 170.84,102.94 170.84,107.51 170.96,107.63 178.84,107.63 178.97,107.76 178.97,109.29
PWRSW_P3V3A on BOTTOM: 211.22,84.27 211.1,84.14 210.84,84.14 210.72,84.01 210.72,83.38 211.1,83 211.1,82.49 210.97,82.36 210.59,82.36 210.21,81.98 209.32,81.98 209.19,82.11 209.19,83.38 208.68,83.89 208.68,84.77 208.81,84.9 209.19,84.9 209.32,85.03 211.1,85.03 211.22,84.9
PWRSW_P3V3S on BOTTOM: 211.22,86.3 207.83,86.3 207.83,87.63 207.9,87.7 208.68,87.7 209.06,87.31 211.1,87.31 211.22,87.19
SPI_TPM_VCC on L6: 173.63,61.91 170.58,61.91 170.46,61.79 170.46,61.03 170.58,60.9 173.25,60.9 173.38,60.77 173.38,60.26 173.5,60.14 173.5,56.71 173.63,56.58 174.9,56.58 175.03,56.71 175.03,56.96 174.77,57.22 174.77,60.77
SPK_OUT_L_R_DN on TOP: 4.26,39.42 5.35,39.42 5.6,39.17 5.6,38.36 4.21,38.36 4.21,39.37
SPK_OUT_L_R_DP on TOP: 4.26,39.73 5.35,39.73 5.6,39.98 5.6,40.29 5.1,40.79 4.44,40.79 4.21,40.57 4.21,39.78
SPK_OUT_R_DN on TOP (solid shape): 8.35,38.44 8.35,37.58 8.05,37.28 7.64,37.28 7.39,37.02 6.32,37.02 6.32,37.91 6.93,37.91 7.62,38.6 8.2,38.6
SPK_OUT_R_DN on L6: 17.93,40.71 17.93,39.69 17.29,39.05 17.04,39.05 16.53,39.56 15.52,39.56 15.52,40.71 15.64,40.83 17.8,40.83
SPK_OUT_R_DP on TOP (solid shape): 8.33,36.84 8.33,36.26 8.18,36.11 7.49,36.11 7.26,35.88 6.32,35.88 6.32,36.77 7.52,36.77 7.77,37.02 8.15,37.02
SPK_OUT_R_DP on L6: 18.69,39.56 18.18,39.56 17.42,38.8 16.79,38.8 16.28,39.31 15.52,39.31 15.39,39.18 15.39,38.04 18.69,38.04 18.82,38.17 18.82,39.44
SPK_OUT_R_DP on L6: 7.64,36.9 6.25,36.9 6.12,36.77 6.12,36.01 6.25,35.88 8.4,35.88 9.17,36.64 9.17,38.8 9.04,38.93 8.02,38.93 7.9,38.8 7.9,37.15
SPK_OUT_R_R_DN on TOP: 4.26,37.04 5.35,37.04 5.6,37.29 5.6,37.59 5.1,38.1 4.44,38.1 4.21,37.87 4.21,37.09
SPK_OUT_R_R_DP on TOP: 4.26,36.73 5.35,36.73 5.6,36.48 5.6,36.17 5.1,35.66 4.44,35.66 4.21,35.89 4.21,36.68
TBT_SVR_IND on TOP: 258.57,69.79 258.57,68.54 258.64,68.47 259.25,68.47 259.28,68.49 259.28,70.58 261.85,73.14 261.85,75.78 261.67,75.96 258.44,75.96 257.93,75.45 257.93,70.42
UNNAMED_7_CSC0603_I24_A on BOTTOM: 241.7,81.6 241.7,80.33 241.58,80.2 239.42,80.2 239.16,80.46 239.16,81.85 239.29,81.98 241.32,81.98
UNNAMED_7_CSC0603_I217_A on BOTTOM: 151.66,112.21 151.66,110.81 151.15,110.3 151.15,109.16 151.91,108.4 155.34,108.4 155.47,108.52 155.47,113.48 155.09,113.86 155.09,115.76 154.33,115.76 154.33,114.24 154.2,114.11 149.88,114.11 149.76,113.98 149.76,113.48 150.9,112.33 151.53,112.33
UNNAMED_7_CSC0805_I128_A on BOTTOM: 110,114.49 109.88,114.37 109.88,110.43 110,110.3 111.91,110.3 113.05,111.44 115.85,111.44 115.97,111.57 115.97,114.37 115.85,114.49
VADPBL on TOP: 250.47,95.57 250.47,90.11 250.59,89.98 253.13,89.98 253.26,90.11 253.26,93.54 254.91,95.19 254.91,96.71 254.78,96.84 250.21,96.84 250.09,96.71 250.09,95.95
VRA5V0_VCC on BOTTOM (solid shape): 239.67,73.34 240.92,73.34 241.32,72.94 241.55,72.94 241.6,72.89 241.6,72.43 241.55,72.38 241.02,72.38 240.56,72.84 239.26,72.84 239.26,73.57 239.29,73.6 239.42,73.6
VRB1V05A_BST on BOTTOM (solid shape): 165.07,99.63 164.69,99.25 162.48,99.25 162.48,100.07 165.07,100.07
VRB1V8A_BST on BOTTOM (solid shape): 107.59,100.4 107.59,99.89 106.45,98.74 106.19,98.74 105.86,99.07 105.86,99.35 106.3,99.79 106.78,99.79 107.49,100.5
VRB5V0A_BST on BOTTOM (solid shape): 188.19,97.47 189.02,97.47 189.1,97.4 189.1,97.27 188.92,97.09 187.37,97.09 187.22,96.94 186.2,96.94 186.2,97.75 187.91,97.75
VRB_VDD5 on BOTTOM: 195.48,89.85 194.71,89.85 194.59,89.73 194.59,88.71 194.71,88.58 195.22,88.58 195.6,88.97 195.6,89.73
VRP1V5 on BOTTOM: 229.64,86.93 229.89,86.68 229.89,85.54 230.15,85.28 231.16,85.28 231.16,85.92 231.8,86.55 231.8,88.51 232.61,89.32 232.61,89.6 232.47,89.75 231.77,89.75 231.58,89.94 231.58,91.25 231.45,91.38 229.77,91.38 229.64,91.25
VRP1V5_PH on BOTTOM: 229,91.25 229,87.7 228.75,87.44 226.34,87.44 226.21,87.57 226.21,89.22 226.34,89.35 227.23,89.35 227.35,89.47 227.35,91.25 227.48,91.38 228.88,91.38
VRP1V5_VIN on BOTTOM: 224.75,89.51 224.75,87.28 224.51,87.03 222.4,87.03 222.27,87.16 222.27,89.85 222.53,90.11 224.15,90.11
VRP1V05A on BOTTOM: 164.61,94.3 164.61,90.62 165.76,89.47 167.03,89.47 167.28,89.73 168.81,89.73 169.19,89.35 169.19,87.7 169.44,87.44 170.84,87.44 171.09,87.7 171.09,94.3 170.84,94.55 170.08,94.55 169.95,94.68 169.95,96.33 169.82,96.46 169.31,96.46 167.41,94.55 164.87,94.55
VRP1V05A_PH on BOTTOM: 163.6,99 164.74,99 165.55,99.81 166.09,99.81 166.19,99.71 166.19,99.05 166.87,98.36 168.3,98.36 168.42,98.24 168.42,96.46 168.17,96.2 163.73,96.2 163.6,96.33
VRP1V05A_VIN on BOTTOM (solid shape): 161.82,103.06 165.25,103.06 165.35,102.96 165.35,102.61 165.3,102.55 165.3,101.51 165.4,101.41 165.4,100.34 165.38,100.32 165.18,100.34 160.47,100.34 160.42,100.4 160.42,103.08 160.43,103.08 160.43,103.95 160.93,103.95
