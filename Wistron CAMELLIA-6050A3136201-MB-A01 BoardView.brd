# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3V3DS_AUDIO_LED: length 5.6
  BOTTOM w0.102: R362.2 48.26,15.28 v3(47.72,14.75) 47.29,14.31 46.02,14.31 45.29,13.58 CN300.6
P3V3DS_CCG5: length 6.7
  TOP w0.076: 261.39,22.86 261.39,23.26 261.57,23.44 U2403.A5
  TOP w0.254: v3(259.91,18.86) R2456.2 260.87,19.69 261.38,20.2 C2411.1 261.38,20.34 261.38,21.14 261.38,21.15 C2410.1 261.38,21.78 261.39,21.78 261.39,22.86
P3V3DS_FN_CAP_PP_LED: length 6.2
  BOTTOM w0.102: CN300.13 41.79,14.33 v3(41.37,14.75) 42.06,15.43 42.52,15.43 42.74,15.65 42.96,15.65 43.06,15.75 43.06,15.75 43.26,15.95 43.26,16.31 43.27,16.32 43.27,16.55 R393.2
P3V3DS_PWR_LED: length 6.4
  BOTTOM w0.102: R343.2 50.27,15.69 v3(50.27,15) 49.68,15 47.79,13.11 46.53,13.11 46.29,12.87 CN300.4
P3V3DS_U5002_PIN3: length 2.4
  BOTTOM w0.254: v3(182.59,113.27) U4412.3 182.47,114.5 R4411.1
P3V3DS_WLAN: length 1
  BOTTOM w0.254: 57.23,32.32 C7522.1 ; C7521.1 57.56,33.92 ; 57.23,32.96 C7520.1
  vias: v3(57.2,35.24)
P3V3DS_WWAN: length 11.8
  TOP w0.254: C1413.1 213.89,57.47 ; C1406.1 214.53,57.47 ; 202.85,57.46 C1414.1 ; C1407.1 202.08,57.47
  BOTTOM w0.254: v5(199.29,57.67) 199.08,57.88 199.08,58.08 199,58.16 CN1400.2 ; CN1400.74 217,58.81 216.5,58.31 216.1,58.31 216.03,58.38 v5(215.47,58.38) ; C1411.1 199.5,61.24 CN1400.4 199.5,58.25 200.05,57.7 v5(200.05,57.67)
  BOTTOM w0.381: 217,61.74 C1408.1
  vias: v3(210.99,57.8) v5(215.46,57.65)
P3V3S: length 501.2
  TOP w0.127: 267.38,79.34 267.64,79.59 270.3,79.59 273.79,76.1 273.79,74.15 273.79,74.15 271.88,72.23 R2755.1
  TOP w0.254: R4355.2 225.13,7.96 228.86,7.96 C7508.1 C4351.1 228.88,6.8 229.25,6.42 v1(230.19,6.42) ; R1954.1 267.74,14.11 v5(265.53,16.32) ; Q4750.2 198.9,64.2 v1(198.88,64.23) 198.9,64.25 R4802.1 ; R4354.2 220.32,7.81 219.71,7.2 219.71,6.47 217.75,4.51 v1(217.55,4.51) ; v1(99.46,91.25) 99.46,91.38 99.08,91.76 R66002.1 ; R3301.2 232.84,96.55 233.09,96.81 v1(233.96,96.81) R3307.1 ; v1(236.62,96.81) 236.41,97.03 R3306.1 ; R3341.2 v1(238.14,99.04) ; C4104.1 163.17,18.86 C4105.1 162.36,18.78 v1(162.35,18.79) 162.16,18.98 R4103.1 ; R3013.1 25.47,15.31 25.57,15.31 v1(25.93,14.95) 25.93,14.56 25.68,14.31 R3010.1 ; C3006.1 53.4,9.81 v5(52.92,10.3) ; R3309.2 v1(249.89,91.47) ; R4650.1 R4729.1 183.88,42.23 183.41,42.71 R4707.1 183.31,42.83 183.31,42.99 183,43.3 v1(183,44.57) ; R4787.1 213.18,73.59 v1(212.8,73.98) 213.06,74.24 R4786.1 ; R3303.2 251.69,88.37 R3311.2 251.73,88.47 252.36,89.1 R3319.2 252.37,89.35 v1(253.21,89.35) ; R3543.2 216.52,54.81 216.05,54.34 216.05,54.27 v1(215.92,54.14) 215.85,54.14 215.29,53.58 C7612.1 ; C4130.1 236.24,21.58 C4129.1 236.73,22.29 v1(236.75,22.31) ; 267.38,79.34 v5(267.33,79.29) 267.31,79.31 C7611.1 ; R3034.1 223.42,102.78 v1(223.45,102.75) ; R4584.1 105.56,5.7 v5(105.56,4.15) 105.58,4.13 F300.1 ; R4549.1 196.35,47.2 196.35,47.1 196.61,46.84 196.66,46.79 v1(197.15,46.79) ; R4922.1 113.28,74.06 v1(113.08,74.26) ; R4705.1 201.41,54.13 v1(201.78,54.13) 201.78,53.38 200.82,52.41 200.11,52.41 198.97,51.27 198.52,51.27 198.27,51.03 R4565.1 197.53,50.87 R4950.1 196.88,51.79 R4721.1 196.88,53.61 197.39,54.12 R4718.1 ; v1(243.08,99.32) 243.16,99.24 R3322.2 ; C7613.1 220.24,100.53 v1(220.34,100.42) ; R4126.1 239.54,15.61 v1(239.62,15.69) ; R4913.1 R4828.1 v1(220.55,37.38) 220.37,37.2 219.45,37.2 219.27,37.38 Q4752.5 ; R4714.1 R4629.1 181.78,41.32 181.78,42.71 R4628.1 R4715.1 181.75,44.56 v1(181.76,44.57) ; R4560.1 R4561.1 197.03,63.06 196.64,62.67 v1(196.64,61.84) ; R4825.1 199.56,62.76 199.12,62.76 198.9,62.55 Q4750.5 198.9,61.74 198.81,61.64 R4798.1 198.49,61.28 198.06,61.71 197.99,61.71 v1(197.86,61.84) ; v1(189.47,61.27) 189.37,61.27 R4542.1 188.3,60.51 R4749.1 ; v1(53.68,10.25) 54.03,9.9 C7615.1 ; 22.24,10.94 21.37,10.07 R3030.1 ; v1(220.82,69.28) 219.81,70.29 R4590.1 R4591.1 ; R3018.2 25.89,12.67 v1(25.93,12.63) ; R396.2 236.79,49.83 236.12,49.83 233.97,51.98 233.14,51.98 232.58,52.54 232.58,52.54 230.17,54.95 230.17,58 v1(230.1,58.08) ; R3340.2 237.53,82.62 v1(237.89,82.62) ; R4725.1 205.63,56.78 v1(205.3,56.45) 205.5,56.26 R4769.1 ; v1(237.64,95.54) 237.51,95.67 C3315.1 236.95,94.85 237.2,94.6 U3300.56 ; R4708.1 v1(183.86,62.35) ; v1(178.97,85.41) 177.96,84.41 177.96,78.69 179.28,77.38 180.2,77.38 184.81,81.98 184.81,82.58 186.19,83.96 191.67,83.96 193.16,82.46 193.16,78.32 v1(194.13,77.36) ; R4711.1 211.32,61.71 v1(212.98,63.38) 212.98,63.45 213.39,63.86 213.87,63.86 214.12,63.61 214.12,62.4 R4765.1 ; Q4752.2 v1(219.27,39.82) ; R3355.2 v1(247.6,96.31) ; R426.2 239.94,33.73 240.75,32.91 v1(241.25,32.91) 241.26,32.91 R318.2 ; C7614.1 55.3,22.39 v1(55.3,21.2) 55.3,17.99 52.42,15.11 52.42,11.48 v5(52.84,11.06) ; F3001.1 v5(219.52,108.48)
  TOP w1.016: 46.38,36.13 48.41,36.13 49.37,35.17 55.55,35.17 58.59,32.12 65.41,32.12 68.48,35.19 70.45,35.19 74.05,38.8 77.11,38.8 v5(79.91,36.01)
  L3 w0.254: v1(194.13,77.36) 194.13,77.13 195.91,75.35 198.29,75.35 199.49,76.55 v1(199.49,77.13) ; v5(265.53,16.32) 265.93,15.92 267.95,15.92 268.73,16.7 268.73,23.91 267.79,24.86 267.39,24.86 266.83,24.3 264.95,24.3 264.3,24.95 264.3,26.21 264.29,26.22 264.29,29.95 v1(264.56,30.22) ; v1(113.08,74.26) 113.51,74.26 113.94,74.69 113.94,74.82 117.9,78.79 117.9,79.26 118.06,79.41 118.06,83.43 117.93,83.55 v1(117.93,83.76) ; v5(24.09,10.71) 24.97,9.83 25.67,9.83 25.93,10.08 v1(25.93,12.63)
  L5 w0.254: v1(212.8,73.98) 212.8,73.27 212.32,72.78 212.32,72.38 212.98,71.71 v1(212.98,63.38) ; v1(25.93,14.95) 25.93,12.64 v1(25.93,12.63)
  L6 w0.254: v1(99.46,91.25) 99.46,91.39 98.39,92.46 98.26,92.46 95.27,95.44 95.27,101.03 98.35,104.1 98.35,106.87 99.69,108.22 103.21,108.22 104.71,106.72 v1(105.46,106.72) ; v1(100.33,50.05) 106.79,56.52 106.79,56.55 106.87,56.63 106.87,65.75 107.62,66.51 108.89,66.51 112.29,69.92 v1(112.71,69.92) ; v1(164.78,15.25) 166.27,13.76 170.37,13.76 170.95,13.17 238.47,13.17 239.62,14.32 v1(239.62,15.69) ; v1(128.13,86.4) 127.33,85.6 119.77,85.6 v1(117.93,83.76)
  BOTTOM w0.229: R7004.1 201.43,64.7 201.24,64.7 200.77,64.23 v1(200.71,64.23)
  BOTTOM w0.254: v1(164.78,15.25) 165.32,15.8 165.32,17.29 163.82,18.79 v1(162.35,18.79) 161.49,18.79 160.63,19.65 CN4100.255 ; v1(236.75,22.31) 236.07,22.31 234.9,23.48 234.9,23.91 234.64,24.17 233.34,24.17 233.33,24.17 233.04,24.17 232.76,24.45 232.76,24.85 233.04,25.14 233.33,25.14 233.34,25.14 234.34,25.14 234.74,25.54 234.74,30.07 237.38,32.7 237.55,32.7 237.76,32.91 v1(241.25,32.91) ; v1(236.75,22.31) 236.33,21.88 CN4125.255 ; v1(236.75,22.31) 237.38,22.31 239.68,20.01 239.68,15.75 v1(239.62,15.69) ; R4563.1 198.82,64.28 v1(198.88,64.23) ; v1(181.76,44.57) v1(183,44.57) ; v1(220.34,100.42) 220.21,100.29 U3002.5 ; Q4411.2 127.15,84.32 126.93,84.1 126.37,84.1 125.62,84.85 R4413.1 R4412.1 126.15,85.66 126.37,85.45 126.93,85.45 127.15,85.67 Q4411.5 127.15,86.85 ; R4866.2 R4865.2 v1(264.56,30.22) ; v1(234.26,3.88) 231.54,3.88 230.19,5.23 v1(230.19,6.42) ; R7411.1 208.63,71.8 R7404.1 208.82,71.2 v1(208.68,71.08) ; R4748.1 190.09,72.26 v1(190.09,72.57) ; v1(55.3,21.2) 55.31,22.32 R1301.2 55.56,22.61 U1300.5 ; v1(128.13,86.4) 127.69,86.85 127.15,86.85 ; v1(85.75,31.49) 85.75,31.91 R4301.2 85.54,32.63 R4303.2 ; R4575.1 R4573.1 189.47,60.83 v1(189.47,61.27) ; v1(113.08,74.26) 112.71,73.89 v1(112.71,69.92) ; R4416.1 119.11,84.48 U4411.1 118.7,84.98 118.36,84.65 C4411.1 117.75,84.17 117.93,83.98 v1(117.93,83.76) ; v1(100.33,50.05) 100.84,50.57 R7422.1 ; v1(22.03,11.69) 22.66,12.32 23.19,12.32 23.56,12.69 C3000.1 ; v5(52.84,11.06) 53.35,11.06 U3000.5 v1(53.68,10.25) ; v1(199.49,77.13) 199.92,76.7 R4782.1 ; v1(188.26,72.57) 187.5,73.33 R4816.1 ; U3003.5 219.99,97.47 v1(219.96,97.5) ; R4577.1 187.11,60.98 187.2,61.07 187.2,61.1 v1(187.37,61.27) 187.53,61.1 187.53,61.07 187.72,60.88 R4571.1 ; 127.15,86.85 126.45,87.54 125.97,87.54 125.63,87.2 125.63,87.17 125.62,87.16 R4414.1 ; v1(217.55,4.51) 217.55,4.83 R400.2 ; R4854.1 178.21,85.41 v1(178.97,85.41) 178.45,84.9 R4870.1
  vias: v1(44.35,37.66) v1(235.23,3.88) v5(205.64,85.97) v5(206.02,85.31) v5(206.4,85.97) v5(206.78,85.31) v5(207.16,85.97) v5(265.15,16.96) v5(265.91,16.96)
P3V3S_2ALS_H: length 4.2
  TOP w0.254: v1(73.2,78.45) R9304.1 ; CN9302.1 77.86,78.59 77.7,78.75 v1(77.7,79.35) ; C9302.1 75.07,79.2 74.6,79.67 v1(74.6,79.99) 74.59,80 U9302.6
P3V3S_ALS: length 13.7
  TOP w0.254: C9301.1 77.75,106.5 v1(77.65,106.6) ; C9301.1 78.53,106.07 U9301.6 ; C9301.1 77.75,106.06 R9302.1
  TOP w0.356: CN9301.1 v1(76.95,96.39)
  L6 w0.381: v1(77.65,106.6) 77.65,105.31 76.33,103.99 76.33,97.01 v1(76.95,96.39)
P3V3S_ALS_HUB_DB: length 13.4
  TOP w0.254: R9300.1 76.89,107.8 77.39,108.3 C9300.1 77.39,109.25 77.98,109.85 v1(77.98,110.44) 78.3,110.44 U9300.6
  TOP w0.356: v1(77.13,102.59) 76.95,102.41 CN9300.1
  L3 w0.381: v1(77.98,110.44) 77.3,109.75 77.3,107.66 77.05,107.41 77.05,106.37 77.13,106.29 v1(77.13,102.59)
P3V3S_AUDIO: length 43.4
  TOP w0.254: R516.1 25.77,36.25 v1(25.68,36.25)
  TOP w0.279: C505.1 26.52,39.93 26.21,40.25 U500.18 ; C520.1 20.65,36.63 U500.3
  TOP w0.305: C520.1 20.69,35.66 23.09,33.26 C521.1
  TOP w0.381: v1(30.12,35.56) 30.12,36.62 29.71,37.02 R500.1 28.9,38.04 28.76,38.25 28.41,38.6 27.05,38.6 26.67,38.98 C504.1 26.67,39.89 C505.1 ; C521.1 23.41,33.27 v1(23.41,34.29) ; R501.2 18.34,33.98 v1(18.44,34.08)
  TOP w1.016: v3(41.81,36.26) 34.57,36.26 33.87,35.56 30.12,35.56 v1(30.12,35.56)
  L3 w0.381: v1(18.44,34.08) 19.76,34.08 20.48,34.8 20.93,34.8 21.44,34.29 v1(23.41,34.29) 23.41,34.52 25.13,36.25 25.67,36.25 v1(25.68,36.25) 27.2,34.72 29.02,34.72 29.86,35.56 v1(30.12,35.56)
P3V3S_CAMERA_ALS: length 15.4
  TOP w0.254: C2250.1 223.55,98.85 223.45,98.75 v1(223.45,98.59) 222.97,98.59 222.5,99.06 222.5,99.91 222.36,100.05 222.36,100.59 v3(221.87,101.08) 221.28,101.67 221.28,105.6
  BOTTOM w0.254: C2251.1 222.76,98.59 222.88,98.59 222.89,98.59 v1(223.45,98.59) 223.45,98.65 224.05,99.25 CN3001.4 ; v1(223.37,105.75) 222.84,105.22 C2256.1 ; v1(223.37,105.75) 223.27,105.86 C2255.1 ; v1(223.37,105.75) 223.87,105.25 CN3001.16
P3V3S_CLKPAD: length 7.2
  TOP w0.254: F300.2 109.5,4.13 v1(109.55,4.18)
  BOTTOM w0.356: v1(109.55,4.18) 108.89,4.84 108.89,6.88 108.75,7.02 CN303.8 108.94,8.06 C323.1
  vias: v3(109.95,3.57)
P3V3S_EN: length 4.5
  TOP w0.13: v3(216.66,85.26) 216.35,84.94 R7016.2 215.8,85.04 215.23,85.6 214.26,85.6 v1(213.71,86.15)
  BOTTOM w0.13: v1(213.71,86.15) 213.63,86.06 U7001.3
P3V3S_KBL_EN#: length 2.6
  BOTTOM w0.102: R382.1 131.09,4.38 Q301.D 130.51,3.8 R351.1
P3V3S_KBL_EN#_RC: length 1.8
  BOTTOM w0.102: Q300.1 132.61,4.84 R382.2 C326.1
P3V3S_LCDVDD: length 1.5
  TOP w0.254: v5(54.71,7.84) v3(54.71,7.08) ; v1(54.65,8.87) 54.55,8.97 R3029.2
  vias: v1(24.63,26.35) v5(24.13,25.9) v5(24.86,25.72) v5(55.27,8.4)
P3V3S_R_LCDVDD: length 10.5
  TOP w0.254: v1(22.45,28.31) 22.04,28.31 v5(21.74,28.01) 21.47,27.74 R3000.2 20.71,25.85 v1(20.6,25.85)
  BOTTOM w0.254: v1(20.6,25.85) 20.5,25.75 CN3000.17 ; CN3000.24 21.51,29.25 v1(22.45,28.31) ; CN3000.23 21.11,28.75 21.74,28.12 v5(21.74,28.01)
P3V3S_SS1: length 2.1
  BOTTOM w0.254: C7040.2 209.72,85.92 209.95,86.15 210.35,86.15 210.43,86.06 U7001.12
P3V3S_SSD: length 1.4
  TOP w0.254: v3(264.26,19.93) 265.21,19.93 R1953.1
  vias: v5(248.54,21.63) v5(267.03,19.34) v5(267.69,19.7) v5(267.69,18.94)
P3V3S_TOUCH_F:
  vias: v3(19.66,16.02)
P3V3S_TOUCH_VCC: length 29
  TOP w0.254: 23.74,14.86 Q3005.5 ; 23.74,14.86 Q3005.2 22.76,14.86 22.4,14.51 v1(22.4,13.91) 22.4,13.11 R4930.2 23.19,12.89 Q3004.G ; 23.74,14.86 23.74,15.45 24.15,15.87 R4927.1 ; 23.74,14.86 R4928.1 ; R3031.2 20.87,15.47 21.6,14.74 v1(21.6,14.33) ; F3002.2 20.09,22.25 20.98,23.14 v5(20.98,23.56)
  TOP w0.381: C3001.1 19.33,23.07 v3(19.58,22.82)
  L3 w0.254: v5(20.98,23.56) 19.58,22.16 19.58,15.1 20.29,14.39 21.53,14.39 v1(21.6,14.33) 22.02,13.91 22.39,13.91 v1(22.4,13.91)
  BOTTOM w0.254: CN3000.12 20.67,23.25 v5(20.98,23.56) 20.79,23.75 CN3000.13
P3V3S_USB: length 34.4
  BOTTOM w0.254: 16.25,42.74 CN2500.1
  BOTTOM w0.508: F2500.2 40.58,37.49 TP2502.1 40.75,37.75 40.75,38.53 40.08,39.21 36.78,39.21 33.8,36.23 28.32,36.23 27.11,37.45 27.11,37.96 26.51,38.56 24.81,38.56 24.26,38.01 19.92,38.01 19.28,38.65 19.28,39.71 16.25,42.74
P3V3S_USB_DB: length 94
  TOP w0.254: 49.17,79.21 49.17,77.95 48.19,76.98 46.41,76.98 46,77.39 v1(46,77.79) 46.03,77.82 R9226.1 45.82,78.57 45.53,78.86 45.53,79.03 45.14,79.42 R9225.1 44.93,79.33 U9203.1 ; 49.17,79.21 49.17,81.35 ; 49.17,79.21 48.11,79.21 46.8,80.52 R9228.1 ; U9203.13 39.25,81.83 38.97,81.55 C9218.1 C9217.1 C9216.1 36.73,81.18 R9223.1 36.73,80.15 R9221.1 R9222.1 36.34,78.22 36.34,76.65 v1(38.91,74.08) ; U9201.1 41.15,98 42.01,97.14 R9215.1 v1(41.43,96.71) ; 49.17,81.35 49.17,81.98 48.92,82.23 R9229.1 ; 49.17,81.35 R9205.1 ; v1(47.64,78.38) 47.21,78.38 R9227.1 ; R9210.1 v1(34.58,98.74) ; C9205.1 35.03,100.77 C9204.1 33.83,101.12 v1(33.83,101.45) ; C9205.1 C9203.1 36.19,100.5 U9201.13 ; C9205.1 35.07,99.97 R9208.1 ; v1(43.63,96.97) R9211.1 R9212.1 R9213.1 43.58,99.42 R9214.1 42.9,100.22 R9204.1
  L6 w0.254: v1(47.64,78.38) 47.64,78.86 47.52,78.99 47.52,84.88 46.48,85.92 46.02,85.92 45.89,85.79 43.2,85.79 42.78,86.21 42.78,87.4 43.86,88.48 43.86,96.74 v1(43.63,96.97)
  BOTTOM w0.254: v1(38.91,74.08) 40.79,74.08 42.11,75.4 43.61,75.4 v1(46,77.79) 46.59,78.38 v1(47.64,78.38) 47.64,77.82 47.25,77.43 CN9202.30 ; v1(33.83,101.45) 33.83,100.24 34.58,99.5 v1(34.58,98.74) 35.61,98.74 36.88,97.47 40.67,97.47 v1(41.43,96.71) 41.69,96.97 v1(43.63,96.97)
P5V0A_USB: length 27.1
  TOP w0.254: v1(267.53,96.43) 267.53,96.58 268.14,97.18 R2618.2 268.78,98.24 C2617.1 C2611.1 ; v1(26.78,32.18) 27,31.97 27,31.61 R2502.2 26.66,31.6 26.47,31.41 C2505.1 24.75,31.41 U2501.5 ; v5(27.2,21.15) 27.07,21.28 C7620.1 ; v5(76.91,30.88) 76.91,31.62 C7619.1 ; U2501.1 26.77,29.15 27.03,28.89 v1(27.03,27.77) ; v1(266.85,41.01) 267.63,41.01 R2628.2 ; 267.36,87.44 C7618.1
  TOP w0.381: 28.09,28.62 C2504.1 ; C2607.1 267.69,47.88 ; 266.35,47.48 C2606.1
  L6 w0.254: v5(266.85,89.14) 266.85,95.75 v1(267.53,96.43) ; v1(26.78,32.18) 26.78,28.02 v1(27.03,27.77)
  BOTTOM w0.381: 77.17,28.56 C2501.1
  vias: v1(230.81,62.39) v1(231.11,60.36) v5(27.2,22.67) v5(27.2,21.91) v5(27.2,20.39) v5(27.2,19.62) v5(77.67,30.88) v5(78.05,19.83) v5(78.81,19.83) v5(229.36,63.15) v5(229.36,62.39) v5(229.36,61.63) v5(230.07,60.87) v5(230.12,63.15) v5(230.12,62.39) v5(230.1,61.63) v5(230.83,61.7) v5(230.83,60.97) v5(264.44,51.32) v5(264.44,50.56) v5(264.44,49.8) v5(265.2,51.32) v5(266.09,89.17) v5(266.11,88.38) v5(266.87,88.38)
P5V0A_USB1:
  vias: v5(15.47,33.19) v5(77.03,35.02) v5(77.8,35.02)
P5V0A_USB_CHARGE: length 3.4
  TOP w0.254: U2501.12 20.17,29.15
  TOP w1.27: 20.17,29.15 TP2500.1
  vias: v1(13.83,33.21) v1(14.59,32.17) v1(14.59,31.56) v1(14.59,30.42) v5(14.73,32.86)
P5V0A_USB_CHARGE_DB: length 1.4
  TOP w0.254: C9200.1 38.07,110.17 v5(38.07,110.4)
  TOP w0.381: 37.09,109.64 C9200.1
  vias: v3(36.14,107.02) v5(37.31,111.16) v5(37.31,110.4) v5(37.69,111.83) v5(38.07,111.16) v5(44.04,87.34) v5(44.04,86.58) v5(44.8,86.6) v5(45.56,86.6)
P5V0A_USB_DB: length 62.1
  TOP w0.254: CN9201.1 32.72,87.2 33.63,88.11 C9207.1 34.77,87.9 C9213.1
  L5 w1.016: 47.66,85.27 47.66,81.75 46.65,80.74 39.98,80.74 36.98,83.74 36.98,86.18 35.96,87.2 32.18,87.2 CN9201.1
  BOTTOM w1.016: 48.03,85.53 48.03,82.67 48.03,82.67 48.03,80.34 47.66,79.96 46.49,79.96 43.35,76.82 v3(40.69,76.82) 39.17,75.3 35.96,75.3 34.95,76.32 34.95,83.5 35.48,84.04 35.48,86.19 34.46,87.2 32.18,87.2 CN9201.1
  vias: v5(46.25,85.36) v5(46.25,84.6)
P5V0DS: length 454.7
  TOP w0.254: v5(203.88,109.49) 203.04,110.33 203.04,112.37 v1(202.18,113.23) ; R435.2 R413.2 270.85,100.48 v1(270.89,100.45)
  TOP w0.508: v5(203.88,109.49) 205.99,109.49 206.63,110.12 213.25,110.12 213.86,109.51 v1(215.49,109.51)
  TOP w1.016: 259.74,9.34 262.29,9.34 263.61,10.66 268.33,10.66 269.35,11.67 269.35,26.46 267.54,28.27 267.09,28.27 266.65,28.72 v1(266.65,29.38)
  L3 w0.254: v1(212.8,72.58) 212.8,73.3 212.32,73.78 212.32,74.31 211.53,75.09 211.29,75.09 211.01,75.37 211.01,76.02 210,77.03 210,77.18 209.95,77.23 v1(209.88,77.23) 209.2,77.23 207.13,79.3 207.13,80.04 206.62,80.55 205.19,80.55 204.36,79.72 203.61,79.72 202.6,80.73 201.13,80.73 195.68,86.17 v5(195.09,86.17)
  L3 w0.508: v1(266.65,29.38) 267.28,30.01 267.28,30.89 270.11,33.72 v1(271.24,33.72) 273.58,36.06 273.58,37.19 274.42,38.03 276.48,40.09 276.48,51.7 274.77,53.41 274.77,53.41 274.24,53.94 273.88,54.29 272.59,55.59 272.59,70.09 272.91,70.41 272.91,71.92 273.2,72.2 273.2,80.61 274.11,81.52 274.11,82.59 274.62,83.1 v1(275.46,83.1)
  L3 w1.016: v5(192.66,6.47) 193.32,5.81 194.18,5.81 196.97,3.01 239.09,3.01 240.31,4.23 240.31,6.59 242.47,8.75 254.94,8.75 255.27,8.42
  L5 w0.254: v1(202.18,113.23) 200.63,111.68 199.47,111.68 199.15,111.37 195.27,111.37 194.99,111.65 193.19,111.65 193.06,111.52 184.53,111.52 184.02,112.03 182.17,112.03 181.32,111.18 178.1,111.18 177.25,112.03 173.61,112.03 171.22,109.64 162.41,109.64 158.07,113.98 147.61,113.98 145.06,111.43 145.06,109.05 144.55,108.55 139.34,108.55 138.83,108.04 138.8,108.04 138.22,107.47 135.74,107.47 135.13,108.07 130.98,108.07 130.37,107.47 127.86,107.47 127.48,107.85 123.14,107.85 121.5,109.49 117.14,109.49 115.97,110.66 109.01,110.66 108.2,109.84 v1(103.04,109.84) ; v5(271.59,94.26) 272.22,94.26 272.48,94.51 272.48,99.02 271.05,100.45 v1(270.89,100.45)
  L5 w0.508: v1(231.67,106.4) 231.67,100.34 234.59,97.42 238.32,97.42 238.44,97.3 241.67,97.3 241.93,97.03 252.75,97.03 256.47,93.32 258.33,93.32 259.62,94.6 271.24,94.6 v5(271.59,94.26)
  L5 w1.016: v5(203.88,109.49) 203.56,109.17 203.56,109.13 203.06,108.62 203.02,108.62 202.54,108.14 198.5,108.14 197.61,107.26 197.61,105.42 198.42,104.61 198.42,100.85 198.7,100.57 198.7,100.57 199.21,100.07 199.21,99.35 198.7,98.85 198.7,98.85 198.42,98.57 198.42,90.53 195.09,87.2 v5(195.09,86.17)
  L6 w0.508: v5(271.59,94.26) 272.45,94.26 273.81,92.9 273.81,84.74 v1(275.46,83.1) ; v1(231.67,106.4) 230.79,106.4 227.68,109.51 222.27,109.51 221.88,109.91 221.86,109.92 217.34,109.92 216.94,109.51 v1(215.49,109.51)
  BOTTOM w0.254: R7303.2 211.92,78.46 210.26,78.46 210.05,78.26 210.05,77.86 209.88,77.68 v1(209.88,77.23) 209.67,77.02 R7313.2 ; v1(212.8,72.58) 212.8,70.8 213.05,70.55 C7400.1 213.48,71.35 213.74,71.61 U7400.8 ; U3150.5 271.57,92.4 271.57,94.24 v5(271.59,94.26) 271.59,94.97 C3151.1 ; CN375.30 264.8,34.94 265.24,34.5 265.45,34.5 265.63,34.32 265.63,31.81 266.95,30.49 266.95,30.09 266.65,29.79 v1(266.65,29.38) ; 199.18,88.66 C7006.1 ; R4417.1 102.77,109.84 v1(103.04,109.84) ; PAD60410.1 v5(192.66,6.47)
  BOTTOM w0.381: 196.94,89.61 R7015.2
  vias: v5(261.01,5.75)
P5V0DS_CCG5: length 38.9
  TOP w0.076: U2403.B3 262.82,24.58 262.82,23.81 v1(262.99,23.64)
  TOP w0.203: U2403.K8 260.07,28.87 259.6,29.33 U2403.L9 259.57,29.33 259.57,29.81 v1(259.43,29.95) ; v1(262.56,28.33) U2403.J2 U2403.J1
  TOP w0.381: U2403.L2 263.07,29.75 267.31,33.99 268.27,33.99 R2469.1 v3(268.76,32.48) 268.8,32.43 268.8,31.61 269.19,31.23 269.19,29.78 268.63,29.22 v1(268.55,29.22)
  L6 w0.381: v1(259.43,29.95) 259.43,28.6 258.81,27.99 258.81,24.58 259.19,24.2 262.43,24.2 v1(262.99,23.64)
  BOTTOM w0.381: v1(259.43,29.95) 259.64,29.74 259.64,28.11 260.23,27.51 261.4,27.51 262.22,28.33 v1(262.56,28.33) 263.4,29.17 265.83,29.17 266.18,28.83 268.16,28.83 v1(268.55,29.22)
P5V0DS_RC: length 3.1
  BOTTOM w0.254: v3(101.52,108.61) R4417.2 102.57,108.61 102.98,109.03 C4413.1 103.85,109.73 U4413.5
P5V0S: length 232.7
  TOP w0.254: C7617.1 v1(31.02,44.9) ; C7616.1 200.1,115.38 v1(199.79,115.69)
  TOP w0.762: 65.91,18.6 61.75,14.44 54.25,14.44 53.44,13.63 53.44,12.15 54.53,11.06 v5(54.61,11.06)
  TOP w1.016: 65.91,18.6 65.91,31 v5(68.96,34.05) ; 217.88,104.05 218.74,103.19 F3000.1
  L3 w0.254: v1(220.11,3.88) 219.96,4.03 216.74,4.03 214.38,6.39 206.14,6.39 205,7.53 192.06,7.53 191.42,8.17 190.17,8.17 177.8,8.17 173.89,4.26 172.77,4.26 172.6,4.26 172.6,4.26 162.22,4.26 161.63,4.84 146.35,4.84 144.81,6.38 144.81,6.87 144.53,7.15 140.23,7.15 139.37,6.29 136,6.29 135.54,6.75 134.02,6.75 133.82,6.54 131.22,6.54 v5(128.98,4.3)
  L5 w0.508: v5(54.61,11.06) 55.85,9.82 61.87,9.82 63.18,11.13 69.09,11.13 69.94,10.28 80.12,10.28 82.54,7.86 99.08,7.86 99.87,8.65 124.63,8.65 v5(128.98,4.3)
  BOTTOM w0.254: R7405.1 201.57,99.38 ; C326.2 131.79,3.43 131.79,2.4 131.34,1.95 129.23,1.95 128.98,2.2 v5(128.98,4.3) R351.2 129.79,4.9 Q300.3 ; v1(39.79,38.28) 39.77,38.26 R4899.2 ; TP4300.1 81.3,34.36 81.12,34.53 CN4300.1 81.12,38.22 81.38,38.47 v1(81.38,38.95)
  BOTTOM w0.381: R7014.2 197.55,94.7
  vias: v1(80.77,38.95) v5(10.33,35.5) v5(11.12,35.47) v5(124.63,116.7) v5(125.47,116.7) v5(200.15,104.18) v5(200.61,109.49) v5(200.91,104.18) v5(201.37,109.49) v5(201.67,104.18) v5(202.43,104.18)
P5V0S_AUDIO_AVDD: length 10.5
  TOP w0.254: C522.1 15.27,36.4 C523.1 13.99,36.4 R512.2
  TOP w0.508: v1(10.54,44.95) 10.54,45 10.31,45.23 D500.2
  L5 w0.254: 13.9,38.89 11.62,41.17 11.62,43.33 10.61,44.34 10.61,44.44 10.59,44.46 10.59,44.92 10.56,44.95 v1(10.54,44.95)
  vias: v1(12.87,37.21) v1(13.48,37.21) v1(14.09,37.21) v1(14.56,44.8) v3(13.79,37.81) v5(13.9,44.87)
P5V0S_EN#: length 3.9
  BOTTOM w0.102: R7009.2 200.94,89.86 200.72,90.07 Q7001.3 200.51,90.07 199.67,89.23 C7006.2 199.67,88.98 v3(199.67,87.9)
P5V0S_EN#_R: length 9.8
  L3 w0.102: v2(200.07,88.46) 199.18,89.35 v1(196.02,89.35)
  BOTTOM w0.102: R7009.1 200.37,88.16 v2(200.07,88.46) ; v1(196.02,89.35) 196.09,89.42 R7015.1 196.09,90.11 ; 196.09,90.11 195.04,90.11 194.94,90.21 Q7005.3 ; 196.09,90.11 196.09,90.57 195.99,90.67 195.54,90.67 195.44,90.77 Q7005.2
P5V0S_HDMI: length 5.4
  BOTTOM w0.254: C3150.1 C3152.1 273.91,94.17 274.37,93.72
  BOTTOM w0.381: 274.85,94.05 274.44,94.45 274.44,95.61 R3150.2 274.06,96.44 v3(273.66,96.84) ; 273.77,92.75 R3151.2
P5V0S_IR_LED: length 9.5
  TOP w0.254: v5(223.13,104.41) 223.13,104.38 222.36,103.61 F3000.2 222.36,103.16 223.37,102.15 v3(223.75,102.15)
  BOTTOM w0.254: v5(223.13,104.41) 223.28,104.25 CN3001.14 ; C2258.1 223.38,103.32 223.44,103.25 CN3001.12 CN3001.13 ; C2257.1 222.19,104.59 v5(222.36,104.41)
P5V0S_KBL:
  vias: v3(142.29,7.51)
P5V0S_NFC: length 2.7
  TOP w0.254: C4350.1 219.98,5.66 220.24,5.92 F4350.2
  BOTTOM w0.254: CN4350.12 v1(222,7)
P5V0S_RC: length 3.2
  BOTTOM w0.254: R7023.2 196.69,95.09 195.98,94.38 C7010.1 195.98,93.53 v3(195.88,93.44) 195.44,92.99 Q7005.5
P5V0S_SM: length 1.3
  BOTTOM w0.254: CN200.10 56.75,10.8 TP850.1
PVBAT: length 185.6
  TOP w0.254: 214.42,93.77 214.42,98.74 213.25,99.91 212.74,99.91 212.5,99.67 C7519.1 212.5,98.62 v1(212.39,98.52) ; 131.24,4.23 129.94,2.94 C7513.1 ; C7608.1 199.72,97.17 199.47,96.92 199.47,96.46 199.62,96.3 ; 122.46,112.72 C7516.1 ; C7517.1 62.13,12.81 62.13,12.82 ; C7609.1 162.75,97.05 ; C7515.1 214.47,79.82 ; 145.31,112.72 C7511.1 ; v1(198.85,85.16) 199.31,85.61 199.69,85.61 ; v5(116.61,110.81) 116.1,110.81 113.15,113.76 106.96,113.76 105.25,112.05 105.25,109.89 106.24,108.9 107.85,108.9 108.66,108.09 108.66,107.63 108.44,107.41 108.44,105.69 R66199.1 ; v1(203.16,115.95) 201.49,114.28 201.49,111.48 200.4,110.39 200.4,110.39 199.63,109.62 199.63,107.35 v1(199.29,107) 199.29,106.9 199.16,106.77 199.16,101.77 199.79,101.14 199.79,99.63 198.4,98.24 198.4,95.95 ; v5(154.77,1.95) 155.17,2.35 C7518.1 ; C7512.1 148.24,4.24 ; C7514.1 187.98,99
  TOP w0.381: C7610.1 103.23,7.89 103.78,8.45
  TOP w0.508: 148.24,4.24 148.23,4.23
  TOP w1.016: v5(55.27,12.82) 83.89,12.82
  TOP w2.032: 126.38,9.09 131.24,4.23 150.72,4.23
  BOTTOM w0.152: R7306.2 198.27,69.53 R7304.2 199.03,70.03 199.03,71.57 199.7,72.25 199.7,74.68 200.39,75.37 200.39,77.84 198.85,79.37 v1(198.85,85.16) ; R7311.2 158.85,87.73 158.21,88.37 R7301.2 157.33,88.84 156.2,89.98 149.91,89.98 149.76,90.13 v1(149.76,98.9)
  BOTTOM w0.254: PAD60110.1 v5(223.8,85.16) ; 56.44,13.58 55.68,12.82 v5(55.27,12.82) ; v1(212.39,98.52) 211.63,99.28 211.63,102.55 211.88,102.81 R1015.2 ; C7564.1 181.65,102.48 ; TP60000.1 146.4,116.47 C7534.1 ; C7566.1 181.32,100.11 ; v1(203.16,115.95) 203.16,116.63 D60099.2 ; C7533.1 146.14,111.26 ; C7535.1 146.04,110.66 ; v1(209.47,91.68) 209.47,90.17 R7040.2 R7039.2 ; Q60034.3 191.37,106.8 197.43,106.8 197.99,107.35 198.93,107.35 v1(199.29,107) ; 181.32,101.55 C7565.1 ; PAD61410.1 v5(174.64,100.67)
  vias: v1(233.52,76.82) v5(96.42,50.33) v5(96.95,50.87) v5(97.48,51.4) v5(98.02,51.93) v5(109.37,81.88) v5(109.37,81.12) v5(109.37,80.35) v5(109.37,79.59) v5(117.37,110.81) v5(117.37,110.05) v5(118.13,110.81) v5(118.13,110.05) v5(118.89,110.81) v5(118.89,110.05) v5(119.66,111.09) v5(149.76,112.33) v5(149.76,111.06) v5(152.61,1.95) v5(158.72,104.33) v5(158.72,103.44) v5(181.76,101.28) v5(181.76,100.4) v5(223.8,84.27) v5(233.5,78.27) v5(233.5,77.51) v5(234.34,77.79) v5(234.34,77.03)
PVBAT_CPU1:
  vias: v3(146.43,109.44)
PVBAT_CPU2:
  vias: v3(115.9,107.58)
PVBAT_CPU3:
  vias: v3(122.68,110.17)
PVBAT_GT: length 1.9
  BOTTOM w0.254: C66314.1 106.16,64.59 U66310.1
  vias: v3(107.57,71.9)
PVBAT_LCM:
  vias: v3(50.66,13.55) v5(20.8,17.02) v5(50.72,12.82)
PVBAT_SA:
  vias: v3(154.63,106.26)
PVCC_PRIM: length 7.7
  TOP w0.254: 170.57,64.99 C4535.2 ; 170.66,66.21 C4536.2
  L3 w0.254: v1(171.5,64.64) v1(172.15,64.64) 172.8,65.29 v1(172.8,65.48)
  L6 w0.254: v1(172.8,65.48) v1(172.8,67.16) 172.8,67.35 v1(173.45,68)
  BOTTOM w0.254: U4555.BV15 U4555.BV16 170.85,67.26 v1(170.85,67.16) 170.85,67.07 U4555.BV18 ; v1(170.85,64.64) 170.85,64.74 U4555.BW20
  vias: v1(170.2,63.8) v1(170.85,63.8) v1(171.5,63.8) v1(173.45,69.68) v5(175.54,86.68) v5(175.54,85.92) v5(176.3,86.68) v5(176.3,85.92)
PVCCGT: length 101.2
  TOP w0.254: 139.23,76.27 C4604.1 ; v1(140.45,77.86) 140.49,77.9 C4606.1 ; 140.41,76.47 C4602.1 ; C4606.1 140.69,78.06 ; C4606.1 C4603.1 ; C4605.1 139.56,77.2
  L3 w0.254: v1(143.33,77.97) 143.21,77.86 v1(140.45,77.86)
  BOTTOM w0.18: v1(143.33,77.97) 143.33,77.94 143.49,77.78 U4555.P2 ; U4555.K2 141.05,77.23 140.85,77.42 140.85,77.48 140.47,77.86 v1(140.45,77.86)
  BOTTOM w0.2: U4555.G15 v1(139.4,67.87) ; U4555.G15 v1(138.75,68.82) ; U4555.G15 v1(138.75,67.87) ; U4555.G15 v1(139.4,68.82) ; U4555.G15 U4555.H15 ; v1(139.4,67.87) U4555.H15 ; v1(139.4,67.87) U4555.G17 ; v1(139.4,67.87) U4555.H17 ; v1(138.75,68.82) 138.88,69 U4555.G14 ; v1(138.75,68.82) 138.62,69 U4555.F14 ; U4555.F14 U4555.G14 ; U4555.F14 U4555.D14 ; U4555.F14 v1(138.1,68.82) ; U4555.G14 U4555.H14 ; U4555.G14 v1(139.4,68.82) ; U4555.D15 v1(137.45,68.82) ; U4555.D15 v1(138.1,68.82) ; U4555.D15 v1(137.45,67.87) ; U4555.D15 U4555.C15 ; v1(137.45,68.82) 137.32,69 U4555.C14 ; v1(137.45,68.82) 137.58,69 U4555.D14 ; v1(137.45,68.82) U4555.C15 ; U4555.B20 136.6,65.71 v1(136.8,65.99) ; U4555.B20 U4555.C20 ; U4555.B20 U4555.A20 135.69,65.71 v1(135.5,65.99) 135.69,66.27 U4555.A18 ; U4555.D14 137.97,69 v1(138.1,68.82) ; U4555.D14 U4555.C14 ; U4555.G20 139.2,65.71 v1(139.4,65.99) ; U4555.G20 138.94,65.71 v1(138.75,65.99) ; U4555.G20 U4555.H20 ; U4555.G20 U4555.F20 ; U4555.F17 U4555.D17 ; U4555.F17 v1(138.75,67.87) ; U4555.F17 U4555.G17 ; U4555.D17 U4555.C17 ; U4555.D17 v1(137.45,67.87) ; v1(140.05,67.87) U4555.J17 U4555.H17 ; v1(140.05,67.87) U4555.H17 ; v1(140.05,67.87) U4555.H15 ; U4555.H17 U4555.G17 ; v1(137.45,70.7) U4555.C12 ; v1(137.45,70.7) U4555.D12 U4555.C12 ; v1(137.45,70.7) U4555.C11 ; v1(137.45,70.7) U4555.D11 U4555.C11 ; U4555.C12 v1(136.8,70.7) ; v1(136.8,70.7) U4555.C11 ; v1(136.8,70.7) U4555.B11 U4555.A11 v1(135.5,70.7) U4555.A12 ; v1(138.75,70.7) U4555.G12 ; v1(138.75,70.7) U4555.F11 U4555.G11 ; v1(138.75,70.7) U4555.G11 ; U4555.G12 U4555.H12 v1(139.4,70.7) ; U4555.G12 v1(139.4,70.7) ; U4555.C18 U4555.D18 137.64,66.27 v1(137.45,65.99) ; U4555.C18 136.99,66.27 v1(136.8,65.99) ; U4555.C18 137.25,66.27 v1(137.45,65.99) ; v1(136.8,65.99) 136.99,65.71 U4555.C20 ; U4555.A15 v1(136.15,67.87) ; U4555.A15 v1(135.5,67.87) U4555.A17 ; U4555.A15 v1(135.5,68.82) 135.63,69 U4555.A14 U4555.B14 ; v1(136.15,67.87) U4555.B17 ; v1(136.15,67.87) U4555.A17 ; U4555.B17 U4555.A17 ; U4555.B17 U4555.C17 ; U4555.B17 v1(136.8,67.87) ; U4555.H14 U4555.J14 ; U4555.H14 v1(139.4,68.82) ; U4555.C17 v1(136.8,67.87) ; U4555.C17 v1(137.45,67.87) ; v1(137.45,67.87) U4555.C15 ; v1(136.8,67.87) U4555.C15 ; U4555.C15 v1(136.8,68.82) ; v1(138.75,67.87) U4555.G17 ; v1(139.4,65.99) 139.59,66.27 U4555.H18 U4555.G18 ; v1(139.4,65.99) 139.2,66.27 U4555.G18 ; v1(139.4,65.99) 139.59,65.71 U4555.H20 ; v1(136.8,68.82) U4555.B14 ; v1(136.8,68.82) 136.93,69 U4555.C14 ; U4555.B14 U4555.C14 ; U4555.H15 v1(139.4,68.82) ; v1(138.75,65.99) 138.94,66.27 U4555.G18 ; v1(138.75,65.99) 138.55,65.71 U4555.F20 ; U4555.F20 U4555.D20 ; U4555.D20 U4555.C20 ; U4555.D20 137.64,65.71 v1(137.45,65.99) ; U4555.H11 v1(139.4,70.7) ; U4555.H11 U4555.G11 ; U4555.H11 U4555.J11 ; v1(139.4,70.7) U4555.G11 ; U4555.C20 137.25,65.71 v1(137.45,65.99) ; U4555.H20 U4555.J20
  BOTTOM w0.254: v1(141.97,73.4) U4555.N7 v1(142.89,73.4) ; v1(146.51,72.83) U4555.W8 v1(145.67,72.76) ; U4555.K11 U4555.J11 ; U4555.F7 v1(138.28,73.4) ; U4555.C3 U4555.B4 U4555.B3 U4555.C2 137,76.45 137,76.27 137.08,76.18 U4555.C3 ; U4555.C3 137.08,75.9 U4555.D4 137.91,75.44 U4555.E4 v1(138.28,74.67) U4555.F5 ; U4555.H7 v1(139.2,73.4) ; U4555.P8 v1(142.89,72.76) ; U4555.H6 v1(139.2,74.03) ; U4555.F8 v1(138.28,72.76) ; 126.9,75.12 126.9,83.06 128.08,84.25 128.08,85.24 128.25,85.4 128.55,85.4 129.13,85.99 129.13,86.02 129.46,86.35 129.92,86.35 130.25,86.02 130.25,85.49 R4528.2 ; U4555.J7 v1(140.12,73.42) ; U4555.H8 v1(139.2,72.76) ; U4555.H5 v1(139.2,74.67) ; U4555.T8 v1(143.82,72.76) ; U4555.F6 v1(138.28,74.03) ; U4555.N8 v1(141.97,72.76) ; U4555.L8 v1(141.05,72.78) ; U4555.U8 v1(144.74,72.76) ; U4555.L7 v1(141.05,73.4) ; U4555.J8 v1(140.12,72.78)
  vias: v1(114.16,68.65) v1(114.16,67.38) v1(114.16,66.11) v1(134.86,67.84) v1(141.52,70.8) v1(141.97,71.4) v1(142.16,65.78) v1(142.45,70.82) v1(142.89,71.4) v1(143.24,64.91) v1(143.34,65.77) v1(143.82,71.4) v1(144.28,70.72) v1(144.42,64.91) v1(144.56,65.78) v1(144.74,71.4) v1(145.2,70.72) v1(145.67,71.4) v1(145.64,64.92) v1(145.8,65.78) v1(146.59,71.4) v5(113.36,64.99) v5(113.35,64.24) v5(114.12,64.99) v5(114.11,64.24) v5(114.88,68.77) v5(114.88,68.01) v5(114.88,67.25) v5(114.88,66.49) v5(114.88,65.72) v5(114.88,64.96) v5(114.87,64.21) v5(115.64,68.79) v5(115.64,68.02) v5(115.64,67.26) v5(115.64,66.5) v5(115.64,65.74) v5(115.64,64.98) v5(115.64,64.21)
PVCCIO: length 43.3
  TOP w0.229: 152.31,66.96 152.6,67.25 153.01,67.25
  TOP w0.254: v1(153.37,63.07) 153.28,63.16 C4525.1 153.28,64.47 152.31,65.43 152.31,66.96 ; v1(126.96,71.17) 126.92,71.21 R4940.2 ; v1(168.27,67.16) 167.44,66.33 C4521.1 ; v1(166.96,53.44) 167.31,53.8 167.31,54.22 167.24,54.29 167.24,55.26 167.21,55.29 R4530.2 ; R4544.1 153.82,70.79 153.52,70.49 153.52,70.37 153.51,70.37 153.51,67.88 153.3,67.66 153.3,67.54 153.01,67.25 ; C4527.1 164.61,62.41 164.91,62.71 v1(164.91,62.74) ; v1(153.52,62.5) 153.23,62.5 C4526.1
  L3 w0.203: 165.45,57.5 165.42,57.5 165.42,60.11 v1(164.98,60.55)
  L3 w0.254: v1(166.96,53.44) 166.96,53.45 167.33,53.82 167.33,54.34 166.71,54.96 166.43,54.96 165.7,55.69 165.7,57.24 165.45,57.5 ; v1(164.06,60.55) 164.06,62.16 164.26,62.37 v1(164.26,62.75) 164.26,63.32 166.74,65.8 166.91,65.8 v1(168.27,67.16)
  L5 w0.254: v1(126.96,71.17) 127.21,71.17 127.86,70.52 127.86,65.62
  BOTTOM w0.2: U4555.BP18 168.27,67.09 v1(168.27,67.16) 168.27,67.23 U4555.BP16
  BOTTOM w0.254: U4555.AM27 U4555.AM25 154.49,62.42 v1(154.35,62.56) 154.35,62.79 v1(154.06,63.08) ; v1(164.91,62.74) 164.97,62.68 U4555.BJ24
  vias: v5(118.13,53.18) v5(118.13,52.42) v5(118.21,51.66) v5(118.21,50.9) v5(118.21,50.13)
PVCCSA: length 0.3
  TOP w0.254: 164.25,71.87 R4522.2
  vias: v1(157.92,91.76) v1(164.14,72.76) v1(164.15,71.4) v1(164.15,70.81) v1(164.78,70.86) v1(165.07,72.76) v1(165.07,71.4) v1(165.78,62.67) v1(165.99,72.76) v1(165.99,71.4) v1(165.99,70.78) v1(166.26,63.01) v5(156.36,92.52) v5(156.36,91.63) v5(156.36,90.74) v5(156.99,92.14) v5(156.99,91.12)
PVCCSFR: length 181.9
  TOP w0.254: v2(167.87,77.76) 167.41,77.3 C4624.2 ; v1(168.25,71.36) 168.4,71.21 168.4,70.2 168.25,70.05 v1(168.25,69.72) ; 163.28,87.98 C4625.2 ; R66101.1 R66100.1 98.04,89.89 98.38,89.55 C66100.1 99.64,89.55 R66104.1 100.58,89.28 100.58,88.49 101.7,87.37 v1(101.7,86.02) ; C4529.1 162.5,88.22 v5(162.52,88.2) ; C325.2 238.4,47.9 R383.1 238.78,47.52 238.78,47.36 239.14,47 v1(239.14,46.84) ; v1(146.7,86.4) 146.7,86.63 146.33,87.01 143.83,87.01 v1(143.22,86.4) ; C4516.2 167.15,75.47
  L3 w0.254: v1(101.7,86.02) 103.4,86.02 104.38,85.04 114.03,85.04 114.58,85.58 118.7,85.58 119.47,84.8 131.59,84.8 132.68,85.89 142.54,85.89 143.05,86.4 v1(143.22,86.4) ; v1(204.75,70.01) 203.05,68.32 186.48,68.32 185.63,69.17 175.39,69.17 175.03,69.52 175.03,70.19 175.53,70.69 v1(175.53,70.74)
  L6 w0.254: 172.62,69.68 174.11,71.18 175.09,71.18 v1(175.53,70.74) ; v1(204.75,70.01) 204.75,69.59 205.61,68.72 206.81,68.72 206.81,68.72 207.18,68.72 207.81,68.09 209.88,68.09 210.05,67.91 211.78,66.18 v1(211.78,65.7) ; v1(239.14,46.84) 237.03,48.95 237.03,49.58 235.62,50.99 235.62,53.78 235.81,53.97 235.81,54.37 234.3,55.87 233.24,55.87 232.86,56.25 225.19,56.25 223.95,57.49 223.95,62.39 221.23,65.11 221.23,66.76 221.61,67.15 v1(221.71,67.15) ; v1(168.25,71.36) v1(168.86,71.36) ; v1(168.25,69.72) 168.74,69.23
  BOTTOM w0.152: U4555.BP2 167.9,77.73 v2(167.87,77.76)
  BOTTOM w0.254: R4605.1 161.41,85.82 160.78,86.45 160.78,86.5 v1(160.75,86.52) 158.91,86.52 157.85,87.58 157.59,87.58 155.9,89.27 149.5,89.27 v1(146.7,86.4) 146.63,85.98 R4604.1 ; v1(168.25,71.36) 167.92,71.01 U4555.BP11 ; R4739.1 205,70.88 204.75,70.63 v1(204.75,70.01) ; v1(221.71,67.15) 221.64,67.22 215.14,67.22 214.89,66.98 212.18,66.98 211.78,66.58 v1(211.78,65.7) ; C7027.1 161.87,88.73 161.9,88.7 162.2,88.7 Q7151.4 ; U4555.BT11 169.22,71 v1(168.86,71.36) 168.86,71.23 U4555.BR11 ; R4595.2 143.73,86.4 v1(143.22,86.4) 143.29,86.47 143.29,87.52 143.63,87.85 R4594.2
PVCCSFR_EN: length 4.6
  BOTTOM w0.102: Q7151.3 161.45,86.62 161.44,86.63 C7025.1 161.12,86.93 160.45,86.93 v3(160.07,87.31) ; R7311.1 159.45,87.31 v3(160.07,87.31) ; Q7307.6 160.07,88.1 v3(160.07,87.31)
PVCCSFR_EN#: length 2
  BOTTOM w0.102: Q7307.2 Q7307.3 158.96,89.34 R7301.1 158.11,89.45 v3(157.5,89.45)
PVCCSFR_PWRGD_R: length 70.4
  TOP w0.102: v1(159.48,85.74) 159.48,87.35 160.19,88.06 160.19,90.04 160.55,90.4 160.55,90.5 160.83,90.79 166.17,90.79 168.69,88.28 175.52,88.28 176.12,88.87 176.12,89.14 178.28,91.3 179.6,91.3 180.34,90.56 v3(180.34,88.84) 180.34,88.24 182.27,86.31 182.27,85.97 182.78,85.47 182.78,85.46 182.88,85.36 192.68,85.36 193.01,85.69 195.29,85.69 195.52,85.92 197.52,85.92 199.09,84.34 200.33,84.34 v1(200.38,84.39)
  BOTTOM w0.102: v1(200.38,84.39) 201.05,83.72 201.05,79.1 201.74,78.4 201.74,75.35 202.91,74.18 203.1,74.18 203.4,73.89 203.9,73.38 204.76,73.38 205.03,73.12 205.49,73.12 206.14,72.47 R4626.1 206.14,70.88 R4739.2 ; v1(159.48,85.74) 160.49,85.74 R4722.2
PVCCSFR_PWRGD_R_R: length 2.1
  BOTTOM w0.102: v3(205.28,72.61) 205.29,72.6 R4626.2 204.83,71.31 Q4751.6
PVCCSTG: length 54.6
  TOP w0.254: v1(163.69,77.68) 163.62,77.6 C4512.2
  TOP w1.016: 158.55,88.21 158.55,83.24 160.7,81.09 163.09,81.09 164.11,80.07
  L6 w0.254: v5(161.01,94.59) 159.85,93.44 156.16,93.44 152.45,89.73 142.56,89.73 v1(141.75,88.92) v1(141.14,88.92)
  BOTTOM w0.254: R4517.1 142.54,88.13 v1(141.75,88.92) ; v1(163.69,78.29) v1(163.69,77.68) 163.69,77.58 163.68,77.57 U4555.BG1 U4555.BG2 U4555.BG3 ; R7013.2 v5(161.01,94.59) ; R4920.2 140.5,84.97 R4807.1 R4891.1 138.72,84.97 R4508.2 R4507.2 136.94,84.97 R4886.1 136,84.97 135.45,85.52 135.45,85.87 135.12,86.2 135.12,86.6 137.44,88.92 v3(138.48,88.92) v1(141.14,88.92)
  BOTTOM w0.381: R7013.2 160.38,94.38 Q7153.4
  vias: v3(159.97,94.43)
PVCCSTG_EN: length 91
  L6 w0.102: v1(159.92,92.72) 162.38,92.72 164.84,95.19 169.2,95.19 171.61,97.6 185.32,97.6 186.69,98.97 192.67,98.97 194.65,96.99 195.03,96.61 198.82,96.61 198.84,96.64 202.23,96.64 v1(202.64,97.04)
  BOTTOM w0.102: Q7000.5 160.68,97.35 160.56,97.46 160,97.46 159.5,96.97 R7006.1 ; v1(202.64,97.04) 202.54,96.94 202.54,88.06 201.49,87.02 199.26,84.78 199.26,79.4 200.69,77.97 200.69,75.25 200,74.56 200,72.19 199.24,71.43 199.24,69.94 198.83,69.53 198.83,69.33 R7304.1 198.17,68.68 198.17,67.66 197.88,67.36 197.36,67.36 196.63,66.63 Q7300.6 ; Q7153.3 160.38,92.26 v1(159.92,92.72) 159.33,93.31 159.33,95.22 158.7,95.85 158.7,96.25 158.98,96.53 159.22,96.53 159.33,96.64 R7006.1 ; R7006.1 159.33,97.3 C7023.1
PVCCSTG_EN#: length 1.3
  BOTTOM w0.102: R7306.1 197.79,67.96 Q7300.3 Q7300.2
PVDDI_EMMC: length 13.5
  TOP w0.076: U3800.C2 202.91,81.55 202.56,81.55 201.84,80.84
  TOP w0.102: C3801.1 193.44,75.81 194.21,76.57 194.46,76.57 194.65,76.76 197.72,76.76 198.63,77.66 198.73,77.66 199.11,78.05 200.13,78.05 201.64,79.56 201.64,80.64 201.84,80.84
VBAT: length 8.4
  TOP w0.102: C60031.1 196.78,98.87 R60013.1 196.03,99.67 C60019.2 195.5,99.89 v3(195.04,100.34) 195.07,100.37 195.07,102.34 193.35,104.06 U60000.31
VCC0V9_LVR_OUT: length 19.3
  TOP w0.203: U2700.H8 v1(260.54,66.25) 260.21,66.57 U2700.H6
  TOP w0.254: C2774.1 C2773.1 271.32,74.77 270.99,74.44 270.99,74.42 v1(270.98,74.36) 270.59,74.8 C2775.1 C2776.1
  L5 w0.254: v1(260.54,66.25) 260.54,66.21 260.99,65.76 262.04,65.76 262.73,66.46 262.73,67.45 263.63,68.35 264.19,68.35 269.24,73.4 269.24,73.93 269.87,74.56 270.79,74.56 270.94,74.41 v1(270.98,74.36)
VCC0V9_SVR: length 31.1
  TOP w0.076: U2700.R8 256.92,65.88 256.36,65.88 U2700.T8 256.31,65.92 v1(255.99,65.59)
  TOP w0.178: U2700.E8 261.5,65.92 261.18,65.6 260.54,65.6 U2700.H9
  TOP w0.203: U2700.T11 v1(255.99,64.95) U2700.T9 v1(256.64,64.95) ; U2700.T11 256.31,64.62 v1(255.99,64.3) ; U2700.T11 v1(256.64,64.95) ; v1(256.64,64.95) U2700.R11 256.96,64.62 v1(257.29,64.95) U2700.N11 U2700.M11 ; U2700.T13 v1(255.99,63) U2700.T15 ; U2700.T13 256.31,63.32 v1(256.64,63.65) U2700.R13 256.96,63.32 v1(257.29,63.65) U2700.N13 257.61,63.32 v1(257.94,63) U2700.M13 v1(258.59,63.65) U2700.L13 v1(259.24,63.65) U2700.J13 259.56,63.32 v1(259.89,63.65) U2700.H13 ; U2700.T13 v1(255.99,63.65) ; v1(260.54,62.35) U2700.H15 v1(260.54,63) U2700.H13 ; U2700.H13 v1(260.54,63.65) ; U2700.R8 257.07,65.81 257.5,65.81 U2700.N8 ; U2700.N6 v1(257.94,66.25) U2700.M8 ; U2700.H9 U2700.H11 U2700.H12 ; U2700.L11 v1(258.59,64.95) ; v1(256.64,62.35) U2700.R16
  TOP w0.254: U2700.M11 258.26,64.62 v1(258.59,64.95) ; U2700.H16 v1(260.54,62.35) ; v1(257.94,66.25) U2700.N8
  BOTTOM w0.254: v1(255.99,63.65) 255.91,63.57 C2784.1 ; 260.81,62.8 C2783.1 261.13,63.12 ; 257.07,65.4 C2757.1 257.39,65.72 ; 259.03,70.67 C2782.1 259.36,71 ; 258.79,62.16 C2761.1 258.47,62.49 ; 258.22,66.23 C2756.1 258.22,66.39 ; 259.15,64.9 C2785.1 ; C2785.1 259.48,65.22 ; C2785.1 258.83,65.22 ; 258.28,62.93 C2767.1 ; C2767.1 258.6,63.25 ; C2767.1 258.6,62.61 ; 259.74,63.12 C2759.1 260.06,62.8 ; C2758.1 257.07,71.57 ; 259.99,71 C2766.1 260.31,70.67 ; 257.13,62.67 C2765.1 257.45,62.99 ; C2760.1 257.07,72.2 ; 255.81,65.25 C2786.1 255.93,65.14
  vias: v3(259.69,80.94) v5(258.95,76.78) v5(259.33,77.42) v5(259.71,76.78) v5(260.19,77.42) v5(260.6,76.77) v5(261.03,77.42) v5(261.37,76.76)
VCC1_R_RST#: length 2.4
  BOTTOM w0.102: CN375.16 257.8,34.45 v3(257.76,34.41) 257.63,34.28 R395.2
VCC1_RST#: length 66.4
  TOP w0.076: U300.K6 v1(239.53,43.89)
  TOP w0.102: v2(248.56,46.17) 248.66,46.27 R325.1 249.61,46.32 250.11,46.82 R342.1
  L3 w0.076: v1(239.53,43.89) 239.53,44.46 240.81,45.75 240.94,45.87 241.55,45.87 241.56,45.86 245.44,45.86
  L3 w0.102: 245.44,45.86 246.65,45.86 247.1,46.32 248.41,46.32 v2(248.56,46.17) 249.18,46.17 249.18,46.17 249.98,45.37 249.98,39.09 248.48,37.58 245.85,37.58 245.26,36.99 245.26,31.19 244.26,30.19 243.91,30.19 241.9,28.19 241.44,28.19 240.9,27.65 v1(240.9,27.5) ; v1(257.85,32.31) 257.47,31.93 257.47,31.39 253.56,27.49 253.56,24.07 v1(253.97,23.66)
  L5 w0.102: v1(253.97,23.66) 253.51,24.12 248.32,24.12 247.54,23.33 245.32,23.33 244.23,24.42 241.91,24.42 241.77,24.56 241.22,24.56 240.98,24.79 240.98,26.34 240.9,26.43 v1(240.9,27.5)
  BOTTOM w0.102: R395.1 257.63,32.53 v1(257.85,32.31)
VCC_HDA: length 24.6
  TOP w0.102: C4530.2 v3(188.34,63.57)
  TOP w0.254: C4530.2 187.63,62.8 187.63,62.8 v1(187.47,62.65)
  L3 w0.254: v1(168.9,64.64) 168.9,64.66 169.35,65.11 170.46,65.11 171.33,65.98 173.62,65.98 173.89,65.7 173.89,65.16 173.57,64.84 173.57,64.45 175.02,63 178.92,63 180.04,61.87 184.67,61.87 184.97,62.17 186.99,62.17 v1(187.47,62.65)
  BOTTOM w0.2: U4555.BT20 v1(168.9,64.64)
VCC_HV_SYS1:
  vias: v3(251.74,40.25)
VCC_HV_SYS_2: length 18
  TOP w0.254: Q68108.3 252.93,85.25 v3(252.93,86.12) 252.93,86.99 254.27,88.33 257.65,88.33 v1(258.42,87.57)
  BOTTOM w0.254: v1(266.85,85.26) 264.54,87.57 v1(258.42,87.57)
VCC_PRIM_PG: length 14.2
  L3 w0.102: v1(176.34,98.3) 176.34,100.61 174.93,102.02 170.47,102.02 v2(168.37,104.12)
  BOTTOM w0.102: R7424.1 R7026.1 v2(168.37,104.12) ; U61400.13 176.7,97.71 176.34,98.07 v1(176.34,98.3)
VCCA_XTAL_1P05: length 4.5
  BOTTOM w0.2: U4555.CP5 180.31,74.86 180.98,74.86 181.01,74.89
  BOTTOM w0.254: v3(182.29,83.68) R4609.2 182.77,84.67 183.06,84.39 C4517.1 ; 181.01,74.89 181.25,74.89 181.27,74.91 182.09,74.91 182.49,75.31
VCCAMPHYPLL_1P05: length 2.7
  TOP w0.254: v1(170.34,77.73) 170.49,77.58 R4583.2 170.49,76.45 C4518.2
  BOTTOM w0.18: v1(170.34,77.73) U4555.BV2
VCCAPLL_1P05_3: length 10.3
  TOP w0.254: C4532.2 166.98,71.81 168.05,70.73 168.05,70.34 167.39,69.67 v1(167.39,68.6) 168.04,69.25 168.44,69.25 168.72,69.53 168.72,70.03 169.08,70.39 169.68,70.39 169.78,70.5 R4585.2
  BOTTOM w0.254: U4555.BR15 168.19,68.8 167.59,68.8 v1(167.39,68.6)
VCCDPHY: length 2.1
  BOTTOM w0.076: U4555.BY23 U4555.CA23 U4555.CA24 U4555.BY24
VCCDPHY_EC: length 9.6
  BOTTOM w0.076: 188,63.03 185.28,63.03 v3(185.19,62.94) 185.19,62.53 184.46,61.81 181.14,61.81 180.89,62.07 U4555.CP25
  BOTTOM w0.102: C4544.1 188.3,63.03 188,63.03
VCCDSW_1P05: length 2.2
  TOP w0.076: v1(169.53,62.99) 168.98,62.45 TP4503.1 169,62.35 C4534.2
  BOTTOM w0.102: U4555.BT24 169.51,62.83 169.51,62.97 v1(169.53,62.99)
VCCIO_LP#: length 3.2
  BOTTOM w0.102: R60520.2 R60522.2 105.14,57.18 v3(105.36,56.96) 105.36,56.73 104.71,56.09 U60500.6
VCCIO_PG: length 152.8
  TOP w0.102: v2(197.81,46.79) 197.81,46.8 R4552.1
  BOTTOM w0.102: U60500.13 103.21,52.68 102.27,51.74 101.51,51.74 101.06,51.29 R7422.2 100.76,51.06 99.16,49.46 88.75,49.46 88.65,49.36 88.65,32.63 88.75,32.53 91.06,32.53 97.25,38.72 102.1,38.72 106.1,34.72 106.7,34.13 155.14,34.13 156.69,35.67 184.53,35.67 193.02,44.16 195.18,44.16 v2(197.81,46.79)
VCCIO_VCCSENSE: length 92.3
  TOP w0.076: 168.08,57.02 168.12,57.06 168.12,57.61 168.04,57.69 168.04,58.14 168.05,58.16 168.05,58.81 168.18,58.94 168.18,59.35 168.58,59.74 168.58,59.86 v1(168.58,59.86)
  TOP w0.13: 168.08,57.02 168.08,56.05 R4530.1 167.94,55.45 167.94,55.05 v3(167.79,54.9) 168.05,54.64 168.05,54.23 169.01,53.27 169.01,51.31 170.62,49.7 170.62,49.47 170.87,49.22 170.88,49.22 170.89,49.21 v1(171.47,49.21)
  L3 w0.097: v1(103.43,52.14) 103.43,51.07 104.71,49.78 106.06,49.78 v1(109.8,46.04)
  BOTTOM w0.076: U4555.BP28 168.31,60.13 168.58,59.86
  BOTTOM w0.089: 168.58,59.86 v1(168.58,59.86)
  BOTTOM w0.13: v1(109.8,46.04) 110.48,46.04 110.9,45.62 111.75,45.62 112.52,44.85 113.21,44.85 116.01,42.05 152.27,42.05 153.53,43.3 165.67,43.3 165.98,42.99 168.01,42.99 171.15,46.13 171.15,46.17 171.26,46.28 171.26,49 v1(171.47,49.21) ; U60500.12 103.71,52.42 v1(103.43,52.14)
VCCIO_VSSSENSE: length 92.3
  TOP w0.076: 168.33,57.01 168.28,57.05 168.28,57.67 168.2,57.76 168.2,58.07 168.21,58.09 168.21,58.72 168.56,59.07 v1(168.56,59.19)
  TOP w0.13: v1(171.04,49.64) 169.26,51.42 169.26,53.32 169.23,53.36 168.83,53.76 v3(168.83,54.14) 168.45,54.14 168.27,54.32 168.27,55.1 168.15,55.22 168.15,55.5 R4531.1 168.33,57.01
  L3 w0.097: v1(111.07,46.04) 107.11,50 104.81,50 104.04,50.78 v1(104.04,52.11)
  BOTTOM w0.076: U4555.BP29 v1(168.56,59.19)
  BOTTOM w0.13: R60526.1 C60509.1 103.21,51.48 103.41,51.48 v1(104.04,52.11) 104.04,52.14 104.21,52.31 U60500.11 ; v1(111.07,46.04) 111.7,46.04 112.62,45.11 113.31,45.11 116.12,42.3 152.16,42.3 153.42,43.56 165.77,43.56 166.08,43.25 167.91,43.25 170.78,46.12 170.81,46.12 170.93,46.24 170.93,46.26 171.04,46.37 v1(171.04,49.64)
VCCPLL_OC: length 1.5
  TOP w0.254: 166.36,54.74 C4515.2
  BOTTOM w0.2: U4555.BM26 U4555.BL27 v1(165.88,60.49)
  vias: v3(165.78,54.44)
VCCPLL_OC_EN: length 307.8
  TOP w0.102: v1(91.26,14.32) 90.76,14.32 90.49,14.58 90.49,21.23 96.06,26.81 96.06,27.39 97.58,28.9 101.32,28.9 102.21,29.79 102.21,31.49 97.53,36.17 97.53,41.58 98.5,42.55 99.8,42.55 100.29,42.07 100.29,41.37 100.24,41.33 U4921.1
  L3 w0.102: v1(85.67,10.25) 86.08,9.84 86.53,9.84 86.69,10.01 86.69,10.24 90.76,14.32 v1(91.26,14.32)
  L5 w0.102: v1(85.67,10.25) 86.08,9.84 86.53,9.84 86.93,10.25 88.51,10.25 89.65,9.11 98.57,9.11 99.35,9.9 125.15,9.9 125.82,9.22 126.11,8.93 131.9,8.93 132.05,9.08 136.88,9.08 136.95,9.01 143.34,9.01 143.75,8.6 150.29,8.6 151.15,9.46 161.39,9.46 162.02,8.83 164.29,8.83 165.66,10.2 167.59,10.2 168.21,10.82 182.5,10.82 184.92,8.4 199.43,8.4 200.8,9.77 214.3,9.77 215.75,8.32 218.32,8.32 219.18,7.46 226.44,7.46 227.48,6.42 227.65,6.42 228.15,6.42 229.45,7.71 230.48,7.71 232.61,9.84 236.44,9.84 236.61,9.84 241.58,14.81 241.58,17.03 236.91,21.7 236.5,21.7 234.77,23.43 234.77,23.99 231.97,26.79 229.88,26.79 229.68,26.99 219.65,26.99 217.23,29.4 213,29.4 196.74,45.66 196.74,47.22 198.59,49.07 198.59,51.41 200.66,53.48 200.66,55.3 200.45,55.51 200.45,56.88 200.73,57.16 200.73,57.96 199.88,58.81 198.2,58.81 195.42,61.59 195.42,62.09 195.78,62.45 196.07,62.45 198.46,64.84 v1(200.71,64.84)
  BOTTOM w0.102: v1(200.71,64.84) 200.97,64.84 201.44,65.31 R7004.2 201.55,65.39 201.12,65.82 R7003.1 200.79,65.94 D4702.3 200.4,67.52 R7002.1
VCCPLL_OC_Q_EN: length 173.5
  TOP w0.102: Q7159.3 167.99,41.8 C7029.1 169.64,42.25 169.64,43.41 169.54,43.51 169.54,46.13 171.9,48.49 v1(171.9,48.78)
  L3 w0.102: v1(109.01,46.04) 109.01,45.41 109.12,45.3 111.38,45.3 111.81,45.74 111.81,46.34 111.5,46.65 111.5,78.95 114.78,82.23 v2(115.08,82.23)
  L6 w0.102: v1(158.47,95.44) 156.77,93.74 156.03,93.74 152.32,90.03 142.43,90.03 141.72,89.32 140.97,89.32 139.98,88.33 128.86,88.33 126.64,86.11 119.56,86.11 118.02,84.57 115.06,84.57 114.5,84.01 114.5,82.44 114.7,82.23 v2(115.08,82.23)
  BOTTOM w0.076: 171.9,45.9 v1(171.9,48.78)
  BOTTOM w0.102: v1(109.01,46.04) 110.95,44.1 112.89,44.1 115.7,41.3 152.58,41.3 153.84,42.55 168.63,42.55 171.9,45.82 171.9,45.9 ; v1(158.47,95.44) 158.47,95.45 158.47,96.96 R7006.2
VCCPLL_OC_XDP_EN: length 294.2
  TOP w0.102: U4921.4 98.94,35.05 102.41,31.58 102.41,29.7 101.41,28.7 97.66,28.7 96.26,27.3 96.26,26.72 90.69,21.15 90.69,15 90.79,14.9 v1(91.26,14.9)
  L3 w0.102: v1(91.26,14.9) 90.89,14.9 86.28,10.29 v1(86.28,10.25)
  L5 w0.102: v1(86.28,10.25) 86.36,10.25 86.56,10.45 88.59,10.45 89.73,9.31 98.48,9.31 99.27,10.1 125.23,10.1 126.2,9.13 131.82,9.13 131.97,9.29 143.35,9.29 143.84,8.8 150.21,8.8 151.07,9.67 161.47,9.67 162.11,9.03 164.21,9.03 165.57,10.4 167.51,10.4 168.12,11.02 182.58,11.02 185,8.6 199.34,8.6 200.72,9.97 214.39,9.97 215.83,8.53 218.4,8.53 219.27,7.66 226.52,7.66 227.56,6.62 228.07,6.62 229.36,7.91 230.39,7.91 232.52,10.05 236.52,10.05 241.37,14.9 241.37,16.95 236.83,21.5 236.42,21.5 234.57,23.34 234.57,23.9 231.99,26.48 230.5,26.48 230.4,26.58 229.8,26.58 229.6,26.79 219.56,26.79 217.15,29.2 212.91,29.2 196.54,45.58 196.54,47.3 198.39,49.16 198.39,51.5 200.45,53.56 200.45,55.22 200.25,55.42 200.25,56.97 200.53,57.25 200.53,57.87 199.8,58.6 198.12,58.6 195.7,61.03 195.22,61.5 195.22,62.18 195.7,62.65 195.98,62.65 196.94,63.61 v1(196.94,64.57)
  BOTTOM w0.102: R7002.2 199.55,67.74 199.31,67.5 198.3,67.5 197.92,67.12 197.41,67.12 197.13,66.84 Q7300.5 197.13,64.75 v1(196.94,64.57)
VCCSA_VCCSENSE: length 96.8
  TOP w0.13: v1(94.31,99.62) 94.44,99.49 R66680.2 ; v1(164.14,73.36) 164.31,73.18 164.32,73.18 164.56,72.94 164.56,72.69 164.57,72.68 R4522.1
  L3 w0.097: v1(164.14,73.36) 163.76,73.36 163.38,73.74 162.9,73.74 161.35,72.19 156.87,72.19 156.66,71.97 147.53,71.97 147.09,72.42 147.09,74.47 146.67,74.89 146.67,78.46 146.71,78.51 146.71,81.67 143.31,85.08 133.01,85.08 131.92,83.99 119.81,83.99 119.81,83.99 119.14,83.99 118.36,84.77 114.91,84.77 114.37,84.23 111.95,84.23 111.43,83.71 103.08,83.71 99.91,86.88 98.39,86.88 95.22,90.04 95.22,98.46 95.22,98.46 95.22,98.64 94.76,99.1 94.41,99.1 94.31,99.2 v1(94.31,99.62)
  BOTTOM w0.13: U4555.BG7 163.87,73.36 v1(164.14,73.36)
VCCSA_VSSSENSE: length 95.8
  TOP w0.13: R4524.1 163.64,72.53 163.67,72.56 163.67,72.9 163.64,72.93 163.64,72.97 163.27,73.35 163.22,73.35 v1(163.22,73.35) ; R66681.2 94.58,98.61 v1(94.31,98.34)
  L3 w0.097: v1(163.22,73.35) 162.77,73.35 161.42,72 156.95,72 156.74,71.79 147.35,71.79 146.9,72.23 146.9,74.39 146.48,74.81 146.48,78.54 146.49,78.55 146.49,81.58 143.22,84.85 133.1,84.85 132.01,83.77 119.9,83.77 119.05,83.77 118.27,84.55 115.01,84.55 114.46,84 112.04,84 111.52,83.49 102.99,83.49 99.82,86.65 98.29,86.65 95,89.95 95,98.55 94.67,98.88 94.41,98.88 94.31,98.78 v1(94.31,98.34)
  BOTTOM w0.13: U4555.BE7 162.99,73.4 163.16,73.4 163.21,73.35 v1(163.22,73.35)
VCCSENSE: length 90.9
  TOP w0.13: R66829.2 98.75,105.88 v1(98.83,105.96) ; R4593.1 155.42,74.79 155.42,74.44 v1(155.83,74.03)
  L3 w0.076: 147.85,75.19 147.89,75.15 147.89,72.54 148.26,72.17 155.09,72.17 155.49,72.57 155.49,73.7 v1(155.83,74.03)
  L3 w0.097: 147.85,75.19 147.8,75.25 147.8,76.09 147.45,76.44 147.45,86.64 144.44,89.65 142.8,89.65 142.48,89.32 140.97,89.32 140.83,89.18 123,89.18 121,91.17 109.95,91.17 109.44,90.66 105.59,90.66 103.86,92.39 100.57,92.39 100.06,92.91 100.06,94.43 98.98,95.51 98.98,105.83 98.85,105.96 v1(98.83,105.96)
  BOTTOM w0.13: v1(155.83,74.03) 155.6,73.92 U4555.AN6
VCCST_PWRGD: length 10.7
  BOTTOM w0.076: U4555.BJ2 164.63,76.68 164.63,76.83 164.49,76.97 164.49,78.67 163.4,79.76 163.4,80.06 163.18,80.29 162.31,80.29 160.83,81.77 160.83,81.97
  BOTTOM w0.102: 160.83,81.97 v3(160.83,82.64) 160.83,84.71 R4722.1
VCCST_PWRGD_XDP: length 3.4
  TOP w0.102: v3(125.5,67.68) 125.35,67.83 R4926.2 124.9,68.96 124.68,68.96 124.48,69.15 CN4920.39
