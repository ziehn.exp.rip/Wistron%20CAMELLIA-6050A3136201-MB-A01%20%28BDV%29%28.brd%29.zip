# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_HD2CA_1_C_DP: length 12.3
  TOP w0.104: R2717.1 arc(267.16,61.34) 267.3,61.28 267.75,61.28 267.75,61.28 267.96,61.28 arc(268.14,61.36) v1(268.22,61.54)
  BOTTOM w0.104: C2741.2 274.9,68.32 D2906.1 arc(274,68.13) 273.67,68.06 273.53,68.06 arc(273.23,68) 272.97,67.83 272.3,67.16 arc(271.93,66.61) 271.8,65.96 271.8,64.76 arc(271.73,64.38) 271.51,64.06 268.79,61.34 arc(268.73,61.29) 268.65,61.28 268.48,61.28 arc(268.3,61.36) v1(268.22,61.54)
TBTA_HD2CA_1_DN: length 14.2
  TOP w0.104: CN2900.B3 283.71,65.31 arc(283.75,65.32) 283.78,65.34 arc(283.81,65.37) 283.85,65.38 284.37,65.38 arc(284.68,65.5) 284.81,65.81 284.81,66.04 arc(284.83,66.18) v1(284.91,66.3)
  BOTTOM w0.104: C2740.1 275.44,67.67 R2608.1 arc(276.08,67.79) 276.19,67.83 276.81,67.83 arc(277.12,67.77) 277.4,67.59 278.67,66.32 arc(278.87,66.18) 279.12,66.13 282.45,66.13 arc(282.59,66.1) 282.7,66.03 283.07,65.66 arc(283.33,65.48) 283.65,65.42 284.5,65.42 arc(284.62,65.44) 284.72,65.51 284.88,65.67 arc(284.91,65.7) 284.91,65.74 v1(284.91,66.3)
TBTA_HD2CA_1_DP: length 14.2
  TOP w0.104: v1(284.18,66.29) 284.3,66.29 arc(284.42,66.27) 284.52,66.2 arc(284.53,66.15) 284.55,66.11 arc(284.59,66.01) 284.6,65.92 284.6,65.81 arc(284.53,65.65) 284.37,65.58 283.77,65.58 arc(283.73,65.57) 283.69,65.55 283.66,65.52 283.56,65.52 arc(283.44,65.54) 283.35,65.61 283.18,65.77 arc(283.14,65.8) 283.08,65.82 CN2900.B2
  BOTTOM w0.104: C2741.1 275.44,68.29 R2607.1 arc(276.11,68.11) 276.3,68.04 276.81,68.04 arc(277.2,67.96) 277.54,67.73 278.81,66.46 arc(278.95,66.37) 279.12,66.33 282.45,66.33 arc(282.67,66.29) 282.85,66.17 283.21,65.81 arc(283.41,65.67) 283.65,65.63 284.5,65.63 arc(284.54,65.63) 284.58,65.66 284.69,65.77 arc(284.7,65.78) 284.71,65.79 284.71,65.89 arc(284.7,65.9) 284.69,65.92 284.41,66.19 arc(284.31,66.26) v1(284.18,66.29)
TBTA_HD2CA_1_R_DN: length 4.2
  TOP w0.076: 265.55,61.07 265.53,61.07 265.51,61.1 265.05,61.1 arc(264.91,61.12) 264.79,61.2 264.44,61.56 arc(264.38,61.59) 264.32,61.61 263.71,61.61 arc(263.69,61.6) 263.66,61.59 arc(263.66,61.58) 263.66,61.58 263.58,61.5 arc(263.51,61.46) 263.44,61.44 263.22,61.44 arc(263.1,61.47) 263,61.53 U2700.B17
  TOP w0.104: 265.55,61.07 266.4,61.07 arc(266.54,61.02) R2720.2
TBTA_HD2CA_1_R_DP: length 4.2
  TOP w0.076: 265.55,61.28 265.53,61.28 265.51,61.26 265.05,61.26 arc(264.97,61.28) 264.91,61.32 264.55,61.68 arc(264.45,61.75) 264.32,61.77 263.69,61.77 263.62,61.84 arc(263.55,61.88) 263.47,61.9 263.26,61.9 arc(263.14,61.83) 263.16,61.69 263.18,61.67 U2700.A17
  TOP w0.104: 265.55,61.28 266.4,61.28 arc(266.54,61.34) R2717.2
TBTA_HPD: length 67.8
  TOP w0.076: 260.32,30.15 260.32,29.08 U2403.K7
  TOP w0.102: v1(256.56,34.81) 256.31,34.81 TP2603.1 256.05,33.53 256.05,32.47 257.08,31.45 259.18,31.45 260.32,30.31 260.32,30.15 ; v1(250.09,77.43) 251.54,77.43 251.71,77.27 R2763.1
  L6 w0.102: v1(250.09,77.43) 249.55,77.97 246.36,77.97 245.11,76.72 245.11,74.78 245.11,74.78 245.11,74.33 245.87,73.57 245.87,70.88 246.25,70.49 246.25,68.01 246.64,67.63 248.25,67.63 248.78,67.1 249.34,67.1 249.58,66.86 249.58,58.39 250.95,57.02 250.95,55.24 254.62,51.58 255.58,51.58 256.77,50.4 256.77,44.97 257.68,44.06 257.68,37.51 256.56,36.4 v1(256.56,34.81)
TBTA_HPD_R: length 10.4
  TOP w0.076: U2700.T2 256.19,68.8 256.19,69.35 254.1,71.44 254.1,72.02
  TOP w0.13: R2764.2 R2763.2 R2732.2 252.96,75.05 v3(253.16,75.05) 253.58,75.05 254.1,74.52 254.1,72.02
TBTA_I2C_INT#: length 65.7
  TOP w0.076: U2700.M4 v1(257.94,67.55) ; v1(262.56,26.66) 262.73,26.83 U2403.F2
  TOP w0.102: v1(254.02,78.22) 253.92,78.32 R2726.2
  L5 w0.102: v1(254.02,78.22) 254.48,77.76 254.48,77.36 254.35,77.23 254.35,71.95 257.94,68.36 v1(257.94,67.55)
  L6 w0.102: v1(257.94,67.55) 258.01,67.55 258.42,67.95 261.67,67.95 261.67,67.95 262.01,67.95 262.01,67.95 262.89,67.95 263.08,67.76 263.08,60.4 261.18,58.51 261.18,57.9 260.87,57.58 260.87,56.59 260.87,51.79 262.86,49.8 262.86,41.92 262.99,41.8 262.99,34.36 262.86,34.23 262.86,30.81 261.95,29.89 261.95,27.28 v1(262.56,26.66)
  BOTTOM w0.102: v1(254.02,78.22) 253.95,78.15 CN2701.8
TBTA_ILIM: length 1.3
  TOP w0.102: R2617.2 263.35,41.52 263.75,41.13 U2602.A3
TBTA_VCC_HV_SYS_EN: length 5.3
  TOP w0.254: R2600.1 257.6,41.34 C2610.1 ; Q2609.4 258.3,39.99 257.92,40.37 C2609.1 257.84,40.51 C2610.1 ; C2610.1 R2601.1 257.78,42.31 Q2601.3
TBTB_AUX_DN: length 77.8
  TOP w0.076: U2403.E11 258.4,26.16 257.85,26.16 257.76,26.25 256.77,26.25 256.75,26.27 256.73,26.27
  TOP w0.104: R2658.2 252.38,29.74 251.17,29.74 v1(250.89,30.01) ; R2424.1 250.08,27.32 250.48,27.32 v1(250.57,27.41) 250.84,27.13 v6(251.48,27.13) 251.95,27.13 252.81,26.27 256.73,26.27 ; v1(258.59,66.9) U2700.L5
  L3 w0.097: v1(250.57,27.41) 250.75,27.23 250.75,27.11 250.98,26.87 251.09,26.87 251.92,27.71 251.92,28.29 252.27,28.64 253.04,28.64 254.03,29.62 254.56,29.62 256.66,31.73 256.66,32.56 263.56,39.45 263.56,48.16 268.12,52.72 268.39,52.72 268.62,52.96 268.62,67.89 267.28,69.23 263.61,69.23 263.33,68.96 260.19,68.96 259.28,68.05 259.28,67.91 258.99,67.62 258.99,67.38 258.59,66.98 v1(258.59,66.9)
  L6 w0.109: v1(250.89,30.01) 250.89,29.91 250.73,29.75 250.36,29.75 250.13,29.52 250.13,28.78 251,27.91 251,27.32 250.9,27.22 250.76,27.22 v1(250.57,27.41)
TBTB_AUX_DP: length 77.8
  TOP w0.076: U2403.D11 258.4,26 257.78,26 257.69,26.09 256.77,26.09 256.75,26.07 256.73,26.07
  TOP w0.104: R2657.2 252.35,29.53 251.14,29.53 v1(250.89,29.28) ; v1(258.59,67.55) 258.62,67.55 258.91,67.84 U2700.L4 ; 256.73,26.07 v6(253.41,26.07) 252.73,26.07 251.87,26.92 250.82,26.92 v1(250.57,26.68) 250.4,26.51 R2423.1
  L3 w0.097: v1(258.59,67.55) 258.64,67.55 259.09,67.99 259.09,68.14 260.11,69.16 263.25,69.16 263.53,69.43 267.36,69.43 268.82,67.97 268.82,52.88 268.47,52.52 268.2,52.52 263.76,48.08 263.76,39.37 256.86,32.48 256.86,31.64 254.64,29.43 254.11,29.43 253.12,28.44 252.36,28.44 252.12,28.2 252.12,27.63 251.17,26.68 v1(250.57,26.68)
  L6 w0.109: v1(250.89,29.28) 250.63,29.54 250.45,29.54 250.34,29.43 250.34,28.87 251.21,28 251.21,27.23 250.99,27.01 250.9,27.01 v1(250.57,26.68)
TBTB_AUX_R_DN: length 5.5
  TOP w0.076: 256.73,29.76 256.75,29.76 256.77,29.74 257.48,29.74 258.05,29.16 258.4,29.16 U2403.L11
  TOP w0.104: 256.73,29.76 v6(255.57,29.76) 255,29.76 254.98,29.73 253.92,29.73 R2658.1
TBTB_AUX_R_DP: length 5.5
  TOP w0.076: 256.73,29.55 256.75,29.55 256.77,29.57 257.41,29.57 257.98,29 258.4,29 U2403.K11
  TOP w0.104: R2657.1 253.94,29.53 255.07,29.53 255.09,29.55 256.73,29.55
TBTB_CA2HD_0_C_DN: length 18.9
  TOP w0.104: v1(268.22,63.98) arc(268.14,63.8) 267.96,63.72 267.75,63.72 267.75,63.72 267.3,63.72 arc(267.16,63.78) R2771.1
  BOTTOM w0.104: C2728.2 276.73,76.51 D2818.1 276.54,76.37 arc(276.43,76.3) 276.3,76.26 arc(276.12,76.21) 275.96,76.1 273.82,73.95 arc(272.84,72.48) 272.49,70.75 272.49,68.62 arc(272.48,68.53) 272.42,68.45 271.19,67.22 arc(271.04,66.99) 270.98,66.72 270.98,65.73 arc(270.94,65.61) 270.86,65.5 269.22,63.86 arc(269.07,63.75) 268.89,63.72 268.48,63.72 arc(268.3,63.8) v1(268.22,63.98)
TBTB_CA2HD_0_C_DP: length 18.9
  TOP w0.104: v1(268.22,63.25) arc(268.14,63.44) 267.96,63.51 267.66,63.51 267.3,63.51 arc(267.16,63.45) R2772.1
  BOTTOM w0.104: C2729.2 276.73,75.9 D2817.1 276.61,75.96 arc(276.48,76.04) 276.33,76.06 arc(276.21,76.02) 276.11,75.95 273.96,73.8 arc(273.03,72.4) 272.7,70.75 272.7,68.62 arc(272.67,68.45) 272.57,68.31 271.34,67.08 arc(271.23,66.91) 271.19,66.72 271.19,65.72 arc(271.13,65.52) 271.01,65.35 269.37,63.71 arc(269.15,63.56) 268.89,63.51 268.48,63.51 arc(268.3,63.44) v1(268.22,63.25)
TBTB_CA2HD_0_DN: length 10.9
  TOP w0.104: CN2800.B10 284.52,77.46 arc(284.74,77.36) 284.83,77.15 284.83,76.83 arc(284.85,76.75) v1(284.9,76.67)
  BOTTOM w0.104: C2728.1 278.01,76.34 278.28,76.34 R2605.1 278.49,76.55 281.97,76.55 arc(282.23,76.6) 282.45,76.74 282.87,77.16 arc(283.13,77.34) 283.45,77.4 284.35,77.4 arc(284.61,77.3) 284.71,77.04 284.71,76.86 arc(284.77,76.73) v1(284.9,76.67)
TBTB_CA2HD_0_DP: length 10.9
  TOP w0.104: v1(284.24,76.67) 284.26,76.67 arc(284.39,76.7) 284.5,76.76 arc(284.53,76.83) 284.56,76.9 arc(284.61,77) 284.63,77.12 284.63,77.15 arc(284.6,77.22) 284.52,77.25 283.57,77.25 arc(283.48,77.23) 283.41,77.18 283.23,77.01 arc(283.17,76.97) 283.11,76.95 CN2800.B11
  BOTTOM w0.104: C2729.1 278.08,76.13 278.21,76.13 R2616.1 arc(278.47,76) 278.53,76.08 278.66,76.21 arc(278.8,76.31) 278.97,76.34 281.97,76.34 arc(282.31,76.41) 282.59,76.6 283.01,77.02 arc(283.21,77.15) 283.45,77.2 284.35,77.2 arc(284.46,77.15) 284.51,77.04 284.51,76.94 arc(284.43,76.75) v1(284.24,76.67)
TBTB_CA2HD_0_R_DN: length 4
  TOP w0.076: 265.55,63.72 265.53,63.72 265.51,63.7 264.6,63.7 arc(264.47,63.67) 264.36,63.6 263.77,63.6 arc(263.77,63.6) 263.77,63.6 263.75,63.6 263.73,63.6 arc(263.68,63.61) 263.63,63.64 arc(263.52,63.71) 263.39,63.74 263.25,63.74 arc(263.1,63.71) 262.98,63.63 U2700.B13
  TOP w0.104: 265.55,63.72 266.4,63.72 arc(266.54,63.78) R2771.2
TBTB_CA2HD_0_R_DP: length 4
  TOP w0.076: U2700.A13 263.26,63.51 arc(263.18,63.48) 263.14,63.39 arc(263.17,63.31) 263.25,63.28 263.44,63.28 arc(263.54,63.3) 263.63,63.36 arc(263.66,63.39) 263.69,63.42 263.7,63.42 arc(263.73,63.43) 263.77,63.43 264.4,63.43 arc(264.43,63.44) 264.45,63.46 264.48,63.48 arc(264.53,63.52) 264.6,63.53 265.51,63.53 265.53,63.51 265.55,63.51
  TOP w0.104: 265.55,63.51 266.4,63.51 arc(266.54,63.45) R2772.2
TBTB_CA2HD_1_C_DN: length 20.6
  TOP w0.104: C2733.2 276.42,81.03 D2816.1 276.39,81 276.21,81.18 arc(276.15,81.22) 276.08,81.23 275.02,81.23 arc(274.98,81.22) 274.94,81.2 274.02,80.27 arc(273.96,80.19) 273.95,80.1 273.95,77.55 arc(273.98,77.36) 274.09,77.2 274.47,76.82 arc(274.58,76.66) 274.62,76.46 274.62,74.03 arc(274.58,73.82) 274.46,73.65 268.13,67.32 arc(267.97,67.21) 267.78,67.17 267.3,67.17 arc(267.16,67.11) R2767.1
TBTB_CA2HD_1_C_DP: length 20.6
  TOP w0.104: C2732.2 276.42,81.64 D2815.1 276.39,81.67 276.22,81.5 arc(276.15,81.45) 276.07,81.44 275.02,81.44 arc(274.9,81.41) 274.8,81.35 273.87,80.42 arc(273.77,80.27) 273.74,80.1 273.74,77.55 arc(273.79,77.28) 273.95,77.06 274.33,76.68 arc(274.39,76.58) 274.42,76.46 274.42,74.03 arc(274.39,73.9) 274.32,73.79 267.99,67.46 arc(267.89,67.4) 267.78,67.38 267.3,67.38 arc(267.16,67.44) R2768.1
TBTB_CA2HD_1_DN: length 3.7
  TOP w0.104: C2733.1 277.54,81.02 R2631.2 arc(278.21,81.17) 278.35,81.23 278.54,81.23 arc(278.57,81.24) 278.59,81.25 arc(278.61,81.26) 278.63,81.27 278.93,81.27 arc(279.04,81.28) 279.15,81.32 arc(279.21,81.34) 279.27,81.35 280.7,81.35 arc(280.9,81.31) CN2800.A10
TBTB_CA2HD_1_DP: length 3.7
  TOP w0.104: C2732.1 278.14,81.64 R2632.2 arc(278.21,81.5) 278.35,81.44 278.48,81.44 278.5,81.45 arc(278.52,81.47) 278.54,81.47 278.93,81.47 arc(278.99,81.48) 279.05,81.5 arc(279.16,81.54) 279.27,81.56 280.7,81.56 arc(280.9,81.6) CN2800.A11
TBTB_CA2HD_1_R_DN: length 4.3
  TOP w0.076: 265.55,67.15 265.53,67.15 265.51,67.17 265.33,67.17 arc(265.26,67.16) 265.2,67.12 264.41,66.33 arc(264.32,66.27) 264.22,66.25 263.82,66.25 263.71,66.14 263.67,66.12 arc(263.66,66.11) 263.65,66.1 arc(263.58,66.06) 263.49,66.04 263.23,66.04 arc(263.14,66.1) 263.16,66.2 arc(263.24,66.25) U2700.A7
  TOP w0.104: 265.55,67.15 266.42,67.15 arc(266.55,67.1) R2767.2
TBTB_CA2HD_1_R_DP: length 4.4
  TOP w0.076: 265.55,67.36 265.53,67.36 265.51,67.34 265.33,67.34 arc(265.2,67.31) 265.09,67.24 264.3,66.45 arc(264.26,66.42) 264.22,66.41 263.72,66.41 263.67,66.46 arc(263.6,66.49) 263.52,66.5 263.13,66.5 arc(263.1,66.49) 263.07,66.48 U2700.B7
  TOP w0.104: 265.55,67.36 266.38,67.36 arc(266.54,67.42) R2768.2
TBTB_CAP: length 1.7
  TOP w0.102: C2601.1 268.86,96.48 268.65,96.27 268.65,96.16 U2600.D4
TBTB_FO: length 79.4
  TOP w0.102: R2634.1 253.72,32.85 v1(254.22,32.85) 254.73,32.85 R2402.1 ; v1(268.14,96.43) 267.9,96.19 U2600.C4
  L5 w0.102: v1(254.22,32.85) 256.16,34.78 256.16,34.98 256.57,35.4 264.31,35.4 v2(265.4,36.49)
  L6 w0.102: v2(265.4,36.49) 266.01,37.1 268.4,37.1 269.93,38.63 269.93,49.21 268.63,50.51 268.63,51.27 269.54,52.18 269.54,69.75 269.05,70.24 269.05,95.53 v1(268.14,96.43)
TBTB_FO_R: length 6.9
  TOP w0.076: 260.07,30.15 U2403.L8
  TOP w0.102: R2402.2 255.65,32.19 v3(255.77,32.07) 256.6,31.24 259.09,31.24 260.07,30.27 260.07,30.15
TBTB_HD2CA_0_C_DN: length 17.2
  TOP w0.104: C2731.2 277.01,76.54 D2814.1 276.39,76.54 276.26,76.41 arc(276.15,76.33) 276.02,76.31 275.69,76.31 arc(275.6,76.29) 275.52,76.23 275.35,76.07 arc(275.26,75.94) 275.23,75.78 275.23,73.62 arc(275.22,73.53) 275.17,73.46 272.64,70.94 arc(272.49,70.7) 272.43,70.42 272.43,69.13 arc(272.41,69.02) 272.34,68.92 268.39,64.97 arc(268.3,64.91) 268.2,64.89 267.35,64.89 arc(267.17,64.96) R2769.1
TBTB_HD2CA_0_C_DP: length 17.2
  TOP w0.104: C2730.2 277.01,75.87 D2813.1 276.39,75.89 276.32,75.96 arc(276.17,76.06) 275.99,76.1 275.69,76.1 arc(275.68,76.1) 275.66,76.09 275.5,75.92 arc(275.45,75.86) 275.44,75.78 275.44,73.62 arc(275.41,73.46) 275.31,73.31 272.79,70.79 arc(272.68,70.62) 272.64,70.42 272.64,69.13 arc(272.6,68.94) 272.49,68.77 268.54,64.82 arc(268.38,64.72) 268.2,64.68 267.25,64.68 arc(267.14,64.64) R2770.1
TBTB_HD2CA_0_DN: length 4.2
  TOP w0.104: CN2800.A3 281.05,77.69 arc(280.89,77.59) 280.7,77.55 280.26,77.55 arc(280.08,77.51) 279.93,77.41 278.91,76.39 arc(278.82,76.33) 278.7,76.31 278.35,76.31 arc(278.21,76.37) R2630.2 277.54,76.51 C2731.1
TBTB_HD2CA_0_DP: length 4.2
  TOP w0.104: C2730.1 277.52,75.91 277.52,75.9 277.54,75.89 R2629.2 arc(278.21,76.04) 278.35,76.1 278.7,76.1 arc(278.9,76.14) 279.06,76.25 280.08,77.27 arc(280.16,77.32) 280.26,77.34 280.73,77.34 arc(280.91,77.31) CN2800.A2
TBTB_HD2CA_0_R_DN: length 4.1
  TOP w0.076: U2700.B11 262.98,64.55 arc(263.1,64.63) 263.25,64.66 263.39,64.66 arc(263.52,64.63) 263.63,64.56 arc(263.68,64.53) 263.73,64.52 264.72,64.52 arc(264.8,64.54) 264.87,64.58 265.12,64.83 arc(265.21,64.9) 265.33,64.92 265.51,64.92 265.53,64.94 265.55,64.94
  TOP w0.104: 265.55,64.94 266.4,64.94 arc(266.54,65) R2769.2
TBTB_HD2CA_0_R_DP: length 4.1
  TOP w0.076: U2700.A11 263.26,64.43 arc(263.18,64.4) 263.14,64.31 arc(263.17,64.23) 263.25,64.2 263.44,64.2 arc(263.54,64.22) 263.63,64.28 arc(263.65,64.31) 263.69,64.33 arc(263.74,64.35) 263.79,64.35 264.72,64.35 arc(264.86,64.38) 264.98,64.46 265.24,64.72 arc(265.28,64.74) 265.33,64.75 265.51,64.75 265.53,64.73 265.55,64.73
  TOP w0.104: 265.55,64.73 266.4,64.73 arc(266.54,64.67) R2770.2
TBTB_HD2CA_1_C_DN: length 22.2
  TOP w0.104: R2765.1 arc(267.16,65.89) 267.3,65.95 267.66,65.95 267.96,65.95 arc(268.14,65.87) v1(268.22,65.69)
  BOTTOM w0.104: C2735.2 277.34,81.03 277.31,81 277.18,81 277.17,81.01 276.83,81.01 276.82,81 D2820.1 276.64,81.06 arc(276.45,81.19) 276.22,81.23 275.39,81.23 arc(275.34,81.22) 275.29,81.19 272.34,78.24 arc(272,77.73) 271.88,77.13 271.88,69.03 arc(271.84,68.81) 271.71,68.62 271.47,68.38 271.23,68.14 arc(271.22,68.12) 271.21,68.11 269.26,66.15 arc(269.03,66) 268.77,65.95 268.48,65.95 arc(268.3,65.87) v1(268.22,65.69)
TBTB_HD2CA_1_C_DP: length 22.2
  TOP w0.104: v1(268.22,66.42) arc(268.14,66.23) 267.96,66.16 267.75,66.16 267.75,66.16 267.3,66.16 arc(267.16,66.22) R2766.1
  BOTTOM w0.104: C2734.2 277.32,81.67 D2819.1 276.57,81.54 arc(276.46,81.46) 276.32,81.44 275.39,81.44 arc(275.26,81.41) 275.14,81.33 272.2,78.39 arc(271.81,77.81) 271.68,77.13 271.68,69.02 arc(271.65,68.88) 271.57,68.77 271.09,68.28 arc(271.06,68.26) 271.05,68.23 269.11,66.3 arc(268.95,66.19) 268.77,66.16 268.48,66.16 arc(268.3,66.23) v1(268.22,66.42)
TBTB_HD2CA_1_DN: length 11
  TOP w0.104: CN2800.B3 283.91,80.95 284.03,81.01 arc(284.06,81.02) 284.08,81.03 284.15,81.05 284.28,81.05 arc(284.49,81.09) 284.66,81.21 284.67,81.22 arc(284.85,81.49) v1(284.91,81.8)
  BOTTOM w0.104: C2735.1 277.99,81.17 278.3,81.17 R2622.1 arc(278.51,81.17) 278.66,81.23 278.92,81.23 arc(279.14,81.27) 279.32,81.4 279.49,81.56 arc(279.55,81.61) 279.63,81.62 282.66,81.62 arc(282.8,81.59) 282.92,81.51 283.24,81.2 arc(283.36,81.11) 283.51,81.08 284.44,81.08 arc(284.66,81.17) 284.76,81.4 284.76,81.65 arc(284.8,81.76) v1(284.91,81.8)
TBTB_HD2CA_1_DP: length 11
  TOP w0.104: v1(284.18,81.8) 284.38,81.8 arc(284.45,81.79) 284.51,81.76 arc(284.52,81.68) 284.55,81.61 arc(284.57,81.56) 284.58,81.51 284.58,81.5 arc(284.56,81.42) 284.52,81.36 arc(284.41,81.28) 284.28,81.26 284.13,81.26 arc(284.11,81.26) 284.09,81.25 284.01,81.22 arc(283.98,81.21) 283.95,81.19 283.87,81.16 283.54,81.16 arc(283.44,81.18) 283.36,81.24 283.29,81.3 283.2,81.4 arc(283.13,81.44) 283.05,81.46 CN2800.B2
  BOTTOM w0.104: C2734.1 278.07,81.41 278.22,81.41 R2624.1 arc(278.51,81.5) 278.66,81.44 278.92,81.44 arc(279.06,81.46) 279.17,81.54 279.34,81.71 arc(279.47,81.8) 279.63,81.83 282.66,81.83 arc(282.88,81.78) 283.06,81.66 283.38,81.34 arc(283.44,81.3) 283.51,81.29 284.44,81.29 arc(284.52,81.32) 284.55,81.4 284.55,81.59 284.51,81.63 284.51,81.7 284.4,81.8 arc(284.29,81.85) v1(284.18,81.8)
TBTB_HD2CA_1_R_DN: length 4.3
  TOP w0.076: 265.55,65.95 265.53,65.95 265.51,65.97 265.3,65.97 arc(265.25,65.96) 265.21,65.94 264.64,65.37 arc(264.53,65.29) 264.41,65.27 263.81,65.27 arc(263.66,65.24) 263.53,65.15 arc(263.49,65.13) 263.45,65.12 263.22,65.12 arc(263.1,65.15) 263,65.21 U2700.B9
  TOP w0.104: 265.55,65.95 266.4,65.95 arc(266.54,65.89) R2765.2
TBTB_HD2CA_1_R_DP: length 4.2
  TOP w0.076: 265.55,66.16 265.53,66.16 265.51,66.14 265.3,66.14 arc(265.19,66.11) 265.09,66.05 264.52,65.48 arc(264.47,65.45) 264.41,65.43 263.79,65.43 arc(263.65,65.46) 263.54,65.54 arc(263.49,65.57) 263.43,65.58 263.25,65.58 arc(263.14,65.51) 263.16,65.38 263.19,65.35 U2700.A9
  TOP w0.104: 265.55,66.16 266.4,66.16 arc(266.54,66.22) 266.6,66.36
TBTB_HPD: length 75.6
  TOP w0.076: U2403.E10 v1(259.55,26.04)
  TOP w0.13: v1(254.35,26.71) 254.68,27.04 254.83,27.04 TP2602.1 ; R2762.1 253.69,76.57 v1(253.54,76.72)
  L3 w0.097: v1(254.35,26.71) 254.35,27.96 257.69,31.3 257.69,31.63 257.91,31.84 257.95,31.84 258.25,32.14 258.25,32.37 262.21,36.32 262.21,36.97 263.36,38.12 264.24,38.12 264.47,38.35 264.47,39.89 264.41,39.96 264.41,41.05 264.59,41.22 264.59,47.61 264.62,47.64 264.78,47.64 265.02,47.88 265.02,48.04 268.9,51.93 269.13,51.93 269.43,52.22 269.43,68.22 267.22,70.43 261.03,70.43 254.74,76.72 v1(253.54,76.72)
  BOTTOM w0.13: v1(254.35,26.71) 255.22,25.85 259.36,25.85 v1(259.55,26.04)
TBTB_HPD_R: length 10
  TOP w0.076: 254.43,72.02 254.43,71.35 256.42,69.35 U2700.T1
  TOP w0.13: 254.43,72.02 254.43,74.56 253.69,75.29 R2762.2 ; v3(254.2,76.9) 254.2,76.29 R2734.2 254.26,76.18 253.77,75.69 R2762.2 ; R2762.2 R2761.2
TBTB_I2C_INT#: length 68
  TOP w0.076: U2403.G2 v1(262.56,27.59) ; v1(257.94,66.9) U2700.M5
  TOP w0.102: R2729.2 253.95,77.64 v1(254.02,77.56)
  L5 w0.102: v1(257.94,66.9) 257.53,67.3 257.53,68.21 254.15,71.59 254.15,77.43 v1(254.02,77.56)
  L6 w0.102: v1(257.94,66.9) 257.9,66.9 257.53,67.27 257.53,67.72 257.77,67.95 258.13,67.95 258.34,68.16 261.59,68.16 261.59,68.16 262.09,68.16 262.09,68.16 262.97,68.16 263.28,67.84 263.28,67.68 263.28,60.32 262,59.03 262,58.17 261.07,57.24 261.07,56.67 261.07,51.88 263.07,49.88 263.07,42 263.19,41.88 263.19,34.27 263.07,34.15 263.07,30.72 262.15,29.8 262.15,27.98 262.54,27.59 v1(262.56,27.59)
  BOTTOM w0.102: v1(254.02,77.56) 254.04,77.56 254.5,78.02 254.5,78.42 254.22,78.7 v3(252.6,78.7) 252.55,78.65 CN2701.7
TBTB_ILIM: length 1.5
  TOP w0.102: U2600.A3 266.75,95.56 266.75,95.56 266.54,95.77 266.54,95.97 R2603.2
TBTB_VCC_HV_SYS_EN: length 17
  TOP w0.102: Q2603.3 261.28,92.93 v3(259.91,92.93)
  TOP w0.254: R2610.1 268.42,85.74 266.93,85.74 265.43,87.24 265.43,88.59 262.15,91.87 Q2603.3
  TOP w0.381: R2610.1 R2635.1 C2602.1 C2608.1 271.75,85.56 Q2600.4
TCP2_HPD: length 13.6
  TOP w0.076: v1(257.29,66.9) U2700.R5
  TOP w0.102: v2(248.31,72.7) 247.83,73.18 R2733.2
  BOTTOM w0.076: 252.09,70.14 254.89,70.14 257.29,67.75 v1(257.29,66.9)
  BOTTOM w0.102: v2(248.31,72.7) 248.76,72.25 250.09,72.25 251.25,71.09 251.25,70.81 251.92,70.14 252.09,70.14
TD_IREF: length 56.7
  TOP w0.102: R4501.1 113.06,72.57 v3(112.54,73.09) 112.52,73.11 112.52,83.07 116.27,86.82 116.99,86.82 124.18,86.82 125.96,88.6 126.13,88.6 126.13,88.61 139.13,88.61 141.09,86.66 141.09,86.61 v1(141.29,86.4)
  BOTTOM w0.076: U4555.W4 146.59,75.35 146.31,75.63 146.31,76.05 146.16,76.4 146.16,76.63 146.22,76.8 146.22,77.84 145.97,78.09 145.75,78.09 145.4,78.45 145.4,80.48
  BOTTOM w0.102: v1(141.29,86.4) 141.29,85.92 141.29,85.92 R4558.2 141.83,85.38 141.83,85.3 141.9,85.23 141.9,85.15 R4514.1 142.16,84.16 143.06,83.26 143.39,83.26 145.13,81.52 145.13,80.75 145.4,80.48
TD_IREF_R: length 4.5
  TOP w0.102: R4501.2 R4502.2 v3(114.79,71.02) 115.16,70.65 CN4920.46
TEST_PWR_GOOD: length 3.2
  TOP w0.076: v1(255.34,66.9) U2700.W5
  BOTTOM w0.076: R2700.2 254,65.95 v3(254.3,65.65) 254.7,65.65 255.34,66.28 v1(255.34,66.9)
THERM#: length 73
  L5 w0.102: v1(117.07,82.67) 116.59,82.19 116.59,77.73 116.33,77.46 116.33,75.05 116.46,74.92 116.46,63.73 116.25,63.53 114.64,63.53 111.93,60.82 111.93,57.65 109.81,55.52 107.01,55.52 104.64,53.15 104.64,51.86 104.57,51.78 104.57,50.56 88.85,34.84 v1(88.16,34.84)
  BOTTOM w0.102: Q4300.5 87.09,32.58 87.19,32.68 87.19,33.61 87.47,33.88 87.47,34.15 v1(88.16,34.84) ; U4411.4 119.7,86.93 120.16,86.47 120.16,84.71 118.83,83.38 R4416.2 117.8,82.67 v1(117.07,82.67)
THERM#_Q: length 2.8
  BOTTOM w0.102: Q4300.3 87.64,32.08 87.51,32.21 87.51,32.95 87.64,33.08 Q4300.1 87.95,33.9 v3(88.14,34.1)
THERM_CLK: length 5.6
  BOTTOM w0.13: U4411.8 124.73,84.98 124.78,85.03 R4413.2 v3(125.12,84.32) 125.66,83.78 127.06,83.78 127.65,84.37 Q4411.1
THERM_DATA: length 4.6
  BOTTOM w0.13: v3(126.21,86.96) 126.65,86.52 Q4411.4 126.28,85.96 126.23,86.01 125.25,86.01 125.12,85.88 R4412.2 124.78,85.66 124.75,85.63 U4411.7
THERM_SCI#: length 163.6
  L5 w0.102: v1(175.22,72.13) 175.84,71.51 179.89,71.51 181.87,73.5 185.31,73.5 185.58,73.23 186.61,73.23 188.09,71.74 191.11,71.74 191.11,71.74 192.13,71.74 193.32,72.93 193.32,82.76 192.35,83.72 192.35,101.11 187.45,106.01 187.28,106.01 186.95,106.34 155.98,106.34 155.81,106.34 154.01,108.14 148.03,108.14 146.58,106.69 146.58,106.53 146.58,106.53 146.58,98.09 145.68,97.19 125.52,97.19 124.8,96.48 124.8,96.48 120.84,92.52 117.52,92.52 116.89,91.89 116.89,87.1 114.2,84.41 114.2,82.26 114.83,81.62 115.67,81.62 v1(115.69,81.65)
  BOTTOM w0.089: U4555.CE9 v1(175.22,72.13)
  BOTTOM w0.102: v1(115.69,81.65) 117.83,81.65 122.46,86.28 U4411.6 124.47,86.28 124.61,86.43 R4414.2
THERMTRIP_CPU#: length 9.8
  BOTTOM w0.076: 161.35,82 161.35,81.48 162.38,80.45 163.25,80.45 163.56,80.13 163.56,79.83 164.66,78.73 164.66,78.6 164.66,77.31 U4555.BJ1
  BOTTOM w0.13: R4605.2 161.34,84.85 v3(161.34,84.14) 161.35,84.13 161.35,82
TLS_ENCRYTION: length 31.7
  TOP w0.076: 186.97,68.82 185.7,68.82 185.69,68.83 182.75,68.83 182.64,68.73 182.47,68.73 181.82,68.08 181.69,68.08 181.69,68.08 177.84,68.08 v2(177.39,67.62)
  TOP w0.102: R4733.2 207.14,68.82 186.97,68.82
  BOTTOM w0.076: U4555.CJ15 v2(177.39,67.62)
TOUCH_INT#: length 308.5
  TOP w0.102: v1(29.82,16.04) 29.82,14.81 29.07,14.06 27.21,14.06 26.43,13.27 v3(26.11,13.27) 26,13.17 R3018.1 25.34,13.17 25.07,12.89 25.07,12.44 24.97,12.35 Q3004.D
  L5 w0.102: v1(185.06,70.13) 185.46,70.52 192.2,70.52 192.55,70.88 192.55,71.31 193.93,72.68 193.93,73.6 194.66,74.33 194.66,77.4 193.93,78.14 193.93,78.38 193.93,82.73 192.76,83.89 192.76,101.55 192.13,102.18 192.13,104.41 189.37,107.18 182.08,107.18 181.83,107.43 155.6,107.43 154.48,108.55 147.57,108.55 145.97,106.95 145.97,101.59 144.93,100.55 128.76,100.55 124.92,104.38 124.09,104.38 123.58,104.38 120.61,107.35 113.86,107.35 111.68,105.17 111.68,103.16 112.49,102.35 112.49,100.76 116.48,96.77 116.48,87.27 113.79,84.58 113.79,80.62 107.06,73.89 107.06,56.75 106.69,56.38 106.69,56.09 104.57,53.96 103.86,53.96 100.96,51.07 99.01,51.07 97.2,49.27 95.04,49.27 84.22,38.44 84.22,36.73 82.57,35.08 82.57,31.73 79.65,28.81 79.65,19.08 79.43,18.86 59.78,18.86 59.68,18.96 52.79,18.96 52.41,18.59 41.83,18.59 39.5,16.26 34.93,16.26 34.7,16.48 31.54,16.48 31.17,16.85 30.5,16.85 30.02,16.38 30.02,16.25 v1(29.82,16.04)
  BOTTOM w0.076: U4555.CM14 178.91,69.34 180.09,69.34 180.3,69.45 180.67,69.45 180.83,69.3 184.23,69.3 v1(185.06,70.13)
TOUCH_PWR_EN: length 322.5
  TOP w0.102: Q3001.5 22.2,18.12 22.44,18.37 22.95,18.37 23.14,18.18 23.47,18.18 R3006.2 25.02,16.63 v3(27.38,16.63) 30.24,16.63 v1(30.83,16.04)
  L5 w0.102: v1(30.83,16.04) 31.04,15.84 33.34,15.84 35.19,13.98 40.78,13.98 41.42,14.62 53.22,14.62 54.79,16.19 60.12,16.19 60.6,16.68 60.8,16.68 61.36,17.23 75.21,17.23 81.59,10.86 88.76,10.86 89.11,10.5 125.4,10.5 125.6,10.3 145.08,10.3 145.18,10.4 161.03,10.4 161.15,10.28 161.5,10.28 162.72,11.5 167.92,11.5 167.99,11.43 182.75,11.43 183.8,10.38 213.82,10.38 214.1,10.66 235.97,10.66 236.14,10.66 240.51,15.03 240.51,16.95 236.57,20.89 236.16,20.89 233.96,23.09 233.96,23.65 233.77,23.84 232.28,23.84 230.15,25.97 229.55,25.97 229.34,26.18 219.34,26.18 219.14,25.97 215.28,25.97 197.5,43.75 182.27,43.75 182.17,43.85 182.17,44.73 181.98,44.92 181.98,47.86 183.35,49.23 183.35,58.77 182.14,59.98 181.39,59.98 180.15,61.22 179.21,61.22 v1(178,62.43)
  BOTTOM w0.076: U4555.CK23 v1(178,62.43)
TOUCH_PWR_EN#: length 9.3
  TOP w0.102: R3030.2 20.11,10.38 19.84,10.38 R3005.2 20.16,11.09 20.16,11.81 20.6,12.25 20.6,12.58 22,13.98 22,14.08 22.04,14.12 22.04,15.02 22.3,15.28 22.3,15.86 ; 22.3,15.86 22.2,15.96 Q3001.2 ; 22.3,15.86 22.59,15.86 22.7,15.96 Q3001.3
TOUCH_PWR_EN#_RC: length 4.9
  TOP w0.102: v1(19.74,13.25) Q3000.1 19.74,11.52 R3005.1
  BOTTOM w0.102: C3000.2 22.6,13.25 v1(19.74,13.25)
TOUCH_Q_INT#: length 16.7
  TOP w0.102: R4930.1 22.89,12.39 Q3004.S 23.33,11.88 23.8,11.41 v1(24.51,11.41)
  BOTTOM w0.102: CN3000.8 20.24,21.25 22.09,19.39 22.09,17.18 22.1,17.18 22.1,17.16 22.94,16.33 23.18,16.33 26.33,13.18 26.33,12.46 25.28,11.41 v1(24.51,11.41)
TOUCH_RST#: length 323.6
  TOP w0.102: v2(20.88,21.63) 21.28,21.22 21.28,20.33 21.82,19.8 R3026.1
  L5 w0.076: 181.4,68.88 178.37,68.88 178.18,69.08 176.51,69.08 v1(176.09,68.66)
  L5 w0.102: 181.4,68.88 182.73,67.55 190.99,67.55 194.28,70.84 195.56,70.84 196.49,71.77 196.49,77.67 195.3,78.87 195.3,83.6 195.3,83.77 194.05,85.01 194.05,106.24 191.28,109.01 178.97,109.01 176.87,111.11 173.99,111.11 171.6,108.73 161.96,108.73 161.45,108.73 157.11,113.07 147.99,113.07 145.97,111.05 145.97,108.67 144.93,107.63 139.72,107.63 139.21,107.13 139.18,107.13 138.6,106.55 135.36,106.55 134.75,107.16 131.36,107.16 130.75,106.55 127.48,106.55 127.1,106.93 123.27,106.93 123.27,106.93 122.76,106.93 121.12,108.57 112.27,108.57 110.05,106.35 109.42,105.72 109.42,102.38 111.1,100.7 111.1,100.42 114.32,97.2 114.32,97.19 115.26,96.25 115.26,87.78 112.57,85.08 112.57,83.35 110.74,81.52 110.74,79.3 105.13,73.69 105.13,59.83 102.49,57.19 100.47,57.19 92.49,49.21 90.4,49.21 82.22,41.04 82.22,38.65 81.35,37.78 81.35,34.76 78.54,31.95 78.54,30.66 77.05,29.17 75.61,29.17 73.91,27.47 72.51,27.47 70.4,25.36 67.22,25.36 64.89,23.03 49.17,23.03 48.54,23.66 46.49,23.66 43.56,20.73 41.76,20.73 41.53,20.49 41.53,19.14 39.25,16.86 35.18,16.86 34.95,17.09 32.58,17.09 30.98,18.68 30.98,20.56 27.44,24.11 25.04,24.11 22.55,21.63 v2(20.88,21.63)
  BOTTOM w0.076: U4555.CG14 v1(176.09,68.66)
  BOTTOM w0.102: v2(20.88,21.63) 20.76,21.75 CN3000.9
TOUCH_SWITCH_EN: length 22.1
  TOP w0.102: D3001.2 23.09,8.28 24.59,9.78 25.85,9.78 26.27,9.36 v3(26.67,9.36) 26.67,10.9 25.59,11.97 R3002.1 24.89,11.97 24.76,11.83 v1(23.99,11.83)
  BOTTOM w0.102: v1(23.99,11.83) 24.55,11.83 25.36,12.65 25.36,13.86 23.1,16.12 22.84,16.12 21.89,17.07 21.89,19.29 20.43,20.75 CN3000.7
TPM_GPIO: length 1.9
  TOP w0.102: U3500.6 224.49,61.03 v3(224.61,61.15) 224.72,61.26 R3503.2
TPM_NCI_GND: length 1.5
  TOP w0.254: U3500.16 222.84,55.62 222.32,55.1 R3505.1
TPM_NCI_VDD: length 1.7
  TOP w0.254: R3504.1 221.88,56.44 222.33,56.89 U3500.14
TPM_PIRQ#: length 58.1
  TOP w0.102: R3517.2 221.72,54.16 v1(221.79,54.09) 222.5,54.09 v3(222.55,54.14) 223.11,54.7 223.73,54.7 223.99,54.96 U3500.18
  L3 w0.076: 180.51,61.02 177.85,61.02 177.81,61.06 177.26,61.06 177.14,61.18 176.49,61.18 176.42,61.11 176.01,61.11 v1(175.63,61.49)
  L3 w0.102: v1(221.79,54.09) 221.61,54.27 217.29,54.27 215.95,55.61 215.95,58.58 215.67,58.87 210.98,58.87 208.91,60.93 208.91,61.27 208.68,61.5 208.68,61.5 208.58,61.6 207.3,61.6 206.52,60.82 199.74,60.82 198.15,62.41 198.13,62.41 198.09,62.45 195.78,62.45 194.99,61.65 194.99,61.11 194.74,60.86 188.44,60.86 187.92,60.34 181.67,60.34 180.99,61.02 180.51,61.02
  BOTTOM w0.076: U4555.CG25 175.9,61.76 v1(175.63,61.49)
TPM_PLT_RST#: length 6.8
  TOP w0.102: v3(218.71,53.53) Q2620.6 219.51,55.31 R3541.2 219.66,55.31 220.01,54.95 220.01,54.83 220.34,54.5 222.22,54.5 222.63,54.9 223.14,54.9 U3500.17
TPM_PLT_RST#_RC: length 4.1
  TOP w0.102: v3(219.61,57.16) C3540.1 218.63,56.45 218.52,56.34 218.21,56.34 ; Q2620.2 218.21,56.34 ; 218.21,56.34 217.48,56.34 217.37,56.45 R3542.1
TPM_PP: length 2.4
  TOP w0.102: v3(223.87,62.37) R3502.1 R3501.2 223.99,60.9 U3500.7
TR_PLT_RST#: length 14
  TOP w0.076: v1(256.64,67.55) U2700.T4
  TOP w0.102: R2706.1 245.9,71.88 U2701.4 246.87,72.24 v1(247.49,71.62)
  BOTTOM w0.102: v1(247.49,71.62) 247.49,71.41 v3(248.12,70.79) 249.42,69.48 254.87,69.48 256.64,67.71 v1(256.64,67.55)
UART0_RXD: length 104.4
  L3 w0.097: v1(184.33,68.45) 184.99,67.79 206.02,67.79 210.84,62.97 217.94,62.97 218.55,62.36 219.78,62.36 221.62,60.52 222.6,60.52 223.89,59.23 224.42,59.23 224.94,58.72 225.5,58.72 228.05,56.17 232.3,56.17 233.22,55.26 233.76,55.26 235.99,55.26 236.39,54.86 236.39,54.54 236.59,54.34 237.45,54.34 237.46,54.34 242.21,54.34 246.45,50.1 248.61,50.1 249.55,49.15 252.06,49.15 253.91,47.31 256.91,47.31 258.22,46 258.22,43.92 256.79,42.49 v1(256.79,42.34)
  BOTTOM w0.076: U4555.CR14 180.54,68.93 183.85,68.93 v1(184.33,68.45)
  BOTTOM w0.13: v1(256.79,42.34) 256.79,42.34 257.84,42.34 v3(257.96,42.23) 258.46,42.23 264.3,36.38 CN375.29 264.3,34.99 R4866.1
UART0_TXD: length 104.5
  L3 w0.097: v1(257.27,41.92) 257.27,42.65 257.27,42.66 258.44,43.83 258.44,46.09 257,47.53 254,47.53 252.16,49.38 249.65,49.38 248.7,50.32 246.55,50.32 242.31,54.56 237.55,54.56 237.55,54.57 237,54.57 236.62,54.95 236.09,55.48 233.66,55.48 233.66,55.48 233.31,55.48 232.39,56.39 228.14,56.39 225.6,58.94 225.03,58.94 224.51,59.46 223.99,59.46 222.7,60.75 221.71,60.75 219.44,63.02 219.28,63.02 219.07,63.24 215.45,63.24 214.91,63.78 210.35,63.78 206.11,68.01 185.36,68.01 v1(184.92,68.45)
  BOTTOM w0.076: U4555.CP14 179.85,69.02 180.34,69.28 180.61,69.28 180.76,69.13 184.25,69.13 v1(184.92,68.45)
  BOTTOM w0.13: R4865.1 263.81,34.85 263.8,34.85 CN375.28 263.8,36.52 259.14,41.19 v3(258.75,41.19) 258.01,41.19 v1(257.27,41.92)
UIM_CD: length 7
  TOP w0.13: v1(211.1,56.99) 210.75,56.65 Q1401.D 210.07,56.39 R1411.2
  BOTTOM w0.13: CN1400.66 215,59.11 213.97,58.08 212.19,58.08 v1(211.1,56.99)
UIM_CD#: length 75.5
  TOP w0.13: R1410.2 209.39,55.94 R1411.1 210.85,55.94 v1(211.1,55.69) 211.61,55.69 Q1401.G ; CN1451.S/W 271.3,47.85 R1452.2 269.26,47.85 D1402.1 268.42,47.81 268.17,47.56 268.17,45.97 267.66,45.46 267.66,44.99 v1(266.85,44.19)
  L3 w0.097: v1(257.76,45.05) 257.45,45.05 256.87,45.63 254.12,45.63 251.05,48.7 249.37,48.7 248.42,49.64 246.27,49.64 243.46,52.45 243.35,52.45 243.29,52.51 241.58,52.51 241.53,52.56 241.35,52.56 241.35,52.56 237,52.56 236.5,53.06 236.17,53.06 235.93,52.82 235.58,52.47 234.89,52.47 234.83,52.47 234.19,51.83 233.28,51.83 232.96,52.15 231.51,52.15 231.04,51.68 220.13,51.68 218.58,53.23 218.01,53.23 216.08,55.16 211.62,55.16 v1(211.1,55.69)
  BOTTOM w0.13: C7504.1 267.45,44.79 v1(266.85,44.19) 265.44,44.19 264.57,45.05 v1(257.76,45.05)
UIM_CLK: length 75.3
  TOP w0.13: CN1451.C3 271.22,43.43 C1453.1 D1405.1 268.79,44.07 267,42.28 v1(266.85,42.28)
  L3 w0.097: v1(208.5,55.79) 211.99,52.31 217.51,52.31 218.2,52.31 219.76,50.74 226.14,50.74 226.24,50.64 234.56,50.64 234.96,50.64 235.28,50.96 243.52,50.96 243.8,50.68 245.77,48.72 248.04,48.72 248.98,47.78 250.6,47.78 253.72,44.66 254.22,44.66 255.3,43.58 256.47,43.58 256.62,43.72 v1(257.03,43.72)
  BOTTOM w0.13: v1(266.85,42.28) 266.67,42.46 266.04,42.46 265.4,43.09 262.07,43.09 v3(261.52,43.65) 257.1,43.65 v1(257.03,43.72) ; v1(208.5,55.79) 208.34,55.96 208.33,55.96 208.08,56.2 208.08,56.21 207.92,56.37 207.92,57.38 207.45,57.85 207.32,57.85 206.51,58.66 206.51,58.7 206.5,58.71 CN1400.32
UIM_DATA: length 75.7
  TOP w0.13: v1(266.85,42.97) 268.17,44.29 268.17,45.25 268.41,45.49 269.16,45.49 R1451.2 269.23,45.54 D1401.1 269.99,45.54 270.17,45.36 270.17,45.22 271.17,44.22 CN1451.C7
  L3 w0.097: v1(208.51,56.38) 208.61,56.38 212.2,52.78 217.31,52.78 218.39,52.78 219.96,51.22 226.34,51.22 226.44,51.12 234.76,51.12 235.08,51.44 243.72,51.44 244.21,50.96 245.97,49.2 248.24,49.2 249.18,48.25 250.79,48.25 251.07,47.97 253.91,45.13 254.1,45.13 254.42,45.14 255.36,44.2 v1(255.97,44.2)
  BOTTOM w0.13: v1(255.97,44.2) 256.1,44.06 256.65,44.06 256.77,44.19 262.58,44.19 v3(262.76,44.01) 263.16,43.6 265.62,43.6 266.25,42.97 v1(266.85,42.97) ; v1(208.51,56.38) 208.93,56.8 208.93,57.16 208.91,57.17 208.91,57.22 207.76,58.36 207.53,58.36 207.12,58.77 207,58.9 CN1400.34
UIM_PWR: length 155.2
  TOP w0.381: v5(272.23,46.39) 272.11,46.27 271.58,46.27 CN1451.C1 271.33,46.02 270.87,46.02 270.42,46.47 270.42,46.97 270.04,47.35 R1452.1 ; v1(268.59,45.07) 268.72,45.07 R1451.1
  TOP w0.635: v5(202.28,74.13) 203.89,74.13 204.05,74.29 205.47,74.29 205.59,74.41 206.87,74.41 207.06,74.6 209.79,74.6 210.57,75.38 210.57,75.96 211.11,76.5 212.13,76.5 212.75,75.89 214.57,75.89 215.83,74.62 217.8,74.62 218.54,75.36 234.16,75.36 240.15,81.36 243.34,81.36 248.44,81.36 250.45,83.37 v3(251.2,83.37) 253.73,83.37 254.74,82.36 v5(255.32,82.36)
  L3 w0.381: v1(268.59,45.07) 270.91,45.07 v5(272.23,46.39)
  L3 w0.635: v5(202.28,74.13) 204.62,74.13 205.15,73.6 205.15,73.35 207.2,71.3 207.2,70.8 207.41,70.59 207.41,69.98 208.08,69.31 v5(209.8,69.31) ; v5(255.32,82.36) 264.59,82.36 266.07,80.88 268.37,80.88 268.77,80.48 268.77,76.76 268.74,76.74 268.74,74.13 268.68,74.07 268.68,70.2 269.96,68.92 270.3,68.58 270.3,52.58 270.3,50.01 272.23,48.07 v5(272.23,46.39)
  L5 w0.635: v5(209.8,69.31) 209.18,68.68 209.18,63.24 208.78,62.84 208.23,62.84 207.5,62.11 v5(207.5,61.12)
  BOTTOM w0.254: 279.37,47.38 C1451.1
  BOTTOM w0.356: CN1400.36 v5(207.5,61.12)
  BOTTOM w0.508: D1451.3 282.13,50.3 281.7,49.86 C1452.1 281.7,48.42 280.66,47.38 278.64,47.38 276.12,49.9 274.44,49.9 272.23,47.69 v5(272.23,46.39)
UIM_RST: length 77.1
  TOP w0.13: v1(266.85,43.58) 266.85,43.59 267.91,44.65 267.91,45.35 268.77,46.21 C1405.1 269.3,46.28 D1404.1 271.02,45.12 CN1451.C2
  L3 w0.097: v1(207.39,56.99) 207.79,57.39 208.73,57.39 211.53,54.6 213.21,54.6 213.31,54.5 213.31,53.1 213.4,53.01 217.22,53.01 218.49,53.01 220.03,51.46 231.13,51.46 231.6,51.93 232.86,51.93 233.19,51.6 234.28,51.6 234.93,52.25 234.98,52.25 234.98,52.25 235.67,52.25 235.68,52.25 236.5,52.25 236.55,52.3 236.59,52.34 241.44,52.34 241.49,52.29 243.19,52.29 243.74,51.74 246.06,49.42 248.33,49.42 249.27,48.48 250.89,48.48 251.3,48.07 251.3,48.07 254.01,45.36 254.51,45.36 255.25,44.62 256.36,44.62 256.44,44.54 v1(256.46,44.54)
  BOTTOM w0.13: v1(256.46,44.54) v3(263.93,44.54) 264.72,44.54 265.33,43.93 265.65,43.93 266.01,43.58 v1(266.85,43.58) ; v1(207.39,56.99) 207.39,57.06 206,58.45 CN1400.30
UNNAMED_7_CSC0402_I34_A: length 2
  TOP w0.102: v3(192.81,96.94) 192.19,97.56 C60020.1 192.19,98.03 R60024.1
UNNAMED_7_CSC0402_I43_A: length 10.7
  TOP w0.102: 191.9,100.83 190.95,100.83 190.45,100.32 C60033.1 190.04,99.3 v3(189.63,99.71) ; 191.9,100.83 192.14,100.59 192.14,98.83 R60024.2 ; 191.9,100.83 191.9,101.85 192.15,102.1 U60000.28
UNNAMED_7_CSC0402_I81_B: length 2.3
  TOP w0.102: v3(185.77,102.25) 186.62,102.25 186.7,102.17 C60006.2 187.1,101.34 187.1,101.34 R60027.1
UNNAMED_7_CSC0402_I84_B: length 7.6
  TOP w0.102: v3(187.83,100.42) 187.95,100.54 R60027.2 188.7,101.28 C60007.2 190.06,101.22 191.75,102.9 U60000.27
UNNAMED_7_CSC0402_I110_B: length 7.8
  TOP w0.102: v3(245.11,96.36) 244.62,96.84 R60032.1
  TOP w0.254: R60032.1 245.51,97.15 C60034.2 R60045.2 246.93,97.15 Q60033.3 251.02,97.68 Q60010.4
UNNAMED_7_CSC0402_I218_A: length 4.2
  TOP w0.102: v3(187.65,111.9) 188.41,112.66 R60039.1
  TOP w0.254: R60039.1 188.49,112.82 C60028.1 ; R60005.1 189.98,112.82 C60028.1 ; C60029.1 189.25,111.9 C60028.1
UNNAMED_7_CSC0402_I218_B: length 5.6
  TOP w0.254: C60030.1 v3(192.44,113.78) 192.08,113.78 R60092.2 191.44,113.25 190.83,113.86 189.44,113.86 C60028.2 189.21,113.63 R60038.1
UNNAMED_7_CSC0603_I200_A: length 7
  TOP w0.102: Q60035.G 182.78,112.64 v3(182.78,111.88)
  TOP w0.254: D60097.2 178.97,111.57 179.8,110.73 179.8,110.73 R60054.1 180.82,110.84 181.55,111.56 C60035.1 181.55,112.2 Q60035.G
UNNAMED_7_CSC0603_I217_A:
  vias: v3(154.66,113.07)
UNNAMED_7_CSC0805_I128_A:
  vias: v3(113.41,112.74)
UNNAMED_7_ISL9241HRTZ_I169_14: length 4.3
  TOP w0.254: U60000.14 191.75,109.64 191.31,110.07 191.31,110.07 v3(191.31,110.96) 191.31,111.81 R60092.1 191.76,111.94 191.94,111.75 R60094.1
UNNAMED_7_ISL9241HRTZ_I169_15: length 3.8
  TOP w0.254: U60000.15 191.35,109.5 190.8,110.05 v3(190.4,110.05) 190.4,110.28 190.65,110.53 190.65,110.93 190.29,111.29 R60005.2
UNNAMED_7_ISL9241HRTZ_I169_19: length 4.6
  TOP w0.102: R60014.2 187.09,106.01 187.62,106.01 188.08,106.48 v3(188.08,106.85) 188.97,107.74 189.58,107.74 189.65,107.66 U60000.19
UNNAMED_7_ISL9241HRTZ_I169_20: length 7.8
  TOP w0.102: U60000.20 189.39,107.26 v3(189.38,107.25) 189.17,107.25 187.7,105.78 185.37,105.78 184.96,106.19 184.81,106.19 R60017.2 184.36,106.64 R60004.2
UNNAMED_7_ISL9241HRTZ_I169_29: length 6.2
  TOP w0.102: U60000.29 192.54,105.11 192.54,100.2 R60011.1
UNNAMED_7_LBSS84LT1G_I27_G: length 10.9
  TOP w0.254: Q60033.1 249.3,96.56 v1(249.3,95.83) ; v1(254.25,99.56) R60050.2 254.25,98.04 R60061.1
  L6 w0.254: v1(249.3,95.83) 249.35,95.9 249.76,96.31 254,96.31 254.25,96.56 v1(254.25,99.56)
UNNAMED_7_LBSS84LT1G_I208_G: length 12.7
  TOP w0.254: R60052.1 185.02,114.07 186.13,112.96 v1(186.13,112.65)
  BOTTOM w0.254: Q60034.1 190.25,108.62 R60051.1 189.92,109.18 189.58,109.18 v3(189.43,109.03) 187.78,109.03 186.48,110.33 186.48,111.09 186.92,111.52 187.06,111.52 187.37,111.83 187.37,112.85 186.98,113.25 186.72,113.25 v1(186.13,112.65)
UNNAMED_7_LBSS84LT1G_I208_S: length 13.7
  TOP w0.254: D60098.1 185.65,112.39 v1(185.65,112.17)
  BOTTOM w0.254: v1(185.65,112.17) 185.65,112.85 186.4,113.6 187.12,113.6 187.73,113 187.73,111.68 187.21,111.16 187.06,111.16 186.84,110.94 186.84,110.48 187.8,109.51 188.16,109.51 v3(188.26,109.62) 188.49,109.39 188.96,109.39 189.19,109.62 190.4,109.62 191.1,108.91 R60051.2 191.1,108.02 Q60034.2
UNNAMED_7_NMOSC_I202_D: length 4.1
  TOP w0.102: R60052.2 184.66,114.93 Q60035.D 183.03,114.85 181.45,113.27 v3(181.28,113.27)
UNNAMED_7_NMOSC_I234_D: length 2
  TOP w0.102: R60061.2 v3(255.02,97.12)
  TOP w0.254: R60061.2 255.24,98.18 Q60032.D
UNNAMED_7_PNPA_I117_B: length 7.3
  BOTTOM w0.102: v3(199.26,115.25) 199.29,115.28 199.96,115.28 200.08,115.4 202.74,115.4 202.87,115.26 203.59,115.26 R68124.1 ; R68124.1 204.58,115.78 Q68120.1 ; R68124.1 R68123.2
UNNAMED_7_PNPA_I117_C: length 5.3
  BOTTOM w0.102: Q68121.1 205.19,111.93 206.17,112.91 206.17,113.35 R68122.1 207.46,115.85 Q68120.3
UNNAMED_7_RSC0402_I114_B: length 5.1
  BOTTOM w0.102: R68124.2 R68120.1 203.66,113.68 203.66,112.98 204.11,112.54 R68125.1 203.66,112.05 v3(203.66,110.35)
UNNAMED_7_RSC0402_I221_B: length 89
  TOP w0.102: R60020.2 200.81,113.4 199.71,114.51 v3(199.11,114.51) 186.06,114.51 184.79,115.78 182.53,115.78 182.21,115.46 182.21,115.09 181.1,113.98 180.98,113.98 180.9,113.91 177.89,113.91 177.28,114.52 121.82,114.52 121.05,113.76 118.07,113.76 116.85,112.54 v1(116.48,112.54)
  BOTTOM w0.102: R60001.4 116.15,112.21 v1(116.48,112.54)
UNNAMED_7_RSC0402_I224_B: length 8.8
  TOP w0.254: R60039.2 187.56,112.64 186.93,112 v1(186.86,112)
  BOTTOM w0.254: R60000.3 185.06,106.36 184.76,106.67 184.76,107.56 v3(184.96,107.76) 184.76,107.96 184.76,108.47 184.96,108.67 184.96,110.3 186.67,112 v1(186.86,112)
UNNAMED_7_RSC0805_I215_A: length 6.6
  BOTTOM w0.102: R60009.1 202.98,111.57 D60031.1 202.98,113.34 202.03,114.29 D60099.3 200.01,114.71 v3(199.26,113.96)
UNNAMED_7_RSC12064PIN_I16_4: length 9.4
  TOP w0.254: R60038.2 186.89,112.96 v1(186.89,112.65)
  BOTTOM w0.254: v1(186.89,112.65) 186.73,112.49 186.65,112.49 184.6,110.44 184.6,109.11 v3(184.4,108.9) 184.4,106.62 184.15,106.36 R60000.4
UNNAMED_7_RSC12064PIN_I238_3: length 85.2
  TOP w0.102: v1(116.48,111.88) 118.16,113.55 121.14,113.55 121.9,114.31 177.2,114.31 177.81,113.7 180.99,113.7 181.07,113.78 181.18,113.78 182.41,115.01 182.41,115.38 182.61,115.58 184.7,115.58 185.98,114.3 196.25,114.3 v3(196.54,114.01) 196.96,114.01 R60018.2
  BOTTOM w0.102: v1(116.48,111.88) 116.81,112.21 R60001.3
UNNAMED_8_LBSS84LT1G_I8_S: length 102.2
  TOP w0.102: Q68102.1 243.26,29.07 243.77,29.07 v1(243.86,28.98) ; v1(262.29,99.59) 261.88,99.59 261.88,99.59 Q68103.2
  L5 w0.102: v1(250.39,81.63) 250.83,81.2 250.83,73.98 250.72,73.88 247.66,73.88 246.26,72.48 246.26,71.56 246.63,71.19 248.56,71.19 249.88,69.87 249.88,45.76 250.39,45.25 250.39,40.94 249.55,40.1 248.94,40.1 247.39,38.55 247.39,35.81 246.76,35.18 246.76,34.33 247.65,33.44 247.65,31.72 246.69,30.77 245.65,30.77 243.94,29.05 v1(243.86,28.98)
  L6 w0.102: v1(264.15,80.06) 264.84,80.76 264.84,90.99 264.19,91.64 264.19,91.82 262.29,93.72 v1(262.29,99.59)
  BOTTOM w0.102: v1(250.39,81.63) 250.39,81.73 251.72,83.06 253.94,83.06 255.12,81.88 262.33,81.88 v1(264.15,80.06)
UNNAMED_8_LBSS84LT1G_I15_S: length 1.9
  TOP w0.102: Q68105.4 253.68,42.82 Q68104.2
UNNAMED_8_LBSS84LT1G_I26_S: length 6.6
  TOP w0.102: Q68107.4 256.55,87.13 Q68108.2 255.26,85.85 v3(253.95,87.16)
UNNAMED_8_PMBT3906YS_I3_2: length 4.8
  TOP w0.102: R68103.1 243.02,26.93 242.33,27.63 242.33,28.38 242.58,28.64 Q68102.2 243.11,28.57 244.88,28.57 Q68102.5
UNNAMED_8_PMBT3906YS_I3_3: length 78.3
  TOP w0.102: Q68102.3 243.22,28.16 v1(243.86,28.16) 243.98,28.04 243.98,27.12 R68102.1 ; Q68100.4 v1(253.9,93.48)
  L5 w0.102: v1(243.86,28.16) 244.57,28.96 244.57,29.38 245.69,30.5 246.71,30.5 248.08,31.87 248.08,33.3 247.19,34.19 247.19,35.32 247.8,35.93 247.8,38.67 249.02,39.89 249.63,39.89 250.59,40.85 250.59,45.33 250.09,45.84 250.09,69.95 249.07,70.97 249.07,71.3 250.98,73.22 251.06,73.22 251.74,73.89 251.74,82.48 252.46,83.2 252.96,83.7 254.67,83.7 v1(255.17,83.2)
  L6 w0.102: v1(255.17,83.2) 253.9,84.47 v1(253.9,93.48)
UNNAMED_8_PMBT3906YS_I3_6: length 9
  TOP w0.102: Q68102.6 244.77,29.29 244.25,29.81 243.37,29.81 242.78,30.39 242.44,30.39 v3(242.41,30.37) 242.13,30.09 242.13,30.04 242.12,30.03 242.12,27.54 242.79,26.88 242.79,25.5 242.42,25.14 R68104.1
UNNAMED_8_PMBT3906YS_I12_2: length 4.1
  TOP w0.102: v3(253.21,46.85) 253.29,46.93 R68106.1 254.33,46.65 Q68105.2 Q68105.5
UNNAMED_8_PMBT3906YS_I12_3: length 3.6
  TOP w0.102: R68100.1 251.96,46.68 v3(251.96,46.52) 252.79,45.69 Q68105.3
UNNAMED_8_PMBT3906YS_I12_6: length 12.7
  TOP w0.102: v1(256.31,36.72) 255.5,36.72 255.17,36.39 v3(255.17,35.93) 253.93,35.93 Q68101.4 ; R68105.1 256.66,43.01 v1(256.66,43.19) 256.16,43.7 255.07,43.7 Q68105.6
  L6 w0.102: v1(256.31,36.72) 256.31,36.97 256.33,37 256.33,42.68 256.66,43.01 v1(256.66,43.19)
UNNAMED_8_PMBT3906YS_I21_2: length 6.6
  TOP w0.102: v3(256.54,85.21) 256.54,85.83 256.84,86.13 258.04,86.13 R68108.1 258.54,86.37 258.64,86.48 Q68107.5 Q68107.2
UNNAMED_8_PMBT3906YS_I21_3: length 1.9
  TOP w0.254: Q68107.3 261.42,88.17 v3(261.39,88.2) R68107.1
UNNAMED_8_PMBT3906YS_I21_6: length 9.6
  TOP w0.102: R68109.1 265.08,81.11 v3(265.66,80.53)
  TOP w0.254: R68109.1 264.82,82.07 Q68106.4 264.17,82.17 262.71,83.64 262.71,84.85 262.3,85.26 260.09,85.26 Q68107.6
UNNAMED_9_CSC0402_I17_A: length 4.6
  TOP w0.102: R68095.1 247.32,26.75 R68096.2 ; R68095.1 C68099.1 ; R68095.1 247.28,26.73 246.47,25.92 245.79,25.92 v3(245.18,26.53)
UNNAMED_9_CSC0402_I39_A: length 12.4
  BOTTOM w0.102: Q68000.2 207.92,116.3 207.92,114.55 208.03,114.45 208.2,114.45 208.7,113.95 C68052.1 ; v3(209.01,111.67) 209.01,111.91 209.59,112.49 209.59,113.5 C68052.1 ; C68052.1 209.43,114.25 211.05,114.25 R68068.2 211.7,114.9 212.84,114.9 213.05,114.69 R68067.1 213.5,115.43 R68009.1
UNNAMED_9_NMOSC_I60_D: length 10.6
  BOTTOM w0.102: v3(214.53,109.81) 215.06,110.34 215.06,110.67 213.86,111.88 213.85,111.88 R68086.2 212.59,111.3 Q68098.D 212.21,110.83 210.09,110.83 209.62,111.3 209.62,112.23 210.24,112.86 Q68051.2
UNNAMED_9_NMOSC_I61_D: length 3.3
  TOP w0.102: v3(181.81,106.62) 181,107.43 Q68054.D 181.85,107.78 182.2,107.43 R68054.1
UNNAMED_9_NPND_I37_B: length 3.8
  BOTTOM w0.102: Q68051.1 210.89,112.41 210.89,113.07 212.32,114.5 R68065.1
UNNAMED_9_RSC0402_I44_A: length 7
  BOTTOM w0.102: v3(215.29,108.78) 215.08,108.98 215.08,109.68 215.26,109.86 215.26,110.76 213.96,112.06 213.96,112.61 R68086.1 213.51,113.83 R68067.2 212.68,113.84 R68065.2
UNNAMED_11_RSCSHORT_I47_B: length 2.3
  BOTTOM w0.102: U60250.11 191.93,99.14 192.48,99.68 v3(192.48,100.01) 192.88,100.41 R60254.2
UNNAMED_13_CSC0402_I17_B: length 5.8
  TOP w0.102: 157.25,9.57 157.09,9.42 R60349.1 v3(155.52,9.42) ; 157.25,9.57 v1(157.25,8.45) 157.25,8.32 157.42,8.15 C60309.2 C60351.2 ; 157.25,9.57 C60350.1
  BOTTOM w0.102: v1(157.25,8.45) 157.25,8.32 157.51,8.05 U60300.4
UNNAMED_13_RSC0402_I35_A: length 1.1
  BOTTOM w0.102: R60301.1 157.96,2.86 R60302.2
UNNAMED_15_CSC0402_I62_A: length 2.9
  BOTTOM w0.254: U60600.12 109.6,102.47 C60630.1 110.06,102.58 110.66,102.58 111.23,103.15 R60630.2
UNNAMED_17_CSC0402_I46_A: length 4.2
  BOTTOM w0.254: U60900.12 169.21,99.97 C60930.1 169.5,99.55 170.2,98.85 R60930.2
UNNAMED_18_CSC0402_I59_B: length 5
  BOTTOM w0.13: U60500.10 104.71,52.17 R60506.1 R60505.1 103.28,49.85 v3(102.71,49.85) C60509.2
UNNAMED_19_CSC0402_I55_A: length 4.4
  BOTTOM w0.102: R61428.1 174.61,97.94 R61401.1 175.46,97.67 C61409.1 175.35,96.71 v3(175.76,96.71) 175.77,96.71 U61400.11
UNNAMED_19_CSC0402_I55_B: length 4.8
  BOTTOM w0.102: v3(174.09,96.28) 174.09,97.34 R61406.1 ; v3(174.09,96.28) 173.47,96.28 R61405.1 ; v3(174.09,96.28) 174.92,96.28 C61409.2 175.01,96.2 176.87,96.2 U61400.10
UNNAMED_19_NB692GD_I42_12: length 4.6
  BOTTOM w0.102: R61400.2 174.57,99.13 v3(174.62,99.07) 174.91,98.79 R61401.2 175.66,98.79 175.93,98.52 175.93,97.31 176.03,97.21 U61400.12
UNNAMED_20_CSC0402_I154_A: length 5.2
  TOP w0.102: U66000.46 103.65,99.5 103.74,99.59 104.24,99.59 104.25,99.58 104.58,99.58 104.59,99.59 C66197.1 R66197.2 107.04,100.43 R66195.2 v3(107.04,101.36)
UNNAMED_20_MP2949GQKLFZ_I283__1: length 3.7
  TOP w0.102: R66108.1 101.37,93.1 v1(101.37,93.51) 101.37,93.94 101.17,94.14 U66000.33
  BOTTOM w0.102: R66004.2 101.37,93.07 v1(101.37,93.51)
UNNAMED_20_MP2949GQKLFZ_I283__2: length 2.1
  TOP w0.102: R66103.2 98.19,93.75 99.15,94.71 99.15,94.91 99.17,94.93 U66000.28
UNNAMED_20_MP2949GQKLFZ_I283_SC: length 2.8
  TOP w0.102: R66102.2 97.3,93.87 97.66,94.22 98.34,94.22 98.77,94.65 U66000.27
UNNAMED_20_MP2949GQKLFZ_I283_SD: length 3.4
  TOP w0.102: U66000.32 100.77,93.57 v2(100.71,93.51) 100.71,92.87 R66109.1
  BOTTOM w0.102: R66003.2 100.83,93.34 v2(100.71,93.51)
UNNAMED_20_MP2949GQKLFZ_I283_VR: length 4.6
  TOP w0.102: v3(100.81,91.05) 100.42,91.43 100.42,92.24 R66001.2 99.97,93.68 100.37,94.08 U66000.31
UNNAMED_32_CN304G_I195_1: length 1.8
  BOTTOM w0.102: TP375.1 249.81,34.86 250.3,35.36 CN375.1
UNNAMED_40_LBSS84LT1G_I1105_S: length 9
  TOP w0.102: v3(251.02,52.39) 251.8,51.62 Q4754.2 251.43,47.52 251.43,45.76 251.99,45.2 251.99,44.75 Q4755.3
UNNAMED_40_LBSS84LT1G_I1108_S: length 1.9
  TOP w0.102: Q4755.2 250.17,43.05 R4861.2 250.17,41.87 v3(250.42,41.62)
UNNAMED_40_NMOSC_I1131_G: length 1
  BOTTOM w0.102: R4899.1 39.27,36.6 Q4756.G
UNNAMED_45_J92043_I167_VSS300: length 14.9
  TOP w0.102: v1(180.26,78.58) 180.26,79.3 182.06,81.11 182.06,86.22 179.83,88.46 179.83,90.34 TP4514.1
  BOTTOM w0.254: U4555.CP1 179.99,77.83 v1(180.26,78.58)
UNNAMED_45_J92043_I167_VSS341: length 6.9
  TOP w0.102: TP4512.1 140.09,56.69 138.18,56.69 138.11,56.62 135.7,56.62 v1(134.81,57.51)
  BOTTOM w0.254: U4555.A32 134.93,57.62 v1(134.81,57.51)
UNNAMED_45_J92043_I167_VSS342: length 4.4
  BOTTOM w0.254: TP4509.1 182.73,53.91 180.85,55.79 180.85,55.9 U4555.CR34
UNNAMED_45_J92043_I167_VSS388: length 5.6
  TOP w0.102: TP4513.1 138.06,55.69 137.87,55.5 135.69,55.5 v1(135.1,54.92)
  BOTTOM w0.254: v1(135.1,54.92) 135.18,54.99 U4555.A36
UNNAMED_45_J92043_I167_VSS399: length 16.2
  TOP w0.102: TP4510.1 178.46,90.64 178.46,89.54 181.86,86.14 181.86,81.19 179.41,78.74 v1(179.41,77.9)
  BOTTOM w0.254: U4555.CN1 179.34,77.83 v1(179.41,77.9)
UNNAMED_45_J92043_I167_VSS413: length 4.3
  BOTTOM w0.254: U4555.CR36 180.73,54.72 181.44,54.72 183.54,52.61 TP4515.1
UNNAMED_45_J92043_I167_VSS433: length 14.6
  BOTTOM w0.254: TP4511.1 129.69,80.2 132.32,77.57 136.91,77.57 137.32,77.16 U4555.D1
UNNAMED_45_J92043_I168_VSS283: length 13.4
  BOTTOM w0.254: TP4516.1 128.85,80.53 132.22,77.16 U4555.C1
UNNAMED_60_APCI0020P001A01_I842: length 7.1
  TOP w0.102: v1(248.76,16.55) 247.29,15.08 TP1952.1
  BOTTOM w0.102: v1(248.76,16.55) 249.86,16.55 250.4,17.09 CN1951.10
UNNAMED_65_NMOS2D2SDIODE_I879_3: length 1.6
  TOP w0.102: Q2620.3 217.62,55.95 R3542.2 R3543.1
UNNAMED_66_NMOSC_I813_D: length 1.7
  BOTTOM w0.102: Q1300.D R1302.2 74.36,38.63 v3(74.11,38.88)
UNNAMED_73_SDINADF432GH_I326_E5: length 1.3
  TOP w0.076: U3800.E5 204.17,80.81 v1(204.16,80.81)
  BOTTOM w0.102: v1(204.16,80.81) 203.73,81.24 TP3800.1
UNNAMED_76_CSC0201_I56_A: length 0.6
  TOP w0.13: R7600.2 C7624.1
UNNAMED_84_CM32181E_I117_4: length 4.7
  TOP w0.102: v1(74.44,78.96) R9304.2 75.05,78.45 75.07,78.45 R9305.2 ; U9302.4 v1(74.14,81.2)
  L3 w0.102: v1(74.44,78.96) 73.72,79.68 73.72,80.78 v1(74.14,81.2)
UNNAMED_85_CM32181E_I114_4: length 4.7
  TOP w0.102: U9300.4 79.8,109.77 78.85,108.82 77.81,108.82 77.71,108.72 77.71,108.2 77.39,107.87 R9300.2 R9301.2
UNNAMED_85_CM32181E_I115_4: length 3.4
  TOP w0.102: U9301.4 79.8,105.7 79,104.9 78.09,104.9 78.08,104.91 R9302.2 R9303.2
