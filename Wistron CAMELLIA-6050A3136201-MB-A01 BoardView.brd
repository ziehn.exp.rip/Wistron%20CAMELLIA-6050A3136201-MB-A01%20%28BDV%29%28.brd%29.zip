# Allegro board Wistron CAMELLIA-6050A3136201-MB-A01 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VRA1V8A_FB: length 5.2
  BOTTOM w0.254: U60600.11 109.19,102.7 109.19,103.61 R60600.2 109.41,104.38 109.36,104.32 108.91,104.32 C60620.2 108.74,104.49 108.73,104.82 108.73,105.6 R60601.1
VRA1V8A_FF: length 1.6
  BOTTOM w0.254: C60620.1 v3(109.98,105.58) 110.03,105.58 R60620.1
VRA1V8A_ILMT: length 6.6
  BOTTOM w0.254: v3(108.81,108.04) 108.66,107.89 108.66,107.63 108.18,107.14 108.18,107.08 108.1,107 108.1,106.4 R60605.1 107.77,105.91 107.77,105.2 108.02,104.94 108.02,104.48 108.81,103.7 108.81,102.96 U60600.10
VRA1V8A_SNB: length 2
  BOTTOM w0.254: R60616.2 C60616.1 109.13,92.63 v3(109.08,92.63)
VRA1V8A_VOUT: length 17.3
  L3 w0.254: v1(110.46,103.06) 110.51,103.06 112.52,101.06 112.52,99.91 v2(119.17,93.26)
  BOTTOM w0.254: v1(110.46,103.06) 110.46,103.68 R60600.1 111.19,104.41 R60620.2 ; 117.61,91.74 117.66,91.74 v2(119.17,93.26)
VRA2V5_FB: length 4.4
  BOTTOM w0.254: U60400.6 194.42,6.22 194.05,6.59 R60401.1 ; v3(192.66,7.51) 192.9,7.26 R60401.1 ; R60401.1 193.5,7.26 C60405.2 R60400.2
VRA3V3A_AGND: length 5.4
  BOTTOM w0.102: R60110.1 223.14,81.6 v3(223.08,81.55) 222.98,81.45 R60199.1 224.66,80.73 C60109.1 225.34,80.1 U60100.10
VRA3V3A_SNB: length 2.1
  BOTTOM w0.254: v3(232.41,76.77) 232.24,76.61 232.24,76.61 R60116.2 231.39,75.78 C60116.1
VRA3V3A_VCC: length 2.7
  BOTTOM w0.254: U60100.9 224.99,79.6 C60109.2 223.89,79.91 v3(223.85,79.95)
VRA3V3DS_VOUT: length 29.2
  L6 w0.254: v2(235.81,66.51) 234.92,65.88 231.78,69.01 231.78,69.95 229.42,72.31 229.42,79.55 230.02,80.15 v1(230.1,80.15)
  BOTTOM w0.254: v2(235.81,66.51) 235.55,66.51 235.23,66.83 231.25,66.83 230.11,65.7 229.23,65.7 227.91,64.38 PAD60100.3 ; U60100.5 230.04,80.1 v1(230.1,80.15) 230.35,80.15 C60190.1
VRA5V0_EN1: length 12.7
  L5 w0.102: v1(233.12,73.47) 234.67,75.02 236.03,75.02 237.07,76.06 v1(240.76,76.06)
  BOTTOM w0.102: R60205.1 240.94,76.24 v1(240.76,76.06) 240.76,75.28 240.53,75.05 U60200.6 ; R60202.2 R60204.2 232.69,73.05 v1(233.12,73.47)
VRA5V0_EN2: length 1.2
  BOTTOM w0.102: R60205.2 240.09,75.56 U60200.5
VRA5V0_FF: length 3.4
  BOTTOM w0.254: R60200.1 242.64,76.15 C60200.2 241.38,75.77 R60201.2 240.65,74.6 U60200.7
VRA5V0_FF_R: length 0.8
  BOTTOM w0.254: C60200.1 241.76,77 R60218.1
VRA5V0_LDO: length 1.3
  BOTTOM w0.254: U60200.9 241.23,73.7 C60217.1
VRA5V0_SNB: length 1.2
  BOTTOM w0.254: C60216.1 234.47,70.33 R60216.2
VRA5V0_VOUT: length 34.1
  TOP w0.254: v1(242.81,74.69) 242.74,74.69 242.33,75.1 242.33,75.5 243.28,76.45 v1(243.28,76.84)
  L5 w0.254: v1(232.35,60.86) 232.05,61.16 232.05,65.7 232.33,65.98 233.5,65.98 234.36,65.11 242.74,65.11 244.83,67.2 244.83,69.23 243.25,70.8 243.25,74.25 v1(242.81,74.69)
  BOTTOM w0.254: v1(243.28,76.84) 243.13,76.99 R60200.2 242.61,77.03 R60218.2 ; R60217.2 242.56,74.44 v1(242.81,74.69) ; PAD60200.3 232,61.22 v1(232.35,60.86)
VRA5V0_VOUT1: length 1.3
  BOTTOM w0.254: R60217.1 241.09,74.15 U60200.8
VRA5V0A_FF: length 2.2
  BOTTOM w0.254: C60281.2 192.86,98.74 v3(192.83,98.77) 192.3,98.24 U60250.13
VRA5V0A_FF_R: length 1.7
  BOTTOM w0.254: v3(196.16,98.79) R60289.1 194.54,98.79 C60281.1
VRA5V0A_LDO: length 1.8
  BOTTOM w0.254: C60280.1 193.09,97.34 U60250.15
VRA5V0A_OUT: length 1.9
  BOTTOM w0.254: U60250.14 193.57,97.79 R60253.1
VRA5V0A_SNB: length 1
  BOTTOM w0.254: R60266.2 C60266.1
VRA5V0A_VOUT: length 11.2
  BOTTOM w0.254: PAD60250.3 194.27,91.23 193.89,91.61 v3(193.89,92.17) 193.89,93.37 195.83,95.31 195.83,95.52 195.83,95.52 195.83,95.92 195.32,96.43 R60289.2 194.57,97.94 R60253.2
VRA_1V05A_VCC: length 1.8
  BOTTOM w0.254: C60909.1 168.5,99.45 U60900.13
VRA_1V8A_VCC: length 1.2
  BOTTOM w0.254: U60600.13 109.12,101.03 109.85,101.03 C60609.1
VRA_5V0A_VCC: length 1.8
  BOTTOM w0.254: U60250.17 U60250.16 192.37,96.79 C60259.1
VRA_VDD18: length 5.9
  TOP w0.254: U66000.26 98.37,94.68 98.21,94.53 97.2,94.53 96.52,93.85 96.52,92.45 v3(96.47,92.39) 96.3,92.23 R66111.1 96.3,90.8 C66111.1
VRABGATE: length 150.9
  TOP w0.254: v1(195.86,102.1) 195.86,101.23 196.66,100.43 C60019.1 ; v1(195.86,102.1) 195.37,102.58 195.37,104.47 194.74,105.11 U60000.32 ; v1(195.86,102.1) 196.83,102.1 198.1,100.82 C60018.1
  L6 w0.254: v1(109.11,114.24) 107.46,114.24 104.57,111.34 102.28,111.34 97.96,107.03 97.96,104.26 94.89,101.19 94.89,93.7 98.43,90.16 109.2,90.16 111.02,91.99 121.59,91.99 125.65,96.05 127.55,96.05 128.18,96.69 156.07,96.69 161.32,101.94 166.22,101.94 166.45,101.72 169.97,101.72 172.81,104.56 181.4,104.56 184.53,101.42 188.13,101.42 188.4,101.69 193.57,101.69 194.46,102.58 195.37,102.58 v1(195.86,102.1)
  BOTTOM w0.254: Q60012.4 v1(109.11,114.24)
VRABYPSRC: length 9.6
  TOP w0.254: U60000.13 192.15,110.04 191.92,110.27 v1(191.92,110.61) ; R60028.1 184.99,109.26 187.78,109.26 v1(189.18,110.66)
  BOTTOM w0.254: v1(191.92,110.61) 191.56,110.25 189.58,110.25 v1(189.18,110.66)
VRACHG_BATGONE: length 3.6
  TOP w0.254: C60049.1 189.04,103.06 R60012.2 189.68,103.95 190.06,104.33 190.69,104.33 190.95,104.59 U60000.25
VRACHG_SNB1: length 1.9
  BOTTOM w0.254: R60016.1 174.47,115.79 C60016.1 v3(174.65,116.8)
VRACHG_SNB2: length 2.1
  TOP w0.254: R60026.1 159.09,115.91 v3(158.59,115.91) 158.24,116.27 C60026.1
VRACPU_BST1: length 2
  BOTTOM w0.254: U66010.21 147.18,102.51 147.97,101.71 148.4,101.71 C66015.1
VRACPU_BST2: length 2.8
  BOTTOM w0.254: C66025.1 122.22,103.52 v3(122.15,103.52) 121.85,103.52 121.59,103.26 120.46,103.26 U66020.21
VRACPU_BST3: length 3.2
  BOTTOM w0.254: U66030.21 131.13,102.91 132.54,102.91 132.71,103.08 C66035.1 133.27,103.26 v3(133.27,103.98)
VRACPU_CS1: length 61.6
  TOP w0.254: U66000.5 100.77,103.22 v1(100.99,103.44) 102.05,104.51 R66454.1
  L3 w0.254: v1(100.99,103.44) 100.99,105.2 101.42,105.63 101.42,107.96 102.54,109.08 102.55,109.08 102.63,109.16 116.48,109.16 116.56,109.08 124.51,109.08 126.6,107 133.37,107 133.77,107.39 146.33,107.39 148.58,105.14 148.58,104.18 148.2,103.8 v1(148.1,103.8)
  BOTTOM w0.254: U66010.18 148.01,103.71 v1(148.1,103.8)
VRACPU_CS2: length 32.4
  TOP w0.254: v3(103.79,105.2) 103.62,105.02 R66455.1 102.94,104 v1(101.65,102.71) 101.17,102.22 U66000.4
  L3 w0.254: v1(101.65,102.71) 102.18,103.24 102.18,107.63 102.94,108.4 116.17,108.4 116.24,108.32 117.57,108.32 120.38,105.51 v1(120.38,104.9)
  BOTTOM w0.254: U66020.18 120.38,104.87 v1(120.38,104.9)
VRACPU_CS3: length 48.4
  TOP w0.254: R66154.1 102.43,106.88 102.73,106.58 103.03,106.58 103.32,106.58 104.35,105.55 104.35,104.33 102.04,102.02 v1(101.65,102.02) 101.57,101.94 U66000.3
  L3 w0.254: v1(131.1,104.65) 131.1,105.46 130.07,106.49 126.39,106.49 124.18,108.7 116.4,108.7 116.32,108.78 102.78,108.78 101.8,107.79 101.8,105.47 101.47,105.14 101.47,103.21 101.17,102.91 101.17,102.5 v1(101.65,102.02)
  BOTTOM w0.254: v1(131.1,104.65) 131.1,104.58 130.16,103.64
VRACPU_IMON: length 2.8
  TOP w0.254: R66407.2 95.16,97.54 95.64,97.06 C66407.2 96.14,96.79 96.44,97.09 97.21,97.09 U66000.21
VRACPU_IREF: length 5.4
  TOP w0.254: R66113.1 94.63,91.98 v3(95.17,92.52) 95.48,92.83 95.77,92.83 95.91,92.98 95.91,94.1 96.52,94.7 97.22,95.4 U66000.24
VRACPU_PE: length 5.4
  TOP w0.254: U66000.36 102.37,95 103.32,94.05 v3(103.32,93.74) 103.72,93.34 R66106.2 104.5,92.93 R66115.1 C66115.1 104.54,91.12 R66114.2
VRACPU_PE_EC: length 211.5
  TOP w0.254: R66106.1 v1(103.72,91.5) ; U300.G3 v1(241.48,41.29)
  L5 w0.254: v1(241.48,41.29) 241.48,41.56 242.11,42.2 242.11,44.8 243.23,45.91 244.06,45.91 244.9,46.75 244.9,51.15 237.37,58.69 232.81,58.69 232.51,58.99 231.15,58.99 228.72,61.42 228.72,62.7 228.44,62.98 227.68,62.98 223.82,66.84 223.82,74.23 225.29,75.7 225.29,78.44 225.6,78.75 225.6,79.32 226.44,80.16 226.44,80.42 226.44,80.42 226.44,81.46 226.03,81.87 226.03,83.12 225.88,83.27 225.88,85.49 224.81,86.55 223.53,86.55 222.27,87.81 222.27,91.23 222.07,91.43 221.99,91.51 221.99,95.89 222.7,96.6 222.7,97.27 222.7,97.27 222.7,97.86 221.54,99.02 220.49,99.02 220.42,99.1 218.26,101.26 218.26,102.35 218.84,102.93 218.84,104.31 v1(218.74,104.41)
  L6 w0.254: v1(103.72,91.5) 104.69,90.54 109.04,90.54 110.87,92.37 121.43,92.37 125.49,96.43 127.39,96.43 128.03,97.07 155.75,97.07 161.01,102.33 166.38,102.33 166.61,102.1 169.81,102.1 172.65,104.94 181.55,104.94 184.69,101.8 187.97,101.8 188.24,102.07 193.41,102.07 194.3,102.96 202.01,102.96 202.99,103.95 202.99,104.75 204.63,106.39 204.88,106.39 205.51,106.39 206.59,105.31 217.84,105.31 v1(218.74,104.41)
VRACPU_PWM1: length 58.6
  TOP w0.254: U66000.43 v1(104.16,98.3)
  L3 w0.254: v1(147.41,105.42) 143.51,101.61 143.51,97.58 142.16,96.23 126.7,96.23 121.31,101.61 120.12,101.61 116.95,104.78 110.24,104.78 108.83,103.37 108.83,101.31 105.82,98.3 v1(104.16,98.3)
  BOTTOM w0.254: U66010.15 147.16,104.91 147.41,105.16 v1(147.41,105.42)
VRACPU_PWM2: length 25.3
  TOP w0.254: v1(104.59,97.12) 104.39,97.32 104.39,97.47 104.11,97.75 104.02,97.75 103.88,97.9 U66000.42
  L3 w0.254: v1(104.59,97.12) 104.26,96.79 103.71,96.79 103.07,97.43 103.07,99.92 104,100.85 104.67,100.85 109.83,106.01 117.9,106.01 v1(118.5,105.41)
  BOTTOM w0.254: v1(118.5,105.41) 118.79,105.12 118.79,104.98 U66020.15
VRACPU_PWM3: length 35.3
  TOP w0.254: v1(103.91,97.27) 103.68,97.5 U66000.41
  L3 w0.254: v1(103.91,97.27) 103.45,97.73 103.45,99.76 104.16,100.47 104.83,100.47 109.98,105.63 117.6,105.63 120.1,103.13 122.9,103.13 125.47,105.7 v1(129.26,105.7)
  BOTTOM w0.254: v1(129.26,105.7) 129.51,105.45 129.51,104.68 U66030.15
VRACPU_SNB1: length 2
  BOTTOM w0.254: v3(141.27,101.54) 141.32,101.49 C66016.1 141.82,100.7 R66016.2
VRACPU_SNB2: length 1.2
  BOTTOM w0.254: C66026.1 117.33,97.29 R66026.2
VRACPU_SNB3: length 2
  BOTTOM w0.254: C66036.1 136.52,101.45 R66036.2 v3(135.53,102.43)
VRACPU_STB: length 103.6
  TOP w0.254: v1(101.62,94.3) 101.57,94.35 U66000.34
  L6 w0.254: v1(155.55,103.47) 155.39,103.32 152.74,103.32 151.72,104.33 150.36,104.33 149.88,104.81 149.88,104.81 149.73,104.97 148.08,104.97 v1(148.08,104.96) 148.05,104.94 146.81,104.94 145.08,103.21 134.36,103.21 132.06,105.51 130.26,105.51 v1(130.03,105.28) 129.67,104.92 128.88,104.92 127.98,105.82 119.67,105.82 119.55,105.7 v1(119.28,105.7) 119.28,105.36 118.79,104.87 117.5,104.87 117.07,105.29 109.56,105.29 105.99,101.72 v1(105.99,95.57) 105.99,95.24 105.05,94.3 v1(101.62,94.3)
  BOTTOM w0.254: U66030.16 129.97,104.58 129.97,105.23 v1(130.03,105.28) ; U66310.16 107.72,68.29 110.66,71.24 110.66,85.17 107.49,88.35 107.49,92.75 107.16,93.08 106.61,93.08 105.99,93.7 v1(105.99,95.57) ; v1(119.28,105.7) 119.31,105.68 119.31,104.93 U66020.16 ; v1(148.08,104.96) 148,104.96 147.54,104.51 U66010.16 ; v1(155.55,103.47) 155.45,103.47 154.92,102.94 U66610.8
VRACPU_VDD33: length 4.3
  TOP w0.254: U66000.44 103.14,98.68 103.86,98.68 103.96,98.78 104.38,98.78 104.78,98.38 104.78,97.62 105.26,97.14 105.31,97.14 ; C66110.1 105.31,97.14 ; 105.31,97.14 R66110.2
VRACPU_VDIFF: length 4.8
  TOP w0.254: v3(101.22,105.27) 100.78,105.27 R66471.1 100.37,104.86 U66000.6
VRACPU_VFB: length 4.9
  TOP w0.254: U66000.7 99.97,103.67 99.57,104.07 99.57,104.62 99.57,104.62 R66471.2 99.56,104.91 R66472.1
VRACPU_VFB1: length 2.7
  TOP w0.254: R66472.2 100.5,105.9 C66472.2 100.5,106.81 100.07,107.23 100.07,107.63 100.11,107.67 100.11,107.67 v3(100.56,108.12)
VRACPU_VINSEN: length 7.9
  TOP w0.254: R66199.2 108.2,104.19 108.2,103.23 107.73,102.76 R66198.1 107.58,102.76 107.2,102.38 C66806.1 106.76,102.4 v3(105.91,102.4) 105.76,102.4 103.95,100.59 103.95,100.23 103.61,99.89 103.13,99.89 U66000.47
VRACPU_VTEMP: length 98.3
  TOP w0.254: R66161.1 107.46,97.56 107.46,97.02 v1(106.96,96.51)
  L3 w0.254: v1(106.96,96.51) 106.96,96.33 108.05,95.24 v1(108.05,92.95)
  L6 w0.254: v1(155.47,102.81) 152.7,102.81 151.56,103.95 150.2,103.95 149.78,104.38 v1(148.1,104.38) 146.88,104.38 145.34,102.83 134.2,102.83 131.91,105.13 130.7,105.13 v1(130.46,104.88) 130.12,104.54 128.72,104.54 127.88,105.38 119.94,105.38 v1(119.87,105.34) 119.04,104.48 117.34,104.48 116.91,104.91 109.72,104.91 106.45,101.64 106.45,97.02 v1(106.96,96.51)
  BOTTOM w0.254: U66030.17 130.37,104.41 130.37,104.79 v1(130.46,104.88) ; v1(155.47,102.81) 155.34,102.81 155.07,102.54 U66610.9 ; U66010.17 147.7,104.11 147.97,104.38 v1(148.1,104.38) ; U66310.17 107.86,67.89 111.05,71.08 111.05,85.33 107.95,88.43 107.95,92.85 v1(108.05,92.95) ; U66020.17 119.87,104.92 v1(119.87,105.34)
VRACPU_VTEMP1: length 4.9
  TOP w0.254: v3(107.08,99.58) R66161.2 107.08,98.79 C66160.1 R66160.1 105.05,98.79 104.68,99.16 103.8,99.16 103.74,99.1 U66000.45
VRAGT_BST1: length 1.8
  BOTTOM w0.254: C66315.1 107.92,65.8 107.43,66.29 U66310.21
VRAGT_CS1: length 56.5
  TOP w0.254: v1(102.93,107.06) 103.38,107.06 103.56,106.88 R66155.1 104.21,106.55 104.21,106.23 104.73,105.71 104.73,104.17 102.37,101.81 U66000.1
  L3 w0.254: v1(108.45,92.42) 108.12,92.09 105.62,92.09 104.29,93.43 104.27,93.43 103.1,94.6 103.1,95.14 102.51,95.72 102.51,101.41 103.01,101.91 103.01,106.5 102.93,106.58 v1(102.93,107.06)
  BOTTOM w0.254: v1(108.45,92.42) 108.43,92.39 108.43,88.49 111.43,85.49 111.43,70.92 109.37,68.86 v3(109.37,68.32) 108.82,68.32 108,67.49 U66310.18
VRAGT_IMON: length 3
  TOP w0.254: R66107.1 95.31,95.13 95.64,95.46 C66107.1 95.64,95.94 96.05,96.34 96.26,96.34 96.61,96.7 U66000.22
VRAGT_PWM1: length 34.6
  TOP w0.254: v1(104.54,96.33) 104.16,96.33 103.8,96.7 U66000.39
  L3 w0.254: v1(104.54,96.33) 103.78,95.57 103.78,94.76 105.66,92.88 106.68,92.88 v1(106.96,92.6)
  BOTTOM w0.254: v1(106.96,92.6) 106.96,88.34 110.28,85.02 110.28,71.46 108.35,69.53 v3(108.15,69.53) 108.15,69.28 107.56,68.69 U66310.15
VRAGT_SNB1: length 1.9
  BOTTOM w0.254: R66316.2 111.68,65.98 111.68,66.79 v3(111.86,66.97) 111.86,67.71 C66316.1
VRAGT_VDIFF: length 7.5
  TOP w0.254: R66171.1 98.14,107.12 97.58,106.57 v3(97.58,106.26) 97.23,105.91 97.23,105.09 97.03,104.9 97.03,103.31 97.73,102.62 97.98,102.62 98.77,101.83 U66000.10
VRAGT_VFB: length 9.2
  TOP w0.254: U66000.11 98.37,101.69 97.79,102.27 97.58,102.27 96.69,103.17 96.67,103.19 96.65,103.21 96.65,105.23 96.85,105.42 96.85,106.07 97.02,106.24 97.02,106.55 97.29,106.81 R66171.2 97.29,107.59 97.28,107.59 R66172.1 97.28,109.13 v3(97.28,109.13)
VRAGT_VFB1: length 1.9
  TOP w0.254: R66172.2 C66172.2 98.89,108.82 v3(98.57,109.13)
VRAPACK_VBAT: length 191.9
  TOP w0.254: R60013.2 194.86,99.19 194.86,99.7 194.46,100.1 194.46,101.9 v1(194.66,102.1) ; v1(81.23,25.74) 81.09,25.74 80.49,26.34 80.49,35.52 80.67,35.69 80.67,37.18 78.79,39.06 v3(78.79,41.62) v1(78.79,42.48)
  L6 w0.254: v1(194.66,102.1) 193.87,101.31 188.55,101.31 188.29,101.04 184.38,101.04 184.13,101.29 184.12,101.29 181.23,104.18 172.97,104.18 168.49,99.7 166.54,99.7 164.67,101.56 161.48,101.56 156.22,96.31 128.34,96.31 127.71,95.67 125.81,95.67 121.75,91.61 111.18,91.61 109.35,89.78 101.14,89.78 100.5,89.14 100.5,88.07 102.66,85.92 106.78,85.92 107.44,85.26 107.44,78.25 97.86,68.67 97.86,63.5 97.5,63.14 97.5,59.28 96.72,58.51 96.72,57.24 81.97,42.48 v1(78.79,42.48)
  BOTTOM w0.254: R60019.2 80.75,25.27 v1(81.23,25.74)
VRASA_BST1: length 2.9
  BOTTOM w0.254: U66610.13 154.55,100.94 155.34,100.14 155.77,100.14 C66615.1 156.71,99.93 156.71,99.93 v3(156.82,99.83)
VRASA_CS1: length 65.1
  TOP w0.254: v1(106.8,104.56) 106.8,105.18 107.08,105.46 R66654.1 v3(106.24,105.71) 105.33,104.79 105.33,102.51 U66000.48
  L6 w0.254: v1(106.8,104.56) 107.11,104.56 110.01,107.46 123.68,107.46 124.11,107.03 137.91,107.03 138.33,107.03 138.6,107.3 138.71,107.3 139.22,107.81 153.11,107.81 156.13,104.79 156.13,102.79 155.57,102.22 v1(155.47,102.22)
  BOTTOM w0.254: v1(155.47,102.22) 155.38,102.14 U66610.10
VRASA_CSUMC: length 17.8
  TOP w0.254: v1(96.01,97.39) 96.05,97.39 96.14,97.47 96.59,97.47 96.61,97.5 U66000.20 ; v1(106.22,106.52) 106.26,106.56 R66654.2
  L6 w0.254: v1(96.01,97.39) 96.62,97.39 97.1,97.88 97.1,100.73 100.73,104.36 104.06,104.36 v1(106.22,106.52)
VRASA_IMON: length 4.1
  TOP w0.254: U66000.23 96.75,96.3 96.14,95.68 v3(96.14,95.11) 96.14,94.86 95.44,94.16 C66607.1 R66607.1
VRASA_PWM1: length 65.7
  TOP w0.254: v1(104.54,95.57) 104.39,95.57 103.66,96.3 U66000.38
  L3 w0.254: v1(104.54,95.57) 106.83,97.86 106.83,98.77 109.21,101.15 109.21,103.21 110.4,104.4 116.79,104.4 119.96,101.23 121.15,101.23 126.54,95.85 126.86,95.85 142.32,95.85 144.33,97.86 150.14,97.86 154.68,102.4 v1(154.68,103.85)
  BOTTOM w0.254: v1(154.68,103.85) 154.68,103.47 154.55,103.34 U66610.7
VRASA_SNB1: length 2
  BOTTOM w0.254: C66616.1 150.69,100.63 v3(150.55,100.5) R66616.2
VRASA_VDIFF: length 1.8
  TOP w0.254: U66000.14 96.75,99.9 96.57,100.08 96.57,101 R66671.1
VRASA_VFB: length 4.3
  TOP w0.254: U66000.15 96.55,99.5 96.19,99.86 96.19,100.27 95.93,100.53 R66671.2 95.8,100.56 v1(94.31,100.56)
  BOTTOM w0.254: R66672.1 94.88,100.56 94.88,100.56 v1(94.31,100.56)
VRASA_VFB1: length 2
  BOTTOM w0.254: C66672.2 96.19,101.54 v3(96.62,101.11) 96.16,100.65 R66672.2
VRASA_VORTN: length 1.5
  TOP w0.254: U66000.17 95.84,98.7 R66681.1
VRASA_VOSEN: length 1.6
  TOP w0.254: R66680.1 95.87,99.49 96.26,99.1 96.49,99.1 96.5,99.1 U66000.16
VRAVCC_PRIM_SNB: length 1
  BOTTOM w0.254: R61416.2 C61416.1
VRAVCCIO_BST: length 2.8
  BOTTOM w0.254: R60515.1 105.18,51.95 105.18,53.63 U60500.9
VRAVCCIO_BST1: length 1
  BOTTOM w0.254: R60515.2 105.74,50.18 C60515.1
VRAVCCIO_MODE: length 2.4
  BOTTOM w0.254: R60529.2 105.97,55.93 v3(105.81,55.77) 105.81,55.29 105.42,54.9 U60500.7
VRAVCCIO_SNB: length 1
  BOTTOM w0.254: R60516.2 C60516.1
VRAVDD: length 17.9
  TOP w0.254: 182.29,110.63 185.01,110.63 D60098.2 v3(186.41,110.67) ; 182.29,110.63 181.78,110.63 R60054.2 ; 182.29,110.63 182.29,109.09 R60003.2 183.03,108.35 C60008.2 R60028.2 185.48,108.35 186,108.88 186.4,108.88 186.71,108.57 186.71,107.48 ; 186.71,107.48 R60004.1 ; 186.71,107.48 188.29,107.48 188.87,108.06 U60000.18
VRAVDDP: length 20.5
  TOP w0.254: v1(187.45,110.66) 186.85,110.06 183.13,110.06 R60003.1 ; v1(197.51,111.85) 197.01,111.35 C60022.1 195.73,110.97 195.73,110.49 194.99,109.76 194.99,109.16 U60000.8
  BOTTOM w0.254: v1(197.51,111.85) 188.64,111.85 v1(187.45,110.66)
VRAVDDQ_BST: length 2.2
  BOTTOM w0.254: R60315.1 160.17,4.35 160.17,5.27 159.78,5.66 U60300.10
VRAVDDQ_BST1: length 1.9
  BOTTOM w0.254: C60315.1 160.37,1.72 v3(160.3,1.79) 160.3,2.51 R60315.2
VRAVDDQ_FB: length 3.3
  BOTTOM w0.254: U60300.13 158.51,3.94 158.82,3.64 R60301.2 158.82,3.16 158.58,2.93 R60300.1 C60348.1
VRAVDDQ_MODE: length 2.7
  BOTTOM w0.254: U60300.14 158.01,4.28 157.5,3.77 157.5,3.76 157.49,3.75 157.49,3.27 R60346.2
VRAVDDQ_SNB: length 1
  BOTTOM w0.254: R60316.2 164.69,8.12 C60316.1
VRAVDDQ_VOUT: length 15.5
  L6 w0.254: v1(171.23,5.93) 168.13,2.83 160.11,2.83 v1(159.72,3.22)
  BOTTOM w0.254: C60348.2 R60300.2 159.44,2.97 159.69,3.22 v1(159.72,3.22) ; v1(171.23,5.93) 171.42,6.13 PAD60300.3
VRAVR_ON: length 5.1
  TOP w0.102: U66000.37 103.12,95.72 TP66001.1 R66000.2 R4855.2 105.13,93.67 105.46,93.34 106.05,93.34 C66101.1
VRB1V05A_BST:
  vias: v3(163.9,99.79)
VRB1V05A_BST1: length 2.2
  BOTTOM w0.381: C60915.1 161.7,99.2 R60915.2 v3(160.73,99.63)
VRB1V8A_BST: length 1.4
  BOTTOM w0.254: R60615.1 104.93,99.3 v3(104.87,99.35)
VRB1V8A_BST1: length 2.2
  BOTTOM w0.381: v3(105.36,96.89) C60615.1 106.15,97.69 R60615.2
VRB3V3A_BST: length 2.7
  BOTTOM w0.381: R60115.1 226.92,78.93 U60100.8
VRB3V3A_BST1: length 2.1
  BOTTOM w0.381: v3(222.45,78.17) 222.66,77.96 C60115.1 223.7,78.38 R60115.2
VRB5V0_BST: length 2
  BOTTOM w0.381: U60200.13 235.6,73.15 R60215.1
VRB5V0_BST1: length 2.2
  BOTTOM w0.381: v3(232.36,71.69) C60215.1 233.15,71.89 R60215.2
VRB5V0A_BST:
  vias: v3(187.6,97.42)
VRB5V0A_BST1: length 2
  BOTTOM w0.381: v3(184.43,97.35) R60265.2 185.4,97.34 C60265.1
VRB_ADP_SELEC: length 120.5
  TOP w0.381: Q68108.1 255.58,84.26 v1(256.08,84.26) ; v1(251.68,30.77) 251.29,31.17 249.84,31.17 249.1,30.42 R68101.1 247.63,30.24 247.25,29.86 D68200.2 ; v1(260.67,99.59) 260.67,98.1 Q68103.1 ; v1(255.95,43.17) 255.93,43.17 Q68104.1
  L5 w0.381: 249.69,34.46 254.25,34.46 255.96,36.17 256.67,36.17 257.53,37.03 258.59,37.03 258.59,37.03 266.28,37.03 v1(266.82,37.58) ; 249.69,34.46 249.37,34.78 249.09,34.78 248.65,35.22 248.65,38.46 249.33,39.14 250.24,39.14 254.26,43.17 v1(255.95,43.17) ; 249.69,34.46 249.69,32.76 v1(251.68,30.77)
  L6 w0.381: v1(260.67,99.59) 260.67,93.02 256.1,88.46 256.1,84.28 v1(256.08,84.26) 257.25,83.09 257.25,74.61 259.74,72.12 264.01,72.12 268.82,67.31 268.82,52.71 267.51,51.4 267.51,38.15 266.94,37.58 v1(266.82,37.58)
VRB_VDD3: length 380.1
  TOP w0.381: C60309.1 156.57,8.4 v1(156.61,8.45) ; v1(104.97,51.37) 104.43,50.83 104.43,49.91 99.1,44.58 98.67,44.58 94.95,40.86 94.95,27.27 90.88,23.19 89.29,21.61 89.29,14.21 v1(92.38,11.12) ; R66109.2 R66108.2 101.75,91.84 R66105.1 102.64,91.61 103.98,90.27 R66114.1 107.49,90.27 v1(108.99,91.76) ; v1(107.72,96.33) 107.26,95.87 106.61,95.87 R66110.1
  L3 w0.381: v1(104.97,51.37) 104.97,54.87 107.66,57.56 108.05,57.56 108.99,58.5 108.99,65.31 v1(111.05,67.37) ; v1(171.6,100.57) 171.6,99.16 171.98,98.78 173.11,98.78 174.13,97.76 189.02,97.76 189.64,98.38 192.64,98.38 193.94,99.67 197.45,99.67 198.22,100.43 204.1,100.43 204.91,101.25 212.36,101.25 212.65,100.96 213.54,100.96 213.54,100.96 213.84,100.96 215.04,99.77 215.04,99.72 220.14,94.61 223.23,94.61 223.47,94.37 223.68,94.16 223.68,87.51 229.55,81.65 229.55,79.32 229.93,78.93 v1(230.1,78.93) ; v1(108.99,91.76) 108.99,92.18 109,92.19 109,95.38 108.05,96.33 v1(107.72,96.33) 107.72,99.03 109.66,100.97 109.66,103.03 110.23,103.61 112.12,103.61 v1(112.31,103.42)
  L5 w0.381: v1(156.26,102.22) 157.51,100.97 165.79,100.97 166.49,101.67 166.94,101.67 167.2,101.41 170.83,101.41 171.6,100.65 v1(171.6,100.57)
  L6 w0.381: v1(92.38,11.12) 92.91,10.59 98.87,10.59 99.76,9.7 119.89,9.7 120.1,9.91 128.91,9.91 129.56,9.26 144.71,9.26 145.41,8.56 156.5,8.56 v1(156.61,8.45) ; v1(230.1,78.93) 229.87,78.7 229.87,72.49 231.42,70.94 232.55,70.94 233.81,70.94 234.17,70.58 234.17,69.82 236.96,67.03 236.96,66.26 236.58,65.88 v1(236.34,65.88) ; v1(156.26,102.22) 156.26,101.78 155.44,100.97 152.11,100.97 150.71,102.37 150.71,102.59 v1(149.5,103.8) 149.33,103.8 147.67,102.14 132.94,102.14 v1(131.63,103.45) 131.6,103.42 128.44,103.42 127.53,104.33 121.49,104.33 v1(120.96,103.8) 120.81,103.65 117.55,103.65 116.73,104.47 113.36,104.47 v1(112.31,103.42)
  BOTTOM w0.254: 147.91,102.54 147.54,102.91 U66010.20 ; U66030.20 131.1,103.45 v1(131.63,103.45) ; C66317.1 109.19,66.51 107.79,66.51 107.62,66.69 U66310.20 ; U66020.20 120.44,103.8 v1(120.96,103.8) ; 155.28,100.97 154.91,101.34 U66610.12
  BOTTOM w0.381: R61406.2 172.69,97.35 172.21,97.83 172.21,98.59 R60930.1 171.95,100.22 v1(171.6,100.57) ; v1(112.31,103.42) 112.28,103.42 R60630.1 ; v1(236.34,65.88) 236.25,65.97 235.47,65.97 235.05,66.38 231.43,66.38 230.3,65.25 229.42,65.25 227.93,63.77 PAD60100.4 ; v1(131.63,103.45) 132.26,103.45 C66037.1 ; R60506.2 104.62,51.02 v1(104.97,51.37) ; v1(108.99,91.76) 108.96,91.73 108.96,88.58 111.87,85.67 111.87,70.18 110.51,68.81 110.51,67.75 110.89,67.37 v1(111.05,67.37) 111.05,67.06 110.7,66.7 109.38,66.7 C66317.1 ; 155.28,100.97 155.52,100.73 C66617.1 156.54,100.73 156.71,100.91 156.71,101.77 v1(156.26,102.22) ; v1(149.5,103.8) 149.5,102.68 149.12,102.3 C66017.1 148.15,102.3 147.91,102.54 ; U60300.3 156.61,8.01 v1(156.61,8.45) ; C66027.1 121.29,103.8 v1(120.96,103.8)
VRB_VDD5: length 155.1
  TOP w0.381: v1(123.59,88.57) 123.59,87.57 123.21,87.19 117.14,87.19 117.14,87.19 116.12,87.19 112.11,83.18 112.11,73.57 111.9,73.36 111.9,72.82 112.11,72.61 112.11,64.27 115.3,61.09 115.3,52.52 113.19,50.41 v1(104.97,50.41) ; v1(168.96,88.68) 170.17,89.89 175.22,89.89 175.71,89.4 v1(175.71,89.04)
  L5 w0.381: v1(123.59,88.57) 123.59,94.18 125.58,96.16 125.84,96.42 156.52,96.42 156.57,96.37 158.86,96.37 159.12,96.11 159.12,96.11 159.57,95.66 159.57,95.14 160.75,93.97 162.17,93.97 167.52,88.62 168.9,88.62 v1(168.96,88.68) 170.6,90.32 170.6,97.16 v2(171.66,98.22)
  L6 w0.381: v1(195.36,89.35) 195.36,89.18 194.98,88.8 175.96,88.8 v1(175.71,89.04)
  BOTTOM w0.254: PAD60250.4 v1(195.36,89.35)
  BOTTOM w0.381: v1(104.97,50.41) 104.7,50.13 R60505.2 ; v2(171.66,98.22) 171.66,97.24 R61405.2
VRBVCC_PRIM_BST: length 2.6
  BOTTOM w0.381: R61415.1 177.09,95.27 U61400.9
VRBVCC_PRIM_BST1: length 2
  BOTTOM w0.381: v3(173.38,95.21) 173.44,95.27 R61415.2 174.39,95.25 C61415.1
VREF_PECI: length 3.9
  TOP w0.254: U300.M6 239.2,45.22 239.79,45.8 239.79,46.17 239.58,46.38 239.58,47.03 239.48,47.13 239.48,47.14 239.18,47.44 R383.2 239.18,47.87 239.01,48.04 R386.2
VRP1V5: length 7.6
  BOTTOM w0.381: R61700.1 225.82,92.45 226.2,92.83 227.04,92.83 227.42,92.45 C61705.1 228.11,92.04 v3(228.22,92.14) 230.01,92.14 230.4,91.75 230.4,90.03
VRP1V5_PH: length 1.3
  BOTTOM w0.508: v3(226.77,87.72) 226.65,87.84 U61700.3
VRP1V5_VIN: length 1.4
  BOTTOM w0.508: v3(223.08,88.48) 223.61,89.01 U61700.4
VRP1V05A: length 1.8
  BOTTOM w0.254: C7558.1 169.82,94.93 ; C7560.1 169.69,96.2 ; C7559.1 169.69,95.57
  vias: v3(169.62,89.3)
VRP1V05A_PH: length 7.3
  BOTTOM w0.102: U60900.16 165.63,99.49 165.63,101.81 U60900.5
  BOTTOM w0.381: C60915.2 163.85,98.62
  BOTTOM w0.508: R60916.1 166.28,97.57 L60900.1
VRP1V05A_VIN:
  vias: v3(161.64,101.46)
VRP1V8A:
  vias: v3(115.26,92.42)
VRP1V8A_PH: length 6.5
  BOTTOM w0.102: U60600.5 106.42,101.88 108.05,100.25 U60600.16
  BOTTOM w0.254: R60616.1 108.06,94.26 107.82,94.02 v3(107.82,93.66)
  BOTTOM w0.508: 108.73,96.36 108.73,95.53 R60616.1 ; 107.46,99 C60615.2
VRP1V8A_VIN:
  vias: v3(104.14,102.05)
VRP2V5: length 11.9
  BOTTOM w0.508: C60405.1 R60400.1 195.53,8.37 195.53,8.37 v3(202.87,8.37) 204.23,8.37 204.74,7.86 204.74,6.67
VRP2V5_VIN: length 1.6
  BOTTOM w0.254: PAD60410.2 192.18,4.62 C60410.1
VRP3V3A:
  vias: v3(224.66,66.31)
VRP3V3A_LDO_RC: length 2.3
  TOP w0.254: v3(234.87,27.65) C1000.1 236.39,27.65 R1000.2 R1001.1
VRP3V3A_PH: length 6.3
  BOTTOM w0.254: v3(222.45,76.87) 222.69,77.11 C60115.2
  BOTTOM w0.508: C60115.2 226.95,77.11 L60100.1 ; R60116.1 230.29,77.81
VRP3V3A_VIN: length 1.9
  BOTTOM w0.254: 227.76,86 C7567.1 ; 227.44,86.61 C7568.1 227.43,86.93 v3(226.89,86.4)
VRP5V0: length 1.1
  BOTTOM w0.254: C76020.1 241.73,64.45 241.45,64.17
VRP5V0_PH: length 2.7
  BOTTOM w0.508: 236.5,71.19 236.15,71.53 R60216.1 234.81,71.69 C60215.2
VRP5V0A_PH: length 7.5
  BOTTOM w0.102: U60250.6 189.4,99.65 189.4,96.82 U60250.20
  BOTTOM w0.508: L60250.1 187.51,93.88 R60266.1
VRP5V0A_VIN: length 1.4
  BOTTOM w0.508: C60260.1 187.19,100.35 C60262.1
  vias: v3(186.15,98.97)
VRPCHG_BST1: length 2.9
  TOP w0.254: 192.94,110.81 v3(192.63,110.5) 192.49,110.36 192.49,109.57 192.55,109.51 U60000.12
  TOP w0.508: R60015.2 193.48,111.35 192.94,110.81
VRPCHG_BST1_R: length 1.3
  TOP w0.508: C60015.2 194.77,112.49 193.64,112.49 R60015.1
VRPCHG_BST2: length 4.3
  TOP w0.254: U60000.4 195.05,106.86 v3(195.32,106.59) 195.53,106.59 196.15,107.22
  TOP w0.508: 196.15,107.22 196.36,107.43 196.36,108.64 R60025.2
VRPCHG_BST2_R: length 2.5
  TOP w0.254: v3(197.35,108.02) 197.93,108.59 R60025.1
  TOP w0.508: R60025.1 197.93,109.97 C60025.2
VRPCHG_HG1: length 19.5
  TOP w0.254: U60000.11 192.95,109.75 v5(193.04,109.84)
  L6 w0.508: v5(193.04,109.84) 192.2,109.01 185.95,109.01 185.62,108.68 v5(176.48,108.68)
  BOTTOM w0.508: Q60000.4 v5(176.48,108.68) ; v5(193.04,109.84) v3(193.04,110.61)
VRPCHG_HG2: length 41.3
  TOP w0.254: U60000.5 195.38,107.26 v5(195.48,107.35)
  L6 w0.508: v5(156.23,108.65) 168.45,108.65 170.08,107.02 195.14,107.02 v5(195.48,107.35)
  vias: v3(156.05,107.84)
VRPCHG_LG1: length 20.7
  TOP w0.254: U60000.9 193.75,109.11 194.12,109.48 v5(194.29,109.48)
  L6 w0.508: v5(177.39,109.91) 177.6,109.69 185.2,109.69 185.53,110.02 190.47,110.02 191.67,111.22 192.64,111.22 194.29,109.57 v5(194.29,109.48)
  BOTTOM w0.508: Q60001.4 v5(177.39,109.91) ; v5(194.29,109.48) v3(194.29,108.71)
VRPCHG_LG2: length 48.2
  TOP w0.254: U60000.7 194.76,108.06 195.25,108.55 195.3,108.55 v5(195.31,108.56)
  L6 w0.508: v5(158.39,116.82) 159.65,115.56 175.69,115.56 177.68,113.57 181.14,113.57 181.73,114.16 195.36,114.16 196.75,112.78 196.75,112.25 196.88,112.11 196.88,109.02 196.33,108.46 195.54,108.46 195.44,108.56 v5(195.31,108.56)
  BOTTOM w0.508: v5(195.31,108.56) v3(196.07,108.56)
VRPCHG_PH1: length 38.5
  TOP w0.254: U60000.10 193.34,109.01 193.34,109.37 193.58,109.61 193.58,109.8 193.72,109.94
  TOP w0.508: 193.72,109.94 193.73,109.94 194.34,110.56 v1(194.54,110.56) 194.84,110.86 C60015.1
  L6 w0.381: v1(194.54,110.56) 194.54,111.85 194.07,112.32 187.95,112.32 187.09,111.46 184.97,111.46 184.62,111.81 182.14,111.81 181.69,111.37 171.62,111.37 169.27,113.72 166.26,113.72 v1(165.68,113.14)
  BOTTOM w0.254: v1(165.68,113.14) L60000.3
VRPCHG_PH2: length 47.7
  TOP w0.254: v1(195.93,109.41) 195.86,109.34 195.86,108.34 195.54,108.02 195.32,108.02 194.97,107.66 U60000.6
  TOP w0.508: v1(195.93,109.41) 195.93,109.67 196.44,110.17 C60025.1 ; R60026.2 161.82,116.4 v2(161.95,116.52)
  L6 w0.381: v1(195.93,109.41) 195.93,111.71 194.43,113.21 182.28,113.21 181.32,112.26 171.99,112.26 169.64,114.61 165.89,114.61 165.31,114.02 164.64,113.35 v1(164.64,113.14)
  BOTTOM w0.254: v1(164.64,113.14) L60000.4
  BOTTOM w0.508: L60000.2 161.95,115.06 v2(161.95,116.52)
VRPCPU_PH1: length 0.8
  BOTTOM w0.381: 148.61,99.84 C66015.2
  vias: v3(145.28,100.93)
VRPCPU_PH2: length 1.9
  BOTTOM w0.508: C66025.2 123.36,101.98 122.28,100.9
  vias: v3(119.05,99.07)
VRPCPU_PH3: length 2.2
  BOTTOM w0.381: 134.16,102.02 C66035.2 133.66,101.89
  BOTTOM w0.508: R66036.1 135.29,100.29 134.59,100.29
  vias: v3(133.35,101.06)
VRPGT_PH1: length 4.9
  BOTTOM w0.508: R66316.1 110.29,65.8 C66315.2 109.49,64.57 107.61,62.7
  vias: v3(105.69,62.96)
VRPPM_SLP_S0_N: length 268.9
  TOP w0.102: v1(251.38,44.36) 251.79,44.77 251.79,45.12 251.23,45.68 251.23,49.17 251.42,49.37 251.42,50.4 v3(250.65,51.17) 250.04,51.78 248.98,52.84 243.94,52.84 243.27,53.51 242.65,53.51 241.78,54.38 241.37,54.38 240.67,55.09 240.67,56.65 240.07,57.25 240.07,57.66 238.35,59.38 238.35,61.47 239.65,62.77 239.65,66.43 243.32,70.1 245.28,70.1 245.52,70.34 245.52,70.68 245.21,70.99 245.21,70.99 245.19,71.01 245.19,71.77 245.21,71.79 245.21,74.8 v1(246.1,75.7) ; v1(212.42,46.83) 212.5,46.91 R4624.2 212.44,47.49 204.72,47.49 203.26,46.03 196.7,46.03 196.03,46.7 195.13,46.7 194.36,47.48 192.71,47.48 190.43,49.76 176.18,49.76 174.25,47.83 173.66,47.83 173.42,47.59 173.42,46.76 172.78,46.13 v1(172.76,46.13)
  L3 w0.102: v1(212.42,46.83) 212.92,47.33 213.61,47.33 214.39,46.55 215.46,46.55 216.24,47.33 216.53,47.33 216.61,47.25 227.1,47.25 227.98,46.37 229.25,46.37 230.63,47.75 231.73,47.75 231.97,47.99 236.09,47.99 236.13,48.03 239.97,48.03 240.21,47.79 243.59,47.79 243.77,47.97 245.03,47.97 245.71,47.29 246.4,47.29 246.73,47.61 246.73,47.76 246.97,48 247.75,48 248.67,47.07 248.86,47.07 250.39,45.54 250.39,45.35 v1(251.38,44.36) ; v1(219.17,101.72) 219.24,101.79 222.13,101.79 222.4,101.51 227.87,101.51 235.18,94.21 235.18,84.7 233.91,83.43 233.91,80.1 235.28,78.72 238.29,78.72 238.5,78.93 238.5,79.95 239.37,80.81 244.9,80.81 245.61,80.1 245.61,77.94 246.51,77.04 246.51,76.11 v1(246.1,75.7)
  L5 w0.102: v1(185.02,95.21) 184.71,95.53 v1(184.71,98.3)
  L6 w0.102: v1(184.71,98.3) 185.11,98.3 185.99,99.18 192.76,99.18 195.12,96.81 198.73,96.81 204.55,102.63 219,102.63 219.17,102.45 v1(219.17,101.72)
  BOTTOM w0.076: U4555.BJ37 165.32,54.25 165.55,53.71 165.71,53.55 167.16,52.09 168.42,52.09 168.43,52.09 170.38,50.14 171.1,50.14 172.28,48.95 172.28,46.6 v1(172.76,46.13)
  BOTTOM w0.102: CN4941.15 261.12,49.45 263.06,51.4 263.06,51.96 262.73,52.29 262.25,52.29 261.06,51.09 257.77,51.09 257.32,50.64 257.32,50.15 257.86,49.61 257.86,49.29 257.6,49.04 256.59,49.04 256.42,48.86 252.37,48.86 250.9,47.39 250.9,44.85 v1(251.38,44.36) ; v1(185.02,95.21) 184.51,94.71 183.47,94.71 R7156.1 R7155.1
VRPRIM_VIN:
  vias: v3(177.09,99.2)
VRPSA_PH1: length 0.6
  BOTTOM w0.381: 155.98,98.49 C66615.2
  vias: v3(152.73,99.56)
VRPVCC_PRIM: length 13.7
  L5 w0.508: v1(175.1,89.04) 175.1,89.73 175.33,89.96 175.33,98.5 v1(173.46,100.37)
  BOTTOM w0.381: v1(173.46,100.37) 172.95,99.86 R61400.1
VRPVCC_PRIM_PH: length 3.3
  BOTTOM w0.381: C61415.2 176.42,93.4
  BOTTOM w0.508: R61416.1 181.72,93.88
VRPVCCIO:
  vias: v3(115.64,50.92)
VRPVCCIO_PH: length 1.7
  BOTTOM w0.254: C60515.2 106.58,51.24 106.58,51.75
  BOTTOM w0.508: 107.96,56.72 R60516.1
  vias: v3(105.86,53.05)
VRPVCCIO_VIN:
  vias: v3(99.87,52.49)
VRPVDDQ: length 12.9
  L3 w0.508: v1(169.59,6.34) 167.11,6.34 167.1,6.34 166.03,7.42 163.91,7.42 163.91,7.42 162.54,7.42 159.32,7.42 158.51,8.22 v1(158.51,8.45)
  BOTTOM w0.33: U60300.6 v1(158.51,8.45)
  vias: v3(170.74,4.66)
VRPVDDQ_PH: length 3.3
  BOTTOM w0.508: R60316.1 163.39,6.84 ; L60300.1 163.07,3.12 161.99,2.04 161.99,1.77 C60315.2
  vias: v3(160.91,6.77)
VRPVDDQ_VIN:
  vias: v3(155.57,4.94)
VRPVTT: length 1.8
  BOTTOM w0.33: v1(160.17,8.19) 160.04,8.19 159.51,7.66 U60300.8 ; U60300.5 158.01,8.19 157.88,8.32 v1(157.88,8.45)
  vias: v3(158.63,10.82)
VRPVTT_REF: length 2.5
  TOP w0.254: C60351.1 v3(159.07,6.85)
  TOP w0.508: v1(159.15,8.45) 159.15,7.77 C60351.1
  BOTTOM w0.33: v1(159.15,8.45) 159.15,8.32 159.01,8.18 U60300.7
WL_LED_ALL#: length 4.6
  BOTTOM w0.102: CN1300.16 64.41,20.5 64.51,20.4 64.51,18.1 64.41,18 CN1300.6
WLAN_ALERT#: length 1.9
  BOTTOM w0.102: CN1300.62 63.37,31.94 61.87,31.94 TP1303.1
WLAN_GND: length 3.1
  BOTTOM w0.356: CN1300.18 62.2,21 v3(61.87,21.33) 61.62,21.57 R1317.2
WLAN_I2CCLK: length 3.4
  BOTTOM w0.13: CN1300.60 61.71,31.5 61.69,31.52 61.59,31.52 60.91,32.2 60.69,32.2 60.69,32.2 TP1302.1
WLAN_I2DATA: length 5.1
  BOTTOM w0.13: TP1301.1 59.14,32.7 60.14,31.7 61.05,31.7 61.48,31.27 61.58,31.27 61.85,31 CN1300.58
WLAN_LED_EN: length 23
  L3 w0.102: v1(180.97,75.42) 181.38,75.02 183.17,75.02 186.53,78.37 191.9,78.37 192.51,77.76 195.86,77.76 196.46,77.17 196.76,77.17 v1(198.09,75.83)
  BOTTOM w0.076: v1(180.97,75.42) 180.64,75.09 180.12,75.09 179.98,74.94 179.6,74.94 179.34,75.21 U4555.CN4
  BOTTOM w0.102: v1(198.09,75.83) 198.68,75.25 R4545.2
WLAN_OFF: length 233.6
  TOP w0.076: v1(240.83,40.64) U300.E4
  TOP w0.102: v1(100.58,29.45) 100.68,29.55 100.68,30.57 101.29,31.18 101.29,32.12 97.33,36.08 97.33,41.67 98.88,43.22 v1(99.67,43.22) ; R348.1 230.53,36.46 v1(230.76,36.23)
  L3 w0.102: v1(50.34,33.47) 51.42,32.38 67.97,32.38 71.87,36.28 72.81,36.28 73.61,37.07 v1(75.54,37.07) 77.96,39.49 92.43,39.49 96.16,43.22 v1(99.67,43.22)
  BOTTOM w0.076: 232.51,36.39 232.61,36.39 232.65,36.35 235.25,36.35 235.94,37.04 238.93,37.04 239.29,37.4 239.98,37.4 240.51,36.88 241.39,36.88 241.6,37.09 241.6,37.38 241.51,37.47 241.51,39.39 241.47,39.43 241.47,39.44 240.83,40.08 v1(240.83,40.64)
  BOTTOM w0.102: v1(75.54,37.07) 75.54,37.69 Q1300.G ; 232.51,36.39 232.09,36.39 231.84,36.64 231.16,36.64 v1(230.76,36.23) 230.43,36.57 229.56,36.57 228.95,35.96 228.95,33.97 227.2,32.22 226.21,32.22 224.79,30.8 221.47,30.8 216.65,25.98 174.27,25.98 172.99,24.7 145.53,24.7 144.88,25.35 138.75,25.35 138.51,25.58 136.6,25.58 135.96,26.23 103.55,26.23 100.58,29.2 v1(100.58,29.45) ; v1(50.34,33.47) 50.01,33.14 50.01,31.5 50.65,30.86 R1349.1
WLAN_OFF_R: length 9.6
  BOTTOM w0.102: R1342.2 v3(49.81,33.9) 49.81,31.41 50.1,31.12 50.1,29.46 50.35,29.2 51.29,29.2 51.5,29.41 R1349.2 51.5,30.63 D1302.1 52.66,30.69 R1343.1
WLAN_PLT_RST#: length 14.1
  BOTTOM w0.102: CN1300.52 62.38,29.5 60.98,28.1 60.45,28.1 60.16,27.8 58.43,27.8 57.94,27.32 57.38,27.32 v3(55.98,25.92) 55.56,25.5 U1300.4 55.28,24.72 54.88,24.32 54.88,22.79 R1301.1 R1347.2
WLAN_PWR_EN#: length 7.2
  BOTTOM w0.102: Q1307.3 53.92,31.79 53.31,32.4 v3(52.7,32.4) 52.7,31.63 R1343.2 51.58,31.6 D1302.3 50.75,32.94 50.75,33.63 50.59,33.79 C1309.2
WLAN_TRANSMIT_OFF#: length 290.9
  TOP w0.076: 188.11,70.8 187,70.8 185.94,69.75 183.38,69.75 182.99,70.14 182.03,70.14 v1(181.58,69.69)
  TOP w0.102: 188.11,70.8 R1300.2
  L5 w0.076: 182.05,69.24 181.6,69.69
  L5 w0.102: v1(51.61,21.93) 53.97,19.57 65.48,19.57 72.77,26.86 77.11,26.86 77.49,27.24 77.49,28.71 80.32,31.54 80.95,31.54 81.96,32.55 81.96,37.53 82.83,38.39 82.83,39.08 92.35,48.6 92.75,48.6 98.71,54.57 103.48,54.57 106.02,57.11 106.02,73.71 113.18,80.88 113.18,84.83 115.87,87.52 115.87,96.51 115.7,96.68 115.69,96.68 114.93,97.44 114.93,97.45 111.88,100.51 111.88,102.1 111.07,102.91 111.07,106.51 112.53,107.96 120.87,107.96 123.84,104.99 125.18,104.99 129.01,101.16 144.68,101.16 145.36,101.84 145.36,107.2 147.32,109.16 155.48,109.16 155.87,109.54 159.78,109.54 161.2,108.12 162.21,108.12 182.01,108.12 182.34,107.79 190.63,107.79 193.37,105.05 193.37,84.19 194.54,83.02 194.54,78.63 194.54,78.63 194.54,78.39 195.15,77.78 195.27,77.66 195.27,77.31 195.67,76.9 195.67,76.74 195.67,76.57 195.67,74.4 194.54,73.26 194.54,72.42 193.16,71.05 193.16,70.63 191.69,69.15 186.51,69.15 186.42,69.24 182.71,69.24 182.71,69.24 182.05,69.24 ; 181.6,69.69 v1(181.58,69.69)
  BOTTOM w0.076: U4555.CP12 179.85,70.24 180.34,69.98 180.74,69.98 180.82,70.06 181.2,70.06 181.57,69.69 v1(181.58,69.69)
  BOTTOM w0.102: D1300.3 52.65,28.37 v3(52.65,27.73) 52.7,27.68 52.7,26.76 52.43,26.49 52.43,23.65 51.61,22.82 51.61,22.82 v1(51.61,21.93)
WLAN_TRANSMIT_OFF#_R: length 6.4
  BOTTOM w0.102: v3(51.94,28.82) 52.84,29.72 D1300.1 55.1,29.72 56,30.62 56.41,30.62 Q1304.S
WLAN_TRANSMIT_OFF#_R_Q: length 6.1
  BOTTOM w0.102: CN1300.56 61.58,30.5 R1346.2 61.28,30.88 60.86,31.31 59.65,31.31 Q1304.D 59.14,30.1 v3(59.53,29.71)
WLAN_WAKE#: length 23.8
  L3 w0.102: v2(67.21,28.25) 66.92,28.53 53.61,28.53 v1(52.09,27.01)
  BOTTOM w0.102: Q1301.S 51.5,25.91 R1305.2 51.5,26.46 51.5,26.46 R1303.1 51.86,27.24 v1(52.09,27.01) ; CN1300.55 68.61,30.25 67.21,28.84 v2(67.21,28.25)
WP_RCOMP: length 8.6
  BOTTOM w0.2: v3(183.5,56.65) 182.46,56.65 181.66,57.44 180.54,57.44 U4555.CR32 180.43,57.55 U4555.CP32
  BOTTOM w0.254: v3(183.5,56.65) 184.86,56.65 185.56,55.95 187.1,55.95 187.52,56.37 R4900.1
WR_CLK_C_DN: length 2.9
  BOTTOM w0.119: R1327.1 72.82,22.01 72.56,21.75 CN1300.21
WR_CLK_C_DP: length 2.9
  BOTTOM w0.119: CN1300.23 71.04,22.32 71.87,22.32 72.22,21.97 72.47,21.97 72.6,22.1 72.6,22.64 72.31,22.93 R1326.1
WR_CLK_DN: length 167.5
  L3 w0.109: v1(106.88,37.66) 106.17,37.66 105.63,37.12 95.87,37.12 92.45,33.69 83.74,33.69 82.8,32.75 82.8,30.97 81.79,29.97 81.46,29.97 81.23,30.2 81.23,30.53 81.94,31.23 81.94,31.39 81.83,31.5 81.67,31.5 78.87,28.69 78.54,28.69 78.31,28.93 78.31,29.25 79.07,30.02 79.07,30.17 78.96,30.28 78.8,30.28 76.29,27.77 73.69,27.77 73.54,27.62 v1(73.54,24.39)
  BOTTOM w0.076: U4555.CN31 180.17,58.51 180.54,58.51 180.76,58.29 182.17,58.29 182.68,57.77 186.03,57.77 186.06,57.8 186.08,57.8
  BOTTOM w0.119: R1327.2 73.28,23.89 73.28,24.12 v1(73.54,24.39) ; 186.08,57.8 189.17,57.8 189.49,57.49 191.86,57.49 192.13,57.21 193.07,57.21 195.73,54.56 195.73,49.35 183.8,37.43 155.96,37.43 154.42,35.88 111.35,35.88 109.38,37.84 108.21,37.84 108.02,37.66 v1(106.88,37.66)
WR_CLK_DP: length 167.5
  L3 w0.109: v1(106.88,38.27) 106.88,38.24 106.51,37.87 106.08,37.87 105.54,37.33 95.78,37.33 92.36,33.91 83.66,33.91 82.59,32.83 82.59,31.06 81.71,30.18 81.55,30.18 81.44,30.29 81.44,30.44 82.15,31.15 82.15,31.48 81.92,31.71 81.59,31.71 78.78,28.9 78.63,28.9 78.52,29.01 78.52,29.17 79.28,29.93 79.28,30.26 79.05,30.49 78.72,30.49 76.2,27.98 73.6,27.98 73.33,27.7 73.33,24.75 72.96,24.39 v1(72.79,24.39)
  BOTTOM w0.076: U4555.CP31 180.39,58.31 180.5,58.31 180.69,58.12 180.84,58.12 180.96,58 181.13,58 181.25,58.12 181.35,58.12 181.47,58 181.59,58 181.71,58.12 182.1,58.12 182.61,57.61 186.03,57.61 186.06,57.58 186.08,57.58
  BOTTOM w0.119: v1(106.88,38.27) 106.88,38.24 107.25,37.88 107.93,37.88 108.12,38.06 109.48,38.06 111.44,36.1 154.32,36.1 155.87,37.65 183.71,37.65 195.51,49.44 195.51,54.47 192.98,56.99 192.04,56.99 191.76,57.27 189.39,57.27 189.08,57.58 v4(188.52,57.58) 186.08,57.58 ; R1326.2 72.25,23.43 72.59,23.77 72.84,23.77 73.05,23.98 73.05,24.12 v1(72.79,24.39)
WR_LANE0_C_DN: length 4.9
  BOTTOM w0.119: R1329.1 74.04,21.37 73.2,20.53 72.29,20.53 72.01,20.25 CN1300.15
WR_LANE0_C_DP: length 5
  BOTTOM w0.119: R1328.1 73.48,22.75 73.81,22.42 73.81,22.26 73.62,22.07 73.62,21.9 73.82,21.71 73.82,21.47 73.68,21.33 73.52,21.33 73.4,21.21 73.4,21.05 73.1,20.75 72.87,20.75 72.76,20.86 72.59,20.86 72.49,20.75 70.98,20.75 CN1300.17
WR_LANE0_DN: length 165.5
  L3 w0.109: v1(74.71,24.89) 74.71,24.92 74.46,25.16 74.46,26.22 74.57,26.33 77.28,26.33 78.48,27.53 78.64,27.53 78.74,27.42 78.74,27.26 77.32,25.84 77.32,25.51 77.55,25.28 77.88,25.28 84.18,31.57 84.18,33.04 84.29,33.15 92.67,33.15 96.1,36.57 107.29,36.57 107.52,36.79 108.15,36.79 v1(108.35,36.59)
  BOTTOM w0.076: 186.08,58.37 186.06,58.37 186.03,58.34 185.23,58.34 185.11,58.22 182.79,58.22 182.32,58.69 180.91,58.69 180.7,58.9 180.64,58.9 180.6,58.94 U4555.CR30
  BOTTOM w0.119: v1(108.35,36.59) 108.54,36.78 109.51,36.78 110.97,35.31 154.65,35.31 156.2,36.86 184.04,36.86 196.3,49.12 196.3,54.79 193.31,57.78 192.37,57.78 192.09,58.06 189.72,58.06 189.41,58.37 186.18,58.37 186.14,58.37 186.08,58.37 ; v1(74.71,24.89) 74.57,24.89 74.25,24.58 74.25,24.09 73.83,23.66 73.83,23.46 R1329.2
WR_LANE0_DP: length 165.5
  L3 w0.109: v1(108.35,37.2) 108.15,37 107.43,37 107.21,36.78 96.01,36.78 92.59,33.36 84.2,33.36 83.97,33.12 83.97,31.66 77.79,25.49 77.64,25.49 77.53,25.6 77.53,25.75 78.96,27.18 78.96,27.51 78.72,27.74 78.39,27.74 77.19,26.54 74.48,26.54 74.25,26.31 74.25,25.16 v1(74,24.92)
  BOTTOM w0.076: 186.08,58.15 186.06,58.15 186.03,58.18 185.3,58.18 185.18,58.06 182.72,58.06 182.25,58.53 180.98,58.53 180.98,58.53 180.84,58.53 180.69,58.67 180.3,58.67 U4555.CP30
  BOTTOM w0.119: v1(108.35,37.2) 108.56,37 109.6,37 111.06,35.53 154.56,35.53 156.11,37.08 183.95,37.08 196.08,49.21 196.08,54.7 193.22,57.56 192.28,57.56 192,57.84 v4(190.5,57.84) 189.63,57.84 189.32,58.15 186.18,58.15 186.14,58.15 186.08,58.15 ; v1(74,24.92) 74.03,24.89 74.03,24.18 73.61,23.76 73.61,23.43 R1328.2
WR_LANE1_C_DN: length 7
  BOTTOM w0.119: R1335.1 75.26,22.74 75.26,21.59 73.63,19.96 72.52,19.96 72.42,19.85 72.42,19.28 71.89,18.75 CN1300.9
WR_LANE1_C_DP: length 7
  BOTTOM w0.119: CN1300.11 72.08,19.25 72.19,19.37 72.19,19.95 72.43,20.18 73.54,20.18 74.02,20.66 74.02,20.86 74.13,20.98 74.33,20.98 74.57,21.22 74.57,21.39 74.69,21.51 74.87,21.51 75.04,21.68 75.04,21.91 74.93,22.02 74.93,22.18 75.04,22.29 75.04,22.42 74.7,22.75 R1334.1
WR_LANE1_DN: length 163.4
  L3 w0.109: v1(107.03,35.96) 107.26,35.73 107.26,35.38 107.15,35.27 106.04,35.27 105.18,36.13 96.14,36.13 92.81,32.81 85.33,32.81 84.52,32 84.52,31.43 77.3,24.22 75.93,24.22 75.82,24.33 75.82,24.68 v1(76.04,24.91)
  BOTTOM w0.076: U4555.CM30 178.81,59.2 179.45,59.2 179.57,59.32 179.77,59.32 179.96,59.28 180.14,59.28 180.27,59.35 180.31,59.37 180.67,59.37 180.71,59.33 180.9,59.33 181.08,59.15 183.17,59.15 183.41,58.91 186.04,58.91 186.07,58.94 186.08,58.94
  BOTTOM w0.119: v1(76.04,24.91) 75.83,24.7 75.83,24.38 75.26,23.81 75.26,23.26 R1335.2 ; v1(107.03,35.96) 107.29,35.7 107.29,35.36 107.9,34.74 154.89,34.74 156.43,36.29 184.27,36.29 196.87,48.88 196.87,55.03 193.55,58.35 192.61,58.35 192.33,58.63 189.96,58.63 189.65,58.94 v4(186.99,58.94) 186.08,58.94
WR_LANE1_DP: length 163.4
  L3 w0.109: v1(107.69,35.96) 107.47,35.73 107.47,35.29 107.24,35.06 105.95,35.06 105.09,35.92 96.23,35.92 92.9,32.6 85.42,32.6 84.73,31.91 84.73,31.35 77.39,24.01 75.84,24.01 75.61,24.24 75.61,24.68 v1(75.38,24.91)
  BOTTOM w0.076: U4555.CN30 178.99,58.78 178.99,58.66 179.05,58.6 179.18,58.6 179.25,58.52 179.36,58.52 179.47,58.63 179.47,58.99 179.63,59.16 179.75,59.16 179.77,59.14 179.84,59.14 179.94,59.12 180.19,59.12 180.35,59.21 180.6,59.21 180.64,59.16 180.83,59.16 181.01,58.98 183.11,58.98 183.34,58.75 186.03,58.75 186.06,58.72 186.08,58.72
  BOTTOM w0.119: v1(107.69,35.96) 107.51,35.77 107.51,35.45 107.99,34.96 154.8,34.96 156.34,36.51 184.18,36.51 196.65,48.97 196.65,54.94 193.45,58.13 192.51,58.13 192.24,58.41 189.87,58.41 189.55,58.72 186.08,58.72 ; R1334.2 74.69,23.25 75.04,23.59 75.04,23.9 75.61,24.47 75.61,24.68 v1(75.38,24.91)
WT_CLK_C_DN: length 2.5
  BOTTOM w0.119: CN1300.71 71.99,34.25 72.16,34.42 73.12,34.42 R1321.1
WT_CLK_C_DP: length 2.5
  BOTTOM w0.119: CN1300.73 71.94,34.75 72.03,34.66 72.03,34.66 72.06,34.63 72.06,34.64 73.08,34.64 R1320.1
WT_CLK_DN: length 154
  L3 w0.109: v1(75.58,35.24) 75.33,34.99 75.19,34.99 75.07,34.86 75.07,34.46 75.18,34.36 80.69,34.36 81.72,35.38 81.72,35.84 82.85,36.97 93.09,36.97 95.26,39.13 96.93,39.13 97.04,39.24 97.04,40.91 97.28,41.14 97.61,41.14 97.84,40.91 97.84,39.24 97.95,39.13 98.1,39.13 98.21,39.24 98.21,40.99 98.44,41.22 98.77,41.22 99.01,40.99 99.01,39.24 99.12,39.13 99.27,39.13 99.38,39.24 99.38,40.99 99.61,41.22 99.94,41.22 100.17,40.99 100.17,39.57 100.28,39.46 100.44,39.46 100.55,39.57 100.55,41 100.78,41.23 102.54,41.23 103.02,40.75 107.65,40.75 108.02,41.12 v1(108.02,41.27)
  BOTTOM w0.076: U4555.CP34 179.79,56.52 180.13,56.52 180.16,56.52 180.22,56.52 180.34,56.58 180.94,56.58 181.03,56.49 181.03,56.33 181.11,56.26 181.26,56.26 182.72,54.8 183.65,54.8 183.68,54.77 183.7,54.77
  BOTTOM w0.119: 183.7,54.77 185.4,54.77 185.52,54.65 185.52,51.56 188.31,48.77 188.31,44.66 183,39.36 155.16,39.36 153.62,37.81 112.15,37.81 108.94,41.01 108.28,41.01 v1(108.02,41.27) ; R1321.2 73.8,34.35 74.06,34.61 74.53,34.61 74.75,34.83 75.03,34.83 75.44,35.24 v1(75.58,35.24)
WT_CLK_DP: length 154
  L3 w0.109: v1(108.02,40.54) 102.93,40.54 102.45,41.02 100.87,41.02 100.76,40.91 100.76,39.48 100.53,39.25 100.2,39.25 99.96,39.48 99.96,40.9 99.85,41.01 99.7,41.01 99.59,40.9 99.59,39.15 99.36,38.92 99.03,38.92 98.8,39.15 98.8,40.9 98.69,41.01 98.53,41.01 98.42,40.9 98.42,39.15 98.19,38.92 97.86,38.92 97.63,39.15 97.63,40.82 97.52,40.93 97.36,40.93 97.25,40.82 97.25,39.15 97.02,38.92 95.34,38.92 93.18,36.76 82.93,36.76 81.93,35.75 81.93,35.3 80.78,34.14 75.09,34.14 74.86,34.38 v2(74.86,35.24)
  BOTTOM w0.076: 183.7,54.99 183.68,54.99 183.65,54.96 182.79,54.96 181,56.75 180.3,56.75 180.18,56.69 180.13,56.69 179.98,56.69 179.97,56.69 179.84,56.74 179.6,56.74 U4555.CN34
  BOTTOM w0.119: v2(74.86,35.24) 74.44,34.83 73.84,34.83 R1320.2 ; v1(108.02,40.54) 108.27,40.79 108.85,40.79 112.05,37.59 153.71,37.59 155.25,39.13 183.09,39.13 188.53,44.57 188.53,48.86 185.74,51.65 185.74,54.74 185.49,54.99 183.7,54.99
WT_LANE0_C_DN: length 2.5
  BOTTOM w0.119: CN1300.65 71.94,32.75 72.08,32.89 73.12,32.89 R1323.1
WT_LANE0_C_DP: length 2.5
  BOTTOM w0.119: CN1300.67 71.94,33.25 72.08,33.11 73.08,33.11 R1322.1
WT_LANE0_DN: length 155.2
  L3 w0.109: v1(108.53,39.11) 108.5,39.11 108.09,39.52 107.81,39.52 107.37,39.95 101.73,39.95 100.35,38.58 95.48,38.58 93.32,36.42 83.57,36.42 80.96,33.81 76.76,33.81 75.69,32.74 75.41,32.74 75,32.33 v2(74.86,32.33)
  BOTTOM w0.076: 186.05,57.01 186.03,57.01 186,57.04 185.12,57.04 185.01,57.15 182.51,57.15 181.98,57.67 180.89,57.67 180.71,57.71 180.56,57.81 180.54,57.82 180.44,57.82 180.42,57.82 180.42,57.82 179.95,57.82 179.91,57.83 179.9,57.83 179.7,57.81 179.59,57.78 179.5,57.68 179.5,57.62 179.36,57.48 179.24,57.48 179.15,57.56 U4555.CN32
  BOTTOM w0.119: 186.05,57.01 188.85,57.01 189.16,56.7 191.53,56.7 191.81,56.42 192.75,56.42 194.94,54.23 194.94,49.68 183.48,38.22 155.63,38.22 154.09,36.67 111.67,36.67 109.71,38.63 108.42,38.63 108.33,38.72 108.33,38.9 v1(108.53,39.11) ; R1323.2 73.8,32.78 74.15,33.12 75.09,33.12 75.32,32.9 75.32,32.79 v2(74.86,32.33)
WT_LANE0_DP: length 155.2
  L3 w0.109: v1(107.92,39.11) 107.28,39.74 101.81,39.74 100.44,38.37 95.57,38.37 93.41,36.21 83.65,36.21 81.04,33.6 76.85,33.6 v1(75.58,32.33)
  BOTTOM w0.076: U4555.CM32 178.89,57.95 179.18,57.97 179.31,57.98 179.69,57.98 179.9,57.99 179.94,57.99 179.98,57.98 180.4,57.98 180.41,57.98 180.44,57.98 180.5,57.98 180.55,57.98 180.63,57.96 180.77,57.87 180.91,57.84 182.05,57.84 182.58,57.31 185.08,57.31 185.19,57.21 186,57.21 186.03,57.23 186.05,57.23
  BOTTOM w0.119: R1322.2 75.19,33.34 75.54,32.99 75.54,32.37 v1(75.58,32.33) ; v1(107.92,39.11) 108.11,38.92 108.11,38.63 108.33,38.41 109.62,38.41 111.58,36.45 154.18,36.45 155.73,38 183.57,38 195.16,49.59 195.16,54.32 192.84,56.64 191.9,56.64 191.62,56.92 189.25,56.92 188.94,57.23 186.05,57.23
WT_LANE1_C_DN: length 2.5
  BOTTOM w0.119: CN1300.59 71.94,31.25 72.08,31.39 73.1,31.39 R1325.1
WT_LANE1_C_DP: length 2.5
  BOTTOM w0.119: R1324.1 73.1,31.61 72.08,31.61 71.94,31.75 CN1300.61
WT_LANE1_DN: length 154
  L3 w0.109: v1(105.41,39.13) 105.44,39.13 105.81,38.76 105.81,38.56 105.12,37.88 103.8,37.88 103.69,37.99 103.69,38.22 103.46,38.45 103.13,38.45 102.9,38.22 102.9,37.99 102.79,37.88 95.55,37.88 93.55,35.87 83.79,35.87 80.95,33.02 80.47,33.02 79.02,31.57 76.05,31.57 75.69,31.21 75.41,31.21 75,30.8 v2(74.86,30.8)
  BOTTOM w0.076: 183.69,55.32 183.68,55.32 183.65,55.35 182.79,55.35 181.76,56.37 181.63,56.37 181.56,56.45 181.56,56.58 181.43,56.7 181.3,56.7 181.23,56.78 181.23,56.91 181.1,57.03 180.97,57.03 180.89,56.94 180.75,56.94 180.67,57.03 180.51,57.03 180.39,56.91 180.17,56.91 U4555.CP33
  BOTTOM w0.119: 183.69,55.32 187.51,55.32 188.32,56.13 191.29,56.13 191.57,55.85 192.51,55.85 194.37,53.99 194.37,49.92 183.24,38.79 155.4,38.79 153.85,37.24 111.91,37.24 109.41,39.74 107.05,39.74 106.66,39.35 106.38,39.35 106.19,39.55 105.84,39.55 105.43,39.13 v1(105.41,39.13) ; R1325.2 74.09,31.46 74.91,31.46 75.1,31.27 75.1,31.05 v2(74.86,30.8)
WT_LANE1_DP: length 154
  L3 w0.109: v1(106.02,39.13) 106.02,38.48 105.21,37.67 103.71,37.67 103.48,37.9 103.48,38.13 103.37,38.24 103.22,38.24 103.11,38.13 103.11,37.9 102.87,37.67 95.64,37.67 93.63,35.66 83.88,35.66 81.03,32.81 80.56,32.81 79.11,31.36 76.14,31.36 v1(75.58,30.8)
  BOTTOM w0.076: 183.69,55.54 183.68,55.54 183.65,55.51 182.86,55.51 181.17,57.2 180.55,57.2 180.25,57.29 179.98,57.29 U4555.CN33
  BOTTOM w0.119: v1(106.02,39.13) 106.75,39.13 107.14,39.52 109.32,39.52 111.82,37.02 153.94,37.02 155.49,38.57 183.33,38.57 194.59,49.83 194.59,54.09 192.6,56.07 191.66,56.07 191.38,56.35 188.23,56.35 187.42,55.54 183.69,55.54 ; v1(75.58,30.8) 75.33,31.08 75.33,31.36 75,31.68 73.93,31.68 R1324.2
WWAN_ANTCTL0: length 3
  TOP w0.102: TP1411.1 212.01,54.14 212.85,54.14 v1(212.87,54.17)
  BOTTOM w0.102: CN1400.59 213.25,53.94 213.03,54.17 v1(212.87,54.17)
